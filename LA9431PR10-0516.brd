# Allegro board LA9431PR10-0516.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_ALW_PCH on TOP (solid shape): 165.42,66.36 165.42,65.59 165.24,65.42 164.83,65.42 164.52,65.73 164.53,65.75 164.48,65.97 164.32,66.12 164.29,66.14 164.29,66.79 164.38,66.88 164.9,66.88
+3.3V_ALW_PCH on TOP (solid shape): 156.21,55.59 156.21,54.22 156.28,54.14 157.27,54.14 157.36,54.04 157.36,53.48 156.55,52.66 155.45,52.66 155.36,52.71 155.35,52.8 155.03,53.31 154.71,52.8 154.71,52.73 154.66,52.67 153.97,53.36 153.97,55.37 154.28,55.69 156.11,55.69
+3.3V_ALW_PCH on BOTTOM (solid shape): 74.35,52.3 74.35,51.35 74.22,51.22 71.55,51.22 71.43,51.35 71.43,52.17 71.62,52.36 74.28,52.36
+3.3V_ALW_PCH on BOTTOM (solid shape): 160.63,70.49 160.63,69.94 160.5,69.81 158.89,69.81 158.79,69.91 158.79,70.55 158.85,70.61 160.51,70.61
+3.3V_ALW_PCH on BOTTOM (solid shape): 160.26,68.44 160.26,68.26 160.73,67.79 160.73,66.5 160.48,66.24 159.68,66.24 159.5,66.42 159.5,68.43 159.65,68.58 160.12,68.58
+3.3V_ALW_PCH on BOTTOM (solid shape): 206.69,70.04 207.13,70.04 207.13,70.59 207.52,70.59 207.67,70.43 207.67,69.6 208.47,68.8 208.47,67.94 208.32,67.8 207.6,67.8 207.18,68.23 207.18,68.23 207.08,68.33 207.03,68.38 206.28,69.13 206.28,70.47 206.39,70.59 206.69,70.59
+3.3V_ALW_PCH on BOTTOM (solid shape): 156.84,52.62 156.84,51.47 156.52,51.16 155.05,51.16 154.93,51.28 154.93,52.5 154.96,52.57 155.03,52.6 155.24,52.67 155.37,52.86 155.38,52.87 155.47,52.96 156.51,52.96
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 124 points within 167.39,59.03 170.42,66.64
+3.3V_ALW_PCH on IN1 (solid shape): 169.32,60.32 169.32,59.61 169.14,59.44 167.26,59.44 167.13,59.56 167.13,60.3 167.32,60.49 169.15,60.49
+3.3V_ALW_PCH on IN1 (solid shape): outline of 320 points within 158.03,64.79 169.53,70.29
+3.3V_ALW_PCH on IN1 (solid shape): outline of 504 points within 206.17,65 222.61,73.63
+3.3V_ALW_PCH on IN3 (solid shape): 221.88,70.99 221.88,70.29 221.75,70.17 220.37,70.17 220.21,70.33 220.21,71.88 220.36,72.03 220.84,72.03
+3.3V_ALW_PCH on IN3 (solid shape): outline of 122 points within 248.23,5.78 255.34,9
+3.3V_ALW_PCH on IN3 (solid shape): outline of 4867 points within 134.8,46.84 171.61,72.11
+3.3V_ALW_PCH_U43 on BOTTOM (solid shape): 206.57,72.75 207.56,72.75 207.63,72.67 207.63,70.71 207,70.71 207,70.17 206.82,70.17 206.82,70.71 206.43,70.71 205.07,72.07 204.46,72.07 204.37,72.16 204.37,72.88 204.67,73.19 206.12,73.19
+3.3V_ALW_U37 on TOP (solid shape): 32.42,28.69 32.42,28.09 32.96,28.09 32.98,28.07 32.98,27.89 32.96,27.86 32.42,27.86 32.42,27.46 32.37,27.41 32.15,27.41 31.77,27.79 30.66,27.79 30.53,27.91 30.53,28.55 30.66,28.68 30.86,28.68 31.04,28.85 32.26,28.85
+3.3V_ALW_U37 on BOTTOM (solid shape): 20.12,41.93 20.12,41.54 20.09,41.47 20.02,41.44 19.69,41.2 19.79,40.82 19.81,40.8 19.81,40.74 19.74,40.66 19.3,40.66 19.3,40.79 19.24,40.79 19.16,40.84 19.15,40.94 18.91,41.45 18.48,41.08 18.43,41.07 18.38,41.06 18.17,41.06 18.07,41.13 17.95,41.17 17.93,41.19 17.93,42.01 18.03,42.11 18.33,42.11 18.41,42.19 19.86,42.19
+3.3V_ALW_U37 on IN2 (solid shape): outline of 887 points within 11.99,29.82 24.67,36.6
+3.3V_ALW_U37 on IN3 (solid shape): 19.16,30.5 19.18,30.44 19.2,30.38 19.2,30.33 19.46,30.07 21.01,30.07 21.13,29.95 21.14,29.95 21.26,29.82 23.52,29.82 23.77,30.07 24,30.07 24.28,30.35 27.66,30.35 27.79,30.23 27.79,29.46 27.57,29.25 27.09,29.25 26.84,28.99 25.07,28.99 24.87,28.8 24.84,28.78 24.58,28.84 24.38,28.74 21.01,28.74 20.82,28.93 18.62,28.93 18.21,29.34 18.21,30.86 18.26,30.91 18.75,30.91
+3.3V_ALW_U37 on IN3 (solid shape): outline of 790 points within 10.5,32.44 19.86,41.52
+3.3V_ALW_U37 on IN4 (solid shape): 30.35,29.97 30.35,29.95 30.65,29.62 31.04,29.84 31.06,29.86 31.09,29.87 31.42,29.87 31.56,29.73 31.57,29.71 31.58,29.69 31.58,29.56 31.62,29.45 31.62,27.86 31.61,27.82 31.57,27.81 29.76,27.81 29.57,28 27.95,28 27.86,28.05 27.85,28.14 27.53,28.65 27.21,28.14 27.2,28.05 27.12,28 26.92,28 26.89,28.01 26.87,28.05 26.87,29.79 26.91,29.83 28.21,29.83 28.38,30 30.32,30
+3.3V_ALW_U38 on TOP (solid shape): 10.59,14.33 10.59,13.18 10.54,13.13 10.14,13.13 10.14,12.6 10.11,12.57 9.96,12.57 9.92,12.59 9.9,12.62 9.9,13.13 9.5,13.13 9.32,13.31 9.32,14.45 9.51,14.64 10.27,14.64
+3.3V_ALW_U38 on BOTTOM (solid shape): outline of 256 points within 31.29,16.23 35.48,22.27
+3.3V_ALW_U38 on BOTTOM (solid shape): outline of 907 points within 9.45,13.25 23.93,23.6
+3.3V_ALW_U38 on IN2 (solid shape): outline of 226 points within 31.29,12.16 35.29,16.93
+3.3V_ALW_U38 on IN3 (solid shape): 25.35,23.43 25.35,23.42 30.73,23.42 32.06,22.1 32.06,21.44 31.99,21.37 30.34,21.37 30.02,21.69 30.02,21.95 29.77,22.2 23.55,22.2 23.17,22.58 23.17,23.16 23.48,23.48 25.3,23.48
+3.3V_ALW_U38 on IN3 (solid shape): outline of 199 points within 9.55,13.31 17.65,16.92
+3.3V_ALWP on TOP (solid shape): 200.95,66.05 200.95,63.99 200.62,63.66 196.33,63.66 196.21,63.78 196.21,64.4 196.2,64.4 196.2,64.9 196.21,64.9 196.21,65.6 196.2,65.6 196.2,66.1 196.21,66.1 196.21,66.85 196.33,66.97 200.03,66.97
+3.3V_ALWP on BOTTOM (solid shape): 200.11,68.39 200.11,66.85 200.86,66.11 200.86,62.46 200.41,62.01 197.16,62.01 196.9,62.27 196.9,62.9 196.39,63.41 195.71,63.41 195.38,63.73 195.38,67.81 196.56,68.98 196.56,69.2 196.8,69.44 199.06,69.44
+3.3V_CAM on TOP (solid shape): 67.55,77.83 67.55,76.43 67.36,76.24 66.35,76.24 66.03,76.56 66.03,77.83 66.22,78.02 67.36,78.02
+3.3V_CAM on TOP (solid shape): 57.52,77.18 57.52,76.59 57.04,76.11 55.23,76.11 55.11,76.24 55.11,77.38 55.3,77.57 57.13,77.57
+3.3V_CAM on TOP (solid shape): 96.38,95.66 96.38,93.52 95.23,92.37 94.31,92.37 94.22,92.46 94.22,92.78 94.74,92.78 94.74,93.22 94.22,93.22 94.22,95.22 93.97,95.48 93.21,95.48 92.95,95.73 92.95,96.88 93.08,97 95.03,97
+3.3V_CAM on BOTTOM (solid shape): 67.42,77.83 67.42,77.57 66.76,76.9 66.5,76.9 66.03,77.38 66.03,77.7 66.47,78.14 67.11,78.14
+3.3V_CAM on IN1 (solid shape): 56.31,78.14 56.31,76.49 55.99,76.17 55.23,76.17 54.98,76.43 54.98,78.14 55.17,78.33 56.12,78.33
+3.3V_CAM on IN1 (solid shape): 94.41,96.81 94.41,95.35 94.28,95.21 93.09,95.21 93.02,95.29 93.02,96.81 93.14,96.94 94.29,96.94
+3.3V_CAM_Q on TOP (solid shape): 94.03,95.03 94.03,92.53 93.98,92.48 93.57,92.48 93.1,92.95 91.83,92.95 90.98,93.8 90.98,94.72 91.43,95.16 93.9,95.16
+3.3V_HDD on TOP (solid shape): 200.36,31.24 200.36,30.21 199.81,30.21 199.81,29.72 200.36,29.72 200.36,29.34 200.31,29.28 198.84,29.28 198.72,29.41 198.72,31.21 198.97,31.47 200.13,31.47
+3.3V_HDD on BOTTOM (solid shape): outline of 275 points within 38.94,18.77 46.03,31.91
+3.3V_HDD on BOTTOM (solid shape): outline of 380 points within 38.98,6.07 50.7,18.69
+3.3V_HDD on IN2 (solid shape): outline of 255 points within 40.61,16.76 46.96,21.51
+3.3V_HDD on IN3 (solid shape): outline of 11406 points within 40.98,17.58 200.05,33.47
+3.3V_HDD_U3 on TOP (solid shape): 201.3,30.36 201.3,29.35 201.55,29.1 202.35,29.1 202.46,28.99 202.46,26.6 202.41,26.56 201.41,26.56 200.84,27.13 200.84,28.61 200.53,28.92 200.53,30.45 200.57,30.49 201.17,30.49
+3.3V_LAN on TOP (solid shape): 241.91,83.06 241.91,81.46 241.81,81.36 240.79,81.36 239.57,82.57 239.57,84.61 239.75,84.78 240.18,84.78
+3.3V_LAN on TOP (solid shape): 245.76,76.56 246.24,76.56 246.3,76.49 246.3,74.79 246.16,74.65 245.5,74.65 243.52,76.62 243.52,77.5 243.66,77.63 244.68,77.63
+3.3V_LAN on TOP (solid shape): 261.23,84.26 261.23,82.97 260.97,82.71 259.26,82.71 259.13,82.84 259.13,84.23 259.44,84.53 260.96,84.53
+3.3V_LAN on TOP (solid shape): 201.76,42.71 201.76,42.39 201.2,42.39 201.2,41.89 201.76,41.89 201.76,41.42 201.6,41.26 199.71,41.26 199.42,41.56 199.42,42.64 199.58,42.8 201.68,42.8
+3.3V_LAN on TOP (solid shape): 261.31,75.16 261.31,74.43 260.4,73.52 259.82,73.52 259.51,73.21 258.95,73.21 258.88,73.28 258.88,74.71 258.92,74.75 259.63,74.75 260.15,75.27 261.2,75.27
+3.3V_LAN on TOP (solid shape): outline of 733 points within 222.49,95.86 246.76,105.64
+3.3V_LAN on BOTTOM (solid shape): 200.93,42.52 200.93,41.62 200.79,41.49 198.49,41.49 198.27,41.7 198.27,42.33 198.62,42.67 200.78,42.67
+3.3V_LAN on BOTTOM (solid shape): 180.44,62.08 180.44,61.19 180.26,61.01 178.51,61.01 178.38,61.14 178.38,62.23 178.44,62.28 180.24,62.28
+3.3V_LAN on BOTTOM (solid shape): 246.72,99.98 246.72,99.3 244.33,96.91 239.91,96.91 239.4,97.42 239.4,97.74 242.28,100.62 246.08,100.62
+3.3V_LAN on BOTTOM (solid shape): 241.03,86.52 241.03,82.27 240.91,82.14 239.51,82.14 239.27,82.38 239.27,86.6 239.57,86.91 240.65,86.91
+3.3V_LAN on BOTTOM (solid shape): 259.55,75.41 259.56,75.39 259.6,75.35 259.65,75.32 259.7,75.3 259.75,75.28 259.8,75.27 259.86,75.27 259.91,75.28 259.96,75.3 260.01,75.32 260.06,75.35 260.1,75.39 260.11,75.41 260.32,75.41 260.5,75.23 261.14,75.23 261.23,75.15 261.23,74.03 261.04,73.84 255.19,73.84 254.69,74.35 254.69,74.83 256.7,74.83 256.7,74.78 256.71,74.73 256.73,74.68 256.75,74.63 256.78,74.59 256.81,74.55 256.86,74.51 256.9,74.49 256.95,74.47 257,74.46 257.06,74.45 257.11,74.46 257.16,74.47 257.21,74.49 257.26,74.51 257.3,74.55 257.34,74.59 257.37,74.63 257.39,74.68 257.4,74.73 257.41,74.78 257.41,74.83 257.4,74.89 257.39,74.94 257.37,74.99 257.34,75.03 257.3,75.07 257.26,75.1 257.21,75.13 257.16,75.15 257.11,75.16 257.06,75.16 257,75.16 256.95,75.15 256.9,75.13 256.86,75.1 256.81,75.07 256.78,75.03 256.75,74.99 256.73,74.94 256.71,74.89 256.7,74.83 254.69,74.83 254.69,75.23 254.86,75.41
+3.3V_LAN on IN1 (solid shape): 262.18,84.07 262.18,82.89 262.17,82.89 262.17,82.62 261.99,82.43 259.68,82.43 259.32,82.8 259.32,84.26 259.39,84.33 261.93,84.33
+3.3V_LAN on IN1 (solid shape): 262.53,75.9 262.53,75.33 262.5,75.25 262.42,75.23 262.21,75.18 262.06,75.02 261.91,75.02 261.91,75.03 261.59,74.95 261.47,74.66 261.47,74.63 261.08,74.25 260.21,74.25 260.09,74.37 260.09,75.3 260.71,75.92 260.75,75.91 261,75.9 261.2,76.07 261.21,76.1 262.33,76.1
+3.3V_LAN on IN3 (solid shape): 180.45,62.76 180.45,61.25 180.23,61.02 179.26,61.02 179.07,61.21 179.07,63.02 179.12,63.07 180.15,63.07
+3.3V_LAN on IN3 (solid shape): outline of 105 points within 234.21,82.58 240.49,84.93
+3.3V_LAN on IN3 (solid shape): outline of 803 points within 222.7,95.64 231.85,105.29
+3.3V_LAN on IN4 (solid shape): 246.81,100.03 246.81,99.38 244.61,97.18 239.53,97.18 239.28,97.43 239.28,99.92 239.87,100.51 246.33,100.51
+3.3V_LAN_OUT on TOP (solid shape): 257.27,77.21 257.27,76.86 256.84,76.43 255,76.43 254.94,76.49 254.94,77.06 255,77.13 256.28,77.13 256.61,77.46 257.01,77.46
+3.3V_LAN_OUT on TOP (solid shape): 259.21,82.18 260.21,82.18 260.29,82.1 260.29,81.53 260.2,81.44 257.99,81.44 257.8,81.64 257.35,81.64 257.23,81.51 257.23,81 257.04,80.81 256.21,80.81 256.05,80.97 256.05,81.57 256.88,82.4 258.99,82.4
+3.3V_LAN_OUT on BOTTOM (solid shape): outline of 359 points within 248.37,76.31 258.08,81.95
+3.3V_LAN_U22 on TOP (solid shape): 203.19,42.58 203.19,38.76 203.13,38.71 201.94,38.71 201.92,38.73 201.92,40.8 201.92,42.68 202.02,42.78 202.99,42.78
+3.3V_M on TOP (solid shape): 191.06,37.33 191.06,35.84 190.98,35.76 190.68,35.76 190.68,36.32 190.19,36.32 190.19,35.76 188.97,35.76 188.6,36.12 188.6,37.33 188.8,37.52 190.86,37.52
+3.3V_M on TOP (solid shape): 175.13,75.93 175.13,68.82 174.91,68.6 173.61,68.6 173.48,68.73 173.48,69.98 173.75,70.24 173.75,71.57 173.95,71.77 173.95,76.02 174.19,76.26 174.79,76.26
+3.3V_M on BOTTOM (solid shape): 177.28,84.3 177.72,84.3 177.85,84.18 177.85,83.35 177.66,83.16 176.78,83.16 175.31,84.63 175.31,85.06 176.52,85.06
+3.3V_M on BOTTOM (solid shape): 174.09,76.87 174.09,76.52 174.36,76.24 174.72,76.24 174.8,76.16 174.8,74.89 174.62,74.71 174.62,74.1 174.26,73.75 174,73.75 173.95,73.8 173.95,74.74 173.1,75.59 173.1,77.24 173.16,77.3 173.66,77.3
+3.3V_M on BOTTOM (solid shape): 175.13,68.32 175.28,68.32 175.29,68.31 176.5,68.31 176.71,68.11 176.71,67.15 175.75,66.19 175.75,65.19 175.63,65.06 174.93,65.06 174.33,65.66 174.33,66.87 173.73,67.47 173.73,68.27 173.47,68.54 173.47,68.99 173.6,69.11 174.33,69.11
+3.3V_M on IN2 (solid shape): 189.6,37.09 189.6,36.5 189.43,36.33 188.13,36.33 187.61,36.85 187.61,37.44 187.88,37.71 188.98,37.71
+3.3V_M on IN2 (solid shape): outline of 187 points within 173.47,56.88 177.46,69.17
+3.3V_M on IN3 (solid shape): outline of 664 points within 162.13,81.5 177.47,86.78
+3.3V_M_U45 on TOP (solid shape): 190.92,35.55 190.92,35.01 191.82,34.1 191.82,33.63 191.76,33.57 190.42,33.57 189.92,34.07 188.46,34.07 188.4,34.14 188.4,35.43 188.56,35.6 190.87,35.6
+3.3V_MSATA_WWAN on TOP (solid shape): 203.35,34.94 203.35,33.97 203.08,33.7 202.29,33.7 201.94,34.05 199.48,34.05 199.43,34.11 199.43,34.98 199.47,35.02 199.75,35.02 199.75,34.46 200.25,34.46 200.25,35.02 202.29,35.02 202.35,35.08 203.21,35.08
+3.3V_MSATA_WWAN on TOP (solid shape): 208.01,66.71 208.01,65.57 208.2,65.38 209.19,65.38 209.51,65.06 209.51,64.12 209.21,63.82 207.93,63.82 207.54,63.43 207.54,61.93 207.07,61.47 205.75,61.47 205.61,61.6 205.61,63.69 205.31,64 205.31,64.82 205.45,64.96 206.72,64.96 207.12,65.37 207.12,66.71 207.19,66.78 207.95,66.78
+3.3V_MSATA_WWAN on TOP (solid shape): 207.19,44.21 207.19,43.56 206.74,43.11 206.74,42.58 207,42.33 207.22,42.33 208.3,41.25 209.16,41.25 209.28,41.12 209.28,39 209.05,38.77 207.76,38.77 207.54,38.99 207.54,41.05 206.87,41.72 206.5,41.72 206.26,41.96 206.26,43 205.6,43.66 205.6,44.18 205.71,44.29 207.12,44.29
+3.3V_MSATA_WWAN on BOTTOM (solid shape): 204.6,63.25 204.83,63.04 205.13,63.09 205.47,62.99 205.73,63.24 205.74,63.28 205.95,63.28 206.08,63.14 206.26,63.09 206.33,63.06 206.36,62.99 206.36,61.77 206.15,61.56 205.64,61.56 205.51,61.42 205.51,60.21 205.51,60.19 205.75,59.9 206.12,59.98 206.13,60 206.21,60 206.22,59.99 207.64,59.99 207.77,59.87 207.77,58.85 207.65,58.72 206.92,58.72 206.77,58.57 206.7,58.54 206.63,58.57 206.23,58.64 206.02,58.31 205.99,58.24 205.92,58.21 202.76,58.21 202.68,58.28 202.68,62.66 203.3,63.28 204.59,63.28
+3.3V_MSATA_WWAN on IN4 (solid shape): outline of 951 points within 202.4,33.92 209.37,65.07
+3.3V_MSATA_WWAN_U22 on TOP (solid shape): 202.78,36.43 202.36,36.01 202.36,35.33 202.22,35.19 199.47,35.19 199.44,35.22 199.44,35.93 199.56,36.06 201.21,36.06 201.85,36.7 201.85,37.19 202,37.33 202.78,37.33
+3.3V_RUN on TOP (solid shape): 167.4,79.26 167.4,77.19 167.2,76.99 166.54,76.99 166.46,77.06 166.46,79.35 166.56,79.45 167.21,79.45
+3.3V_RUN on TOP (solid shape): 183.03,74.02 183.03,72.39 182.86,72.21 181.81,72.21 180.96,73.06 180.96,74.24 181.08,74.36 182.7,74.36
+3.3V_RUN on TOP (solid shape): 245.67,74.08 245.67,72.17 245.54,72.05 243.83,72.05 243.74,72.14 243.74,73.88 243.98,74.12 245.63,74.12
+3.3V_RUN on TOP (solid shape): 160.71,75.54 160.71,72.07 159.27,70.64 158.48,70.64 158.37,70.75 158.37,75.37 158.6,75.6 160.64,75.6
+3.3V_RUN on TOP (solid shape): 31.72,33.9 31.72,31.77 31.61,31.66 29.2,31.66 29.13,31.72 29.13,34.01 29.26,34.14 31.48,34.14
+3.3V_RUN on TOP (solid shape): 187.55,71.75 187.55,71.34 186.99,71.34 186.99,70.85 187.55,70.85 187.55,70.58 187.5,70.53 185.84,70.53 185.65,70.72 185.65,71.83 185.75,71.93 187.38,71.93
+3.3V_RUN on TOP (solid shape): 252.92,11.09 252.92,10.59 253.13,10.38 253.13,9.93 252.72,9.53 252.24,9.53 252.05,9.71 252.05,11.09 252.14,11.18 252.83,11.18
+3.3V_RUN on TOP (solid shape): 255.8,25.93 255.8,24.73 256.3,24.23 256.3,22.55 256.24,22.49 256.12,22.49 256.07,22.54 256.07,23.68 255.14,24.61 255.14,25.93 255.24,26.03 255.7,26.03
+3.3V_RUN on TOP (solid shape): 88.89,94.69 89.69,94.69 90.53,93.85 90.53,93.19 90.18,92.85 88.35,92.85 88.04,92.53 87.72,92.53 87.52,92.74 87.52,93.52 87.73,93.73 87.73,94.93 88.65,94.93
+3.3V_RUN on TOP (solid shape): 44.58,28.14 44.58,27.08 44.45,26.95 43.41,26.95 43.28,27.08 43.28,28.07 43.43,28.22 43.74,28.22 43.76,28.19 43.76,27.74 43.82,27.69 44.17,27.69 44.22,27.74 44.22,28.22 44.25,28.24 44.48,28.24
+3.3V_RUN on TOP (solid shape): 184.08,79.34 184.11,79.27 184.14,79.22 184.14,78.59 184.01,78.46 183.57,78.46 183.44,78.33 183.44,77.57 182.8,76.94 182.04,76.94 181.98,77 181.98,78.84 182.8,79.67 183.76,79.67
+3.3V_RUN on TOP (solid shape): 198.36,10.39 198.36,8.99 198.32,8.95 198.08,8.95 198.07,8.96 198.07,9.51 197.64,9.51 197.64,8.96 197.63,8.95 197.23,8.95 197.2,8.93 196.43,8.93 196.22,9.14 196.22,10.49 196.27,10.54 198.21,10.54
+3.3V_RUN on TOP (solid shape): 255.39,18.19 255.39,18.02 255.35,17.98 254.44,17.98 254.15,17.69 252.4,17.69 252.27,17.56 251.57,17.56 251.45,17.69 251.45,18.2 251.49,18.24 255.33,18.24
+3.3V_RUN on TOP (solid shape): 188.14,8.36 188.14,7.8 189.47,6.46 189.47,5.54 189.38,5.45 189.15,5.45 189.06,5.54 189.06,6.49 188.84,6.72 188.19,6.72 187.44,7.47 187.44,8.36 187.5,8.42 188.07,8.42
+3.3V_RUN on TOP (solid shape): 252.7,27.05 252.7,24.84 255.4,22.15 255.4,22.03 255.33,21.97 254.44,21.97 254.1,22.31 253.16,22.31 253,22.15 252.45,22.15 252.37,22.22 252.37,22.64 251.36,23.66 251.36,26.96 251.61,27.22 252.54,27.22
+3.3V_RUN on TOP (solid shape): 87.91,82.27 87.91,81.69 86.79,80.57 85.93,80.57 85.33,79.97 85.26,79.94 85.19,79.97 84.77,80.06 84.53,79.7 84.53,79.11 84.76,78.89 84.76,76.91 85.27,76.4 85.27,75.13 85.19,75.06 84.1,75.06 83.44,75.72 83.44,76.81 83.48,76.9 83.57,76.91 84.03,77.25 83.57,77.59 83.48,77.61 83.44,77.69 83.44,79.85 83.65,80.06 83.72,80.35 83.72,80.37 86.18,82.83 87.35,82.83
+3.3V_RUN on BOTTOM (solid shape): 167.49,79.17 167.49,76.99 167.4,76.9 166.62,76.9 166.47,77.05 166.47,79.41 166.52,79.46 167.2,79.46
+3.3V_RUN on BOTTOM (solid shape): 195.83,71.73 195.83,71.05 195.6,70.82 195.6,70.36 195.47,70.23 194.01,70.23 193.85,70.39 193.85,71.34 194.31,71.81 195.76,71.81
+3.3V_RUN on BOTTOM (solid shape): 104.8,97.21 104.8,94.54 104.52,94.26 103.33,94.26 103.2,94.39 103.2,95.42 103.2,95.76 103.28,95.83 103.73,95.83 103.76,95.86 103.76,96.24 103.73,96.27 103.25,96.27 103.2,96.32 103.2,97.18 103.43,97.41 104.6,97.41
+3.3V_RUN on IN1 (solid shape): outline of 266 points within 191.82,86.95 202.57,91.43
+3.3V_RUN on IN2 (solid shape): 104.7,97.94 104.7,96.85 104.47,96.62 100.58,96.62 100.25,96.95 100.25,97.79 100.53,98.07 104.57,98.07
+3.3V_RUN on IN2 (solid shape): 91.29,93.83 91.29,93.07 91.03,92.81 88.93,92.81 88.65,92.53 87.71,92.53 87.55,92.68 87.55,93.55 88.03,94.03 91.08,94.03
+3.3V_RUN on IN2 (solid shape): outline of 159 points within 159.25,72.01 163.37,79.1
+3.3V_RUN on IN3 (solid shape): outline of 576 points within 141.22,71.98 147.37,77.57
+3.3V_RUN on VCC: outline of 958 points within 105.52,1.22 283.08,111.98
+3.3V_RUN_AIN on TOP (solid shape): 254.85,12.3 254.85,10.54 254.66,10.35 253.43,10.35 253.08,10.7 253.08,12.23 253.43,12.58 254.58,12.58
+3.3V_RUN_AIN on IN2 (solid shape): 255.83,15.88 255.83,11.49 255.25,10.91 254.24,10.91 253.97,11.18 253.97,12.54 254.51,13.08 254.51,15.76 254.84,16.08 255.63,16.08
+3.3V_RUN_AUDIO on TOP (solid shape): 265.64,31.64 265.64,30.57 266.09,30.11 267.11,30.11 267.18,30.03 267.18,29.37 267.12,29.31 265.75,29.31 264.35,30.71 262.05,30.71 261.93,30.84 261.93,31.6 262.12,31.79 265.49,31.79
+3.3V_RUN_AUDIO on TOP (solid shape): 267.95,15.44 268.44,15.44 268.44,16 269.19,16 269.47,15.72 270.08,15.72 270.17,15.63 270.17,14.71 270.09,14.64 269.39,14.64 269.31,14.72 267.76,14.72 267.57,14.91 267.57,15.92 267.66,16 267.95,16
+3.3V_RUN_AUDIO on IN3 (solid shape): outline of 617 points within 263.63,14.74 269.52,32.27
+3.3V_RUN_AUDIO_U18 on TOP (solid shape): 270.32,17.47 270.32,16.09 270.19,15.96 269.51,15.96 269.31,16.15 267.69,16.15 267.65,16.2 267.65,16.53 268.61,17.5 268.61,18.03 268.67,18.08 269.71,18.08
+3.3V_RUN_CARD on TOP (solid shape): 250.86,19.66 253.05,19.66 253.98,18.73 254.37,18.73 254.44,18.66 255.32,18.66 255.4,18.58 255.4,18.4 255.38,18.38 250.93,18.38 250.79,18.53 250.04,18.53 249.76,18.25 249.76,17.89 249.51,17.65 249.04,17.65 248.89,17.79 248.89,20.55 249.02,20.68 249.85,20.68
+3.3V_RUN_CARD on BOTTOM (solid shape): 251.1,19.53 251.1,18.77 250.93,18.59 250.2,18.59 249.52,19.28 248.86,19.28 248.65,19.48 248.65,20.14 248.86,20.34 250.29,20.34
+3.3V_RUN_TPM on TOP (solid shape): 38.09,31.41 38.09,29.82 38.28,29.63 41.25,29.63 41.32,29.6 41.35,29.52 41.59,29.17 42,29.3 42.02,29.32 42.06,29.34 42.23,29.21 42.43,29.21 42.66,29.31 42.76,29.53 42.79,29.6 42.86,29.63 44.44,29.63 44.6,29.46 44.6,28.45 44.53,28.37 44.19,28.37 44.18,28.36 43.42,28.36 43.41,28.35 43.37,28.35 43.37,28.33 43.2,28.17 42.82,28.17 42.65,28.21 42.48,28.17 40.63,28.17 40.44,28.36 37.27,28.36 37.19,28.45 37.19,29.55 37.45,29.82 37.45,29.84 37.47,29.86 37.56,29.97 37.59,30.11 37.59,31.35 37.58,31.43 37.55,31.51 37.53,31.55 37.58,31.6 37.9,31.6
+3.3V_RUN_TPM on BOTTOM (solid shape): outline of 156 points within 35.61,36.61 41.77,40.17
+3.3V_RUN_TPM on IN1 (solid shape): 37.01,38.26 37.01,38.13 37,38.1 36.97,38.08 36.73,37.74 36.97,37.4 37,37.38 37.01,37.36 37.01,32.99 36.56,32.55 36.56,32.11 36.69,31.98 36.7,31.96 36.78,31.83 36.92,31.74 36.93,31.74 38.47,30.2 38.47,27.66 38.28,27.47 37.55,27.47 37.46,27.52 37.45,27.62 37.14,28.13 36.82,27.62 36.81,27.52 36.72,27.47 36.69,27.47 35.87,28.29 35.85,28.39 35.92,28.46 36.18,28.71 36.08,29.07 36.05,29.13 36.07,29.21 36.08,29.22 36.12,29.23 36.16,29.22 36.79,29.42 36.19,29.69 36.12,29.67 36.05,29.69 35.93,29.77 35.78,29.79 35.71,29.82 35.67,29.9 35.67,30.45 34.85,31.28 34.85,33.83 34.9,33.92 35.01,33.92 35.56,34.21 35.01,34.51 34.9,34.5 34.85,34.59 34.85,35.85 35.1,36.11 35.1,38.52 35.29,38.71 36.56,38.71
+3.3V_RUN_U46 on TOP (solid shape): 189.95,71.45 189.95,69.07 189.55,68.67 189.55,68.19 189.44,68.07 188.98,68.07 188.87,68.17 188.87,69.47 188.87,69.47 188.78,69.75 188.5,69.86 188.3,70.07 188.07,70.07 187.71,70.43 187.71,71.7 187.77,71.76 189.64,71.76
+3.3V_RUN_VDDA on BOTTOM (solid shape): 199.19,86.59 199.19,85.38 199.12,85.32 198.43,85.32 198.11,85 198.11,84.56 198.04,84.49 197.54,84.49 197.35,84.68 197.35,86.52 197.47,86.65 199.12,86.65
+3.3V_RUN_VDDA on BOTTOM (solid shape): 198.58,81.43 198.57,81.22 198.58,81 198.73,80.85 199.14,80.85 199.95,80.85 200.05,80.75 200.05,80.25 199.94,80.14 199.26,80.14 199.06,80.34 198.05,80.34 197.97,80.38 197.96,80.47 197.97,80.62 197.92,80.76 197.89,80.8 197.99,80.9 197.99,81.43 198.04,81.48 198.53,81.48
+3.3V_RUN_VDDA on IN4 (solid shape): outline of 1272 points within 193.52,77.44 200.53,84.99
+3.3V_RUN_VDDIO on TOP (solid shape): 188.95,89.81 190.25,89.81 190.55,89.51 190.55,88.3 190.3,88.05 188.57,88.05 187.68,88.94 187.68,89.76 187.88,89.97 188.8,89.97
+3.3V_RUN_VDDIO on IN1 (solid shape): outline of 702 points within 188.19,76.93 200.77,88.57
+3.3V_RUN_VMM on TOP (solid shape): outline of 238 points within 186.14,87.41 198.95,92.18
+3.3V_RUN_VMM on BOTTOM (solid shape): 196.44,76.47 196.44,75.38 196.32,75.26 195.58,75.26 195.58,75.82 195.07,75.82 195.07,75.26 194.83,75.26 194.83,76.11 195.31,76.59 196.32,76.59
+3.3V_RUN_VMM on IN3 (solid shape): outline of 469 points within 191.25,86.67 201.19,91.14
+3.3V_RUN_VMM_U31 on BOTTOM (solid shape): 195.82,75.03 195.82,74.21 195.81,74.21 195.81,73.13 195.76,73.08 194.69,73.08 194.62,73 193.76,73 193.67,73.09 193.67,73.26 193.67,73.27 193.67,74.07 194.47,74.87 194.47,74.88 194.67,75.08 195.77,75.08
+3.3V_SUS on TOP (solid shape): 187.25,8.46 187.25,7.47 187.95,6.77 187.95,5.55 187.87,5.47 186.65,5.47 186.58,5.55 186.58,6.59 186.44,6.73 185.9,6.73 185.8,6.84 185.8,8.3 186.06,8.56 187.15,8.56
+3.3V_SUS on TOP (solid shape): outline of 464 points within 187,11.72 198.17,29.5
+3.3V_SUS on BOTTOM (solid shape): outline of 542 points within 155.31,99.73 168.14,111.98
+3.3V_SUS on IN2 (solid shape): outline of 509 points within 185.79,6.35 196.49,13.69
+3.3V_SUS_U45 on TOP (solid shape): 191.82,32.14 191.82,31.09 191.27,30.54 190.27,30.54 190,30.27 190,29.73 189.97,29.7 188.77,29.7 188.71,29.76 188.71,30.43 189.26,30.97 189.26,31.68 189.38,31.81 190.15,31.81 190.54,32.19 191.76,32.19
+3.3V_TP on TOP (solid shape): 198.93,8.67 199.76,8.67 199.8,8.64 199.8,7.06 199.63,6.9 199.63,5.88 199.5,5.75 199.31,5.75 199.25,5.82 199.25,6.58 199.23,6.6 199.23,6.63 199.15,6.83 198.94,6.91 198.92,6.91 198.43,7.4 197.41,7.4 197.16,7.66 197.16,8.74 197.22,8.8 198.81,8.8
+3.3V_TP on IN2 (solid shape): 200.27,7.52 200.02,7.27 198.5,7.27 198.25,7.52 198.25,8.43 199.3,9.47 200.27,9.47
+3.3V_TP on IN2 (solid shape): 192.03,20.32 192.13,20.26 192.1,20.15 192,19.86 192.16,19.6 192.21,19.52 192.16,19.43 192.14,19.42 192.05,19.4 191.99,19.47 191.75,19.7 191.42,19.63 191.36,19.6 191.29,19.63 190.71,19.35 191.29,19.08 191.36,19.1 191.42,19.08 191.64,19 191.86,19.07 191.95,19.09 192.02,19.02 192.57,18.85 192.56,19.43 192.51,19.52 192.56,19.6 192.71,19.86 192.61,20.15 192.59,20.26 192.68,20.32 193.14,20.32 193.35,20.26 193.55,20.32 193.57,20.32 193.85,20.04 193.85,17.75 193.65,17.55 190.93,17.55 190.35,18.14 190.35,20.17 190.5,20.32
+3.3V_TSP on TOP (solid shape): 133.97,103.3 140.01,103.3 140.28,103.03 141.41,103.03 141.55,102.88 141.55,101.46 141.52,101.43 141.01,101.43 140.99,101.41 140.99,100.98 141.01,100.96 141.51,100.96 141.55,100.92 141.55,100.27 141.38,100.11 139.52,100.11 139.47,100.15 139.47,101.48 139.07,101.88 132.98,101.88 131.1,103.76 131.1,104.15 131.85,104.9 132.37,104.9
+3.3V_TSP on BOTTOM (solid shape): 72.25,77.14 72.25,75.65 71.83,75.23 70.97,75.23 70.82,75.39 70.94,76.77 70.9,77.01 70.58,77.93 70.58,78.06 70.64,78.12 71.27,78.12
+3.3V_TSP on IN2 (solid shape): 71.62,76.61 71.62,75.3 71.49,75.17 70.2,75.17 70.11,75.26 70.11,76.64 70.24,76.77 71.45,76.77
+3.3V_TSP on IN2 (solid shape): 132.33,104.97 132.33,104.51 131.25,103.43 130.24,103.43 129.84,103.83 129.84,104.67 130.64,105.47 131.83,105.47
+3.3V_TSP_Q on TOP (solid shape): 143.77,103.63 143.77,100.77 143.6,100.6 141.73,100.6 141.69,100.65 141.69,101.08 141.67,101.1 141.14,101.1 141.13,101.11 141.13,101.28 141.14,101.29 141.66,101.29 141.69,101.32 141.69,103.39 142.19,103.89 143.51,103.89
+3.3V_WLAN on TOP (solid shape): 213.54,9.42 213.54,8.99 212.21,7.66 210.34,7.66 209.86,8.15 209.86,8.97 210.4,9.51 213.45,9.51
+3.3V_WLAN on TOP (solid shape): 206.72,41.11 206.72,40.47 207.38,39.82 207.38,38.82 207.22,38.65 206.51,38.65 206.37,38.79 206.37,39.22 206.21,39.38 206.21,41.14 206.27,41.2 206.64,41.2
+3.3V_WLAN on TOP (solid shape): 211.42,27.18 211.42,26.67 211.32,26.57 210.82,26.57 210.55,26.3 207.81,26.3 206.83,25.32 206.83,24.61 206.77,24.55 205.94,24.55 205.9,24.58 205.9,24.86 206.46,24.86 206.46,25.35 205.9,25.35 205.9,26.55 206.32,26.96 207.46,26.96 207.6,26.83 210.34,26.83 210.77,27.26 211.34,27.26
+3.3V_WLAN on BOTTOM (solid shape): 209.46,28.24 209.46,28.21 209.45,28.17 209.45,28.12 209.45,28.07 209.47,28.02 209.49,27.97 209.52,27.92 209.55,27.88 209.59,27.84 209.64,27.81 209.7,27.79 209.75,27.78 209.8,27.77 209.86,27.78 209.91,27.79 209.94,27.8 210.6,27.8 211.04,28.24 211.87,28.24 211.98,28.13 211.98,27.07 211.83,26.92 211,26.92 210.36,26.28 206.9,26.28 206.8,26.37 206.8,27.26 208.92,27.26 208.92,27.2 208.92,27.15 208.94,27.1 208.96,27.05 208.99,27.01 209.03,26.97 209.07,26.94 209.12,26.91 209.17,26.89 209.22,26.88 209.27,26.87 209.32,26.88 209.38,26.89 209.43,26.91 209.47,26.94 209.51,26.97 209.55,27.01 209.58,27.05 209.6,27.1 209.62,27.15 209.63,27.2 209.63,27.26 209.62,27.31 209.6,27.36 209.58,27.41 209.55,27.45 209.51,27.49 209.47,27.52 209.43,27.55 209.38,27.57 209.32,27.58 209.27,27.59 209.22,27.58 209.17,27.57 209.12,27.55 209.07,27.52 209.03,27.49 208.99,27.45 208.96,27.41 208.94,27.36 208.92,27.31 208.92,27.26 206.8,27.26 206.8,27.51 207.53,28.24
+3.3V_WLAN on IN2 (solid shape): outline of 243 points within 204.62,27.6 211.7,39.57
+3.3V_WLAN on IN4 (solid shape): outline of 1500 points within 202.26,5.84 213.63,33.38
+3.3V_WLAN_U3 on TOP (solid shape): 205.73,27.25 205.73,24.62 205.68,24.57 205.39,24.57 204.69,25.27 204.69,26.41 204.56,26.54 203.89,26.54 203.81,26.62 203.81,27.3 203.89,27.38 205.6,27.38
+5V_ALW on TOP (solid shape): 267.34,21.08 267.34,19.53 267.26,19.46 266.57,19.46 266.42,19.61 266.42,20.88 266.83,21.28 267.13,21.28
+5V_ALW on TOP (solid shape): 105.79,104.42 105.79,102.84 105.59,102.64 102.59,102.64 102.51,102.72 102.51,102.97 102.24,103.25 100.84,103.25 100.74,103.35 100.74,104.19 100.91,104.37 102.44,104.37 102.64,104.57 105.64,104.57
+5V_ALW on TOP (solid shape): 236.53,81.33 236.53,79.6 236.98,79.15 236.98,78.08 236.88,77.98 235.43,77.98 235.26,78.15 235.26,80.29 235.23,80.32 235.23,81.33 235.43,81.53 236.32,81.53
+5V_ALW on TOP (solid shape): 122.92,99.15 124.08,99.15 124.24,98.98 124.24,98.49 124.02,98.26 124.02,98.11 123.83,97.92 123.51,97.92 123.04,98.4 122.68,98.4 122.31,98.76 122.31,99.19 122.47,99.35 122.72,99.35
+5V_ALW on TOP (solid shape): 233.6,85.48 233.63,85.48 233.67,85.45 233.67,84.94 233.29,84.56 232.27,84.56 232.08,84.37 232.08,82.65 231.8,82.37 227.72,82.37 227.6,82.5 227.6,83.48 227.69,83.57 229.68,83.57 230.3,84.19 230.3,84.43 229.73,85 229.73,85.45 230.29,86 233.08,86
+5V_ALW on TOP (solid shape): outline of 1091 points within 175.88,63.47 188.29,99.35
+5V_ALW on BOTTOM (solid shape): 268.45,23.8 268.45,23.34 268.76,23.04 268.76,21.67 267.26,20.17 266.83,20.17 266.67,20.32 266.67,22.76 266.99,23.08 267.01,23.07 267.27,23.18 267.37,23.44 267.37,23.46 267.78,23.86 268.39,23.86
+5V_ALW on BOTTOM (solid shape): 232.78,87.79 232.78,85.57 232.85,85.57 232.85,85.55 233.57,85.55 233.73,85.38 233.73,85.19 233.54,85 231.24,85 230.95,84.71 230.95,82.54 230.82,82.41 230.19,82.41 230.02,82.57 230.02,84.77 229.73,85.06 229.73,85.38 229.86,85.51 230.15,85.51 230.91,86.26 230.91,86.62 230.68,86.84 229.22,86.84 229.16,86.91 229.16,87.79 229.22,87.86 230.68,87.86 230.87,88.05 232.52,88.05
+5V_ALW on BOTTOM (solid shape): outline of 484 points within 264.69,30.25 268.88,47.57
+5V_ALW on BOTTOM (solid shape): outline of 843 points within 239.88,71.73 267.46,76.28
+5V_ALW on IN3 (solid shape): outline of 331 points within 235.59,72.49 242.95,78.54
+5V_ALW on VCC: outline of 108 points within 63.17,84.94 233.35,111.98
+5V_ALWP on TOP (solid shape): 184.03,63.34 184.81,63.34 184.81,63.35 185.31,63.35 185.31,63.34 186.01,63.34 186.01,63.35 186.51,63.35 186.51,63.34 187.13,63.34 187.38,63.09 187.38,61.44 186.79,60.86 183.01,60.86 182.84,61.03 182.84,63.16 183.03,63.35 184.03,63.35
+5V_ALWP on BOTTOM (solid shape): 187.77,64.54 188.47,64.54 188.92,64.99 192.82,64.99 192.88,64.93 192.88,61.61 192.52,61.25 186.42,61.25 186.11,61.57 183.69,61.57 182.93,62.33 182.93,63.22 184.07,64.36 184.07,65.7 184.33,65.95 186.36,65.95
+5V_HDMI_DDC on BOTTOM (solid shape): 200.58,98.86 200.58,98.07 200.7,97.95 202.53,97.95 202.64,97.84 202.64,97.31 202.57,97.23 201.7,97.23 201.55,97.08 199.73,97.08 199.26,97.54 199.26,98.73 199.52,98.98 200.46,98.98
+5V_RUN on TOP (solid shape): 186.96,70.17 186.96,69.45 186.85,69.34 185.95,69.34 185.77,69.52 185.27,69.52 185.27,70.09 184.77,70.09 184.77,69.52 184.53,69.52 184.48,69.57 184.48,70.32 184.53,70.38 186.76,70.38
+5V_RUN on TOP (solid shape): 189.28,8.29 189.28,7.66 189.94,7 189.94,5.56 189.85,5.47 189.65,5.47 189.6,5.52 189.6,6.55 188.33,7.82 188.33,8.36 188.39,8.42 189.15,8.42
+5V_RUN on TOP (solid shape): 204.05,8.52 204.05,7.57 203.38,6.9 203.25,6.83 203.18,6.69 203.12,6.64 203.12,5.54 203.06,5.47 202.82,5.47 202.74,5.55 202.74,6.83 202.87,6.96 202.87,8.6 202.96,8.69 203.89,8.69
+5V_RUN_AUDIO on TOP (solid shape): 267.36,41.1 267.36,39.77 267.22,39.62 265.87,39.62 265.75,39.74 265.75,41.1 265.93,41.28 267.18,41.28
+5V_RUN_AUDIO on TOP (solid shape): 271.87,23.06 271.87,20.88 271.64,20.64 271.14,20.64 271.14,21.2 270.65,21.2 270.65,20.64 270.38,20.64 270.34,20.69 270.34,21.24 269.91,21.66 269.91,23.13 270.01,23.23 271.7,23.23
+5V_RUN_AUDIO on IN3 (solid shape): outline of 862 points within 266.29,21.2 272.16,41.54
+5V_RUN_AUDIO_U18 on TOP (solid shape): 270.15,21.13 270.15,20.61 270.28,20.48 270.78,20.48 270.78,20.48 271.4,20.48 271.44,20.45 271.44,19.83 271.26,19.65 269.82,19.65 269.62,19.45 268.68,19.45 268.62,19.51 268.62,20.12 268.57,20.17 268.57,21.49 268.62,21.54 269.74,21.54
+5V_RUN_U46 on TOP (solid shape): 185.93,69.15 187.23,69.15 187.5,68.87 187.5,68.17 187.44,68.11 186.91,68.11 186.6,67.79 185.6,67.79 185.55,67.84 185.39,67.84 185.39,68.12 185.22,68.3 185.22,68.5 185.01,68.5 184.47,69.05 184.47,69.32 184.52,69.37 185.71,69.37
+5V_USB_CHG_PWR on TOP (solid shape): 98.48,104.24 98.48,101.13 98.35,101 96.7,101 96.38,101.32 96.38,104.24 96.51,104.37 98.35,104.37
+5V_USB_CHG_PWR on TOP (solid shape): 76.7,98.17 76.7,97.26 76.53,97.09 76.53,96.14 76.38,95.99 75.87,95.99 74.82,97.04 74.82,98.51 75,98.7 75.02,98.71 75.04,98.71 76.16,98.71
+5V_USB_CHG_PWR on BOTTOM (solid shape): 83.72,97.61 84.16,97.61 84.68,97.09 84.68,95.05 83.72,94.08 82.45,94.08 82.09,94.44 82.09,98.3 82.17,98.37 82.96,98.37
+5V_USB_CHG_PWR on IN4 (solid shape): 98.41,102.21 98.41,100.81 98.16,100.56 96.44,100.56 96.19,100.81 96.19,102.27 96.44,102.53 98.1,102.53
+5V_USB_CHG_PWR on IN4 (solid shape): 77.75,96.65 79.45,96.65 81.12,98.31 83.05,98.31 83.76,97.6 84.23,97.6 84.71,97.12 84.71,96.13 83.73,95.15 83.41,95.15 83.19,94.92 74.65,94.92 74.07,95.5 74.07,98.55 74.45,98.93 75.46,98.93
+GND_CHASSIS on TOP (solid shape): 260.52,93.71 260.52,92.37 260.31,92.16 248.03,92.16 247.73,92.47 247.73,93.62 248.03,93.93 260.3,93.93
+GND_CHASSIS on BOTTOM (solid shape): 260.53,92.57 260.53,91.82 260.32,91.62 259.73,91.62 259.39,91.96 259.39,92.57 259.52,92.71 260.39,92.71
+V1.05S_APLLOPI on TOP (solid shape): outline of 162 points within 147.07,79.58 149.91,83.44
+V1.05S_APLLOPI on IN3 (solid shape): outline of 1163 points within 138.53,71.39 147.69,83.07
+V1.05SP_B+ on TOP (solid shape): 230.94,74.08 230.94,70.36 230.94,70.33 230.81,70.21 224.33,70.21 224.21,70.33 224.21,71.53 224.22,71.57 224.25,71.58 224.72,71.58 224.72,72.09 224.25,72.09 224.22,72.11 224.21,72.14 224.21,72.33 224.22,72.37 224.25,72.38 224.72,72.38 224.72,72.89 224.25,72.89 224.22,72.91 224.21,72.94 224.21,73.32 224.33,73.44 226.17,73.44 226.68,72.94 229.54,72.94 229.73,73.13 229.73,73.95 229.92,74.14 230.87,74.14
+V1.05SP_B+ on BOTTOM (solid shape): 231.29,71.96 231.29,70.38 231.24,70.33 229.39,70.33 229.21,70.51 229.21,71.83 229.39,72.01 231.24,72.01
+VCC_CORE on TOP (solid shape): outline of 5793 points within 93.59,56.11 137.46,83.41
+VCC_CORE on BOTTOM (solid shape): outline of 1100 points within 92.32,57.7 106.86,79.79
+VCC_CORE on BOTTOM (solid shape): outline of 1518 points within 116,68.02 138.84,80.98
+VCC_CORE on IN3 (solid shape): outline of 6077 points within 93.45,57.45 137.68,82.8
+VCC_CORE on VCC: 104.85,66.52 102.67,64.35 101.26,63.67 100.58,62.25 96.94,58.61 93.9,58.61 93.9,80.64 94.9,81.64 137.36,81.64 137.85,81.15 137.85,76.53 136.7,75.39 136.7,68.05 112.93,68.05 112.04,68.94 108.66,68.94 106.24,66.52
+VCC_PWR_SRC on TOP (solid shape): 81.04,63.54 81.04,59.78 80.97,59.7 79.29,59.7 79.15,59.84 79.15,63.53 79.42,63.8 80.78,63.8
+VCC_PWR_SRC on BOTTOM (solid shape): 81.17,66.84 81.17,63.35 81,63.18 81,59.92 82.19,58.72 82.19,56.01 81.94,55.75 75.36,55.75 75.16,55.96 75.16,56.76 75.17,56.79 75.21,56.81 75.66,56.81 75.66,57.51 75.21,57.51 75.17,57.53 75.16,57.56 75.16,57.96 75.17,57.99 75.21,58.01 75.66,58.01 75.66,58.71 75.21,58.71 75.17,58.72 75.16,58.76 75.16,59.31 75.16,59.39 76.15,60.38 76.15,64.44 76.25,64.54 78.74,64.54 78.82,64.62 78.82,66.04 78.89,66.12 79.58,66.12 80.31,66.85 81.16,66.85
+VDDA_PVDD on TOP (solid shape): 267.36,38.84 267.36,38.33 267.53,38.16 267.53,37.93 267.75,37.93 268,37.69 268,34.62 267.85,34.47 267.64,34.47 267.5,34.32 267.3,34.22 267.2,34.03 266.89,33.72 266.56,33.72 266.51,33.77 266.51,34.15 267.32,34.96 267.32,34.98 267.32,35.3 267.31,35.31 267.31,35.43 267.23,35.51 267.23,37.06 266.6,37.69 266.6,37.76 266.53,37.76 266.41,37.88 265.9,37.88 265.77,38.01 265.77,38.77 265.9,38.9 267.3,38.9
GND on TOP (solid shape): 75.51,5.94 75.51,4.72 75.29,4.5 72.21,4.5 72.01,4.7 72.01,5.94 72.14,6.07 75.39,6.07
GND on TOP (solid shape): 126.23,56.3 126.23,53.38 125.91,53.06 125.21,53.06 125.08,53.19 125.08,56.46 125.17,56.55 125.97,56.55
GND on TOP (solid shape): 131.53,56.8 131.53,53.88 131.29,53.64 129.84,53.64 129.55,53.93 129.55,56.99 129.82,57.26 131.08,57.26
GND on TOP (solid shape): 117.22,5.75 117.22,4.48 117.08,4.34 114.98,4.34 114.91,4.27 113.94,4.27 113.69,4.52 113.69,5.64 113.94,5.89 117.08,5.89
GND on TOP (solid shape): 59.79,16.7 59.79,15.48 59.69,15.38 56.86,15.38 56.61,15.64 56.61,16.72 56.67,16.78 59.72,16.78
GND on TOP (solid shape): 16.75,14.73 16.75,13.27 16.68,13.19 16.13,13.19 15.93,12.99 15.93,12.78 15.82,12.67 15.3,12.67 15.21,12.76 15.21,14.79 15.37,14.95 16.54,14.95
GND on TOP (solid shape): 40.17,28.03 42.86,28.03 42.98,27.91 42.98,26.77 42.72,26.52 37.4,26.52 37.25,26.67 37.25,27.28 36.89,27.63 36.89,27.99 37.01,28.1 40.09,28.1
GND on TOP (solid shape): 56.9,35.11 56.9,32.07 56.58,31.75 56.58,30.24 56.21,29.87 55.22,29.87 54.97,30.12 54.97,33.55 55.08,33.67 55.08,34.96 55.35,35.23 56.78,35.23
GND on TOP (solid shape): 102.36,102.92 102.36,102.53 102.49,102.4 104.13,102.4 104.29,102.23 104.29,100.94 104.24,100.89 100.89,100.89 100.69,101.09 100.69,102.84 100.86,103.02 102.26,103.02
GND on TOP (solid shape): 165.34,89.75 165.34,88.75 165.19,88.59 165.19,87.8 165.14,87.75 164.54,87.75 164.43,87.87 164.43,88.36 164.2,88.59 164.2,89.69 164.35,89.84 165.26,89.84
GND on TOP (solid shape): 80.82,15.4 80.82,10.96 80.7,10.83 78.98,10.83 78.54,11.28 78.54,12.93 78.09,13.37 75.81,13.37 75.55,13.63 75.55,15.4 75.68,15.53 80.7,15.53
GND on TOP (solid shape): 121.91,56.5 121.91,53.95 121.78,53.82 120.12,53.82 119.85,54.09 119.85,54.3 120.59,55.04 120.59,56.6 120.66,56.68 121.73,56.68
GND on TOP (solid shape): 109.87,15.91 109.87,15.05 110.53,14.39 110.53,13.27 110.31,13.06 104.11,13.06 104.04,13.13 104.04,14.17 103.78,14.43 103.33,14.43 103.15,14.6 103.15,16.1 103.43,16.38 109.4,16.38
GND on TOP (solid shape): 272.57,68.35 281.31,68.35 281.48,68.17 281.48,67.28 281.25,67.06 272.46,67.06 271.88,67.64 271.06,67.64 270.92,67.78 270.92,68.27 271.07,68.43 272.49,68.43
GND on TOP (solid shape): 111.78,55.38 111.78,52.49 110.65,51.36 98.9,51.36 98.56,51.69 98.56,54.24 99.06,54.74 102.44,54.74 103.24,55.54 108.13,55.54 108.19,55.6 108.19,56.04 108.29,56.14 111.02,56.14
GND on TOP (solid shape): 276.11,36.5 276.11,31.04 276.03,30.96 270.57,30.96 270.55,30.99 270.55,33.71 270.33,33.92 269.42,33.92 269.33,34.01 269.33,34.13 269.43,34.24 270.5,34.24 270.57,34.31 270.57,36.52 276.09,36.52
GND on TOP (solid shape): 83.58,68.43 83.58,68.17 88.3,63.45 88.3,59.18 87.9,58.78 81.84,58.78 81.23,59.38 81.23,64.03 80.96,64.3 80.96,68.29 81.61,68.94 83.07,68.94
GND on TOP (solid shape): 141.33,93.14 141.33,92.43 141.22,92.33 141.02,92.33 140.89,92.46 140.7,92.46 140.63,92.46 140.44,92.46 140.28,92.3 138.8,92.3 138.74,92.37 138.74,93.07 138.93,93.26 141.21,93.26
GND on TOP (solid shape): 175.92,87.73 175.92,85.72 175.91,85.69 175.87,85.67 168.5,85.67 168.28,85.45 168.28,84.56 168.17,84.45 168.05,84.45 168,84.51 168,85.45 168.35,85.8 168.35,87.73 168.38,87.76 175.9,87.76
GND on TOP (solid shape): 266.67,33.35 266.68,33.35 266.71,33.32 266.71,31.8 266.91,31.6 267.14,31.6 267.29,31.46 267.29,30.7 266.9,30.31 266.12,30.31 265.89,30.53 265.89,31.83 265.75,31.98 260.46,31.98 260.22,32.21 260.22,32.93 260.42,33.12 265.82,33.12 266.23,33.53 266.48,33.53
GND on TOP (solid shape): 57.48,8.84 57.48,8.46 57.46,8.43 57.38,8.43 56.11,8.43 56.06,8.43 56.04,8.41 56.01,8.38 56.01,8.25 55.93,8.18 55.73,8.18 55.55,8.36 55.55,8.76 55.68,8.89 57.43,8.89
GND on TOP (solid shape): 194.04,63.22 194.87,63.22 195.25,62.84 195.25,58.14 194.42,57.31 194.42,56.43 194.23,56.24 191.31,56.24 191.19,56.36 191.19,57.51 191.38,57.7 192.39,57.7 192.65,57.95 192.65,59.73 192.77,59.85 194.04,59.85 194.17,59.98 194.17,61.12 193.98,61.32 192.84,61.32 192.58,61.57 192.58,63.35 192.71,63.47 193.79,63.47
GND on TOP (solid shape): 37.33,31.41 37.33,30.02 36.98,29.68 36.98,29.41 36.06,28.49 35.1,28.49 34.66,28.93 34.66,29.04 34.67,29.06 34.77,29.3 34.67,29.55 34.66,29.57 34.66,29.59 34.66,31.53 34.79,31.66 37.07,31.66
GND on TOP (solid shape): 59.68,11.47 59.68,10.64 60.19,10.13 62.73,10.13 62.92,9.94 62.92,6.45 62.66,6.2 61.52,6.2 61.01,5.69 59.36,5.69 59.3,5.75 59.3,6.64 59.11,6.83 58.03,6.83 57.84,7.02 57.84,7.8 57.84,7.8 57.84,8.92 57.84,8.93 56.76,10 56.76,10.45 56.41,10.79 56.41,11.47 56.57,11.62 59.53,11.62
GND on TOP (solid shape): 199.06,63.35 199.06,61.63 199,61.57 198.43,61.57 198.3,61.44 198.3,59.35 198.11,59.16 196.58,59.16 196.08,58.65 196.08,57.7 196.2,57.57 197.66,57.57 198.11,58.01 199.76,58.01 199.82,57.95 199.82,56.74 199.7,56.62 198.62,56.62 198.08,56.08 194.84,56.08 194.74,56.17 194.74,57.31 195.5,58.08 195.5,63.16 195.76,63.41 199,63.41
GND on TOP (solid shape): 206.52,67.8 206.65,67.74 206.79,67.73 206.91,67.74 207.03,67.78 207.64,67.78 207.76,67.67 207.76,67.09 207.63,66.97 207.12,66.97 207,66.84 207,66.77 207,65.66 206.82,65.48 205.24,65.48 205.09,65.63 205.09,67.49 205.4,67.8
GND on TOP (solid shape): 273.53,85.74 274.25,85.42 274.97,85.74 281.47,85.74 281.99,85.22 281.99,83.46 281.69,83.16 271.46,83.16 271.2,83.42 271.2,85.37 271.57,85.74
GND on TOP (solid shape): 207.6,104.08 207.26,103.74 203.8,103.74 203.22,103.16 203.22,102.26 203.01,102.05 202.42,102.05 201.36,103.12 201.36,105.15 203,105.15 203.74,105.77 203.25,106.61 203.25,112.75 207.6,112.75
GND on TOP (solid shape): 235.13,80.24 235.13,76.94 234.82,76.63 234.82,76.35 234.5,76.02 234.02,76.02 233.97,75.97 233.97,75.2 234.09,75.07 234.59,75.07 234.73,74.93 234.73,74.67 234.74,74.66 234.74,74.46 234.69,74.41 233.14,74.41 232.87,74.14 232.85,74.14 232.85,74.13 232.74,74.02 232.74,74.01 232.66,73.94 232.66,70.22 232.65,70.18 232.61,70.17 231.11,70.17 231.08,70.18 231.06,70.22 231.06,70.28 231.06,74.07 231.45,74.45 231.45,77.04 231.52,77.11 233.54,77.11 233.79,77.37 233.79,80.05 234.05,80.3 235.06,80.3
GND on TOP (solid shape): 283.65,95.3 276.79,95.3 276.32,94.98 276.45,94.43 276.51,94.34 276.54,94.24 276.54,87.06 276.28,86.81 276.03,87.06 276.03,94.13 275.78,94.84 276.09,95.53 276.09,96.63 275.83,96.89 271.35,96.89 271.35,97.4 283.65,97.4
GND on TOP (solid shape): 233.95,103.65 234.17,103.12 234.7,102.9 235.01,102.9 235.01,102.39 234.7,102.39 233.81,102.76 233.44,103.65 233.44,112.24 222.11,112.24 222.11,109.26 222.43,108.94 223,108.94 223.19,108.75 223.19,106.59 222.94,106.34 222.49,106.34 222.11,105.96 222.11,102.03 222.61,100.99 222.07,99.98 222.07,97.34 221.73,97 221.09,97 220.65,97.45 220.65,99.86 221.06,100.27 221.35,100.27 222.08,100.82 221.73,101.67 221.64,101.77 221.6,101.9 221.6,112.75 233.95,112.75
GND on TOP (solid shape): 158.65,111.95 158.87,111.42 159.4,111.2 161.29,111.2 161.55,110.94 161.29,110.69 159.4,110.69 158.51,111.06 158.14,111.95 158.14,112.24 106.26,112.24 106.26,111.95 105.89,111.06 105,110.69 103.11,110.69 102.85,110.94 103.11,111.2 105,111.2 105.53,111.42 105.75,111.95 105.75,112.75 158.65,112.75
GND on TOP (solid shape): 64.7,101.9 64.66,101.77 64.57,101.67 64.22,100.82 64.95,100.27 65.75,100.27 66.23,99.78 66.23,97.17 66.87,96.53 68.49,96.53 68.9,96.13 68.9,93.93 68.53,92.89 68.9,91.85 68.9,88.89 67.74,87.73 65.44,87.73 63.93,86.22 56.21,86.22 54.88,84.89 54.88,82.42 52.44,79.98 52.44,76.05 51.57,75.18 48.78,75.18 48.24,74.64 47.8,69.98 46.68,65.43 46.31,65.06 46.25,65.1 46.14,65.23 46.14,65.4 47.33,70.27 47.73,75.26 47.73,79.29 46.96,80.82 47.48,82.45 47.48,88.15 52.73,88.15 52.89,88.03 53.03,87.9 61.65,87.9 62.18,88.12 62.4,88.65 62.4,112.75 64.7,112.75
GND on TOP (solid shape): 283.39,52.96 283.65,52.71 283.39,52.45 282.4,52.45 281.1,51.15 282.4,49.85 283.65,49.85 283.65,40.09 283.65,36.65 283.57,36.48 283.4,36.4 283.1,36.4 282.57,36.18 282.35,35.65 282.35,27.49 282.57,26.96 283.1,26.74 283.6,26.74 283.77,26.66 283.85,26.49 283.85,14.03 283.34,14.03 283.34,26.23 283.1,26.23 282.21,26.6 281.84,27.49 281.84,35.65 282.21,36.54 283.1,36.91 283.14,36.91 283.14,40.09 283.14,49.34 282.4,49.34 280.59,51.15 282.4,52.96
GND on TOP (solid shape): 6.8,11.07 6.1,10.21 5.01,10.45 4.03,10.45 4.03,9.66 2.87,8.51 0.76,8.51 0.76,4.42 3.33,3.52 2.4,0.96 3.01,0.96 3.48,1.49 3.77,2.13 3.91,2.7 6.83,2.7 6.83,2.19 4.31,2.19 4.26,2 3.86,1.13 3.18,0.45 1,0.45 0.47,0.67 0.25,1.2 0.25,1.95 0.42,1.95 3,2.7 0.42,3.45 0.25,3.45 0.25,9.61 0.37,9.82 0.4,10.06 0.4,10.96 5.26,10.96 5.81,10.66 6.28,11.07
GND on TOP (solid shape): 40.6,55.28 40.78,55.24 41.03,55.08 41.03,54.9 40.82,54.69 40.82,54.69 40.78,54.64 40.69,54.7 29.82,46.43 16.48,43.5 6.43,43.5 2,43.5 1.12,43.14 0.76,42.26 0.76,20.68 0.87,20.4 0.91,20.09 0.91,19.71 5.01,19.71 6.16,19.93 6.81,18.95 6.81,18.92 6.3,18.92 6.3,18.95 5.88,19.49 5.26,19.2 0.4,19.2 0.4,20.09 0.37,20.33 0.25,20.54 0.25,42.26 0.77,43.49 2,44.01 6.43,44.01 16.48,44.01 29.7,46.94 40.44,55.19
GND on TOP (solid shape): 187.05,106.78 187.01,106.65 186.92,106.55 186.55,105.95 186.83,105.31 186.83,105.31 187.15,104.99 188.32,104.99 188.65,104.66 188.65,102.41 188.23,101.99 187.77,101.99 187.45,102.31 187.45,103.59 186.42,104.62 184.13,104.62 176.2,96.69 168.54,104.35 168.54,110.69 165.11,110.69 164.85,110.94 165.11,111.2 169.05,111.2 169.05,104.35 176.2,97.2 183.35,104.35 183.35,112.75 187.05,112.75
GND on TOP (solid shape): 283.21,8.35 283.1,8.35 282.57,8.13 282.35,7.6 282.35,0.45 277.35,0.45 277.35,1.4 275.7,3.05 274.05,1.4 274.05,0.45 273.11,0.45 175.75,0.45 175.52,0.42 175.3,0.31 175.23,0.27 175.15,0.25 149.4,0.25 149.4,1.44 149.18,1.97 148.65,2.19 143.48,2.19 143.35,2.23 143.25,2.32 142.98,2.59 142.6,2.69 118.65,2.69 115.2,2.69 114.77,2.56 114.49,2.19 113.93,2.19 5.76,2.19 5.76,2.7 113.93,2.7 114.19,2.7 114.64,3.07 115.2,3.2 118.65,3.2 142.6,3.2 143.16,3.07 143.61,2.7 148.55,2.7 148.55,4.28 149.2,4.93 156.44,4.93 157.02,4.36 157.02,1.56 157.02,1.56 157.81,0.76 172.14,0.76 172.5,0.39 174.12,0.39 174.49,0.76 175.07,0.76 175.39,0.91 175.75,0.96 273.11,0.96 273.54,0.96 273.54,1.4 275.04,3.46 277.46,2.66 278.42,3.62 281.84,3.62 281.84,7.6 282.21,8.49 283.1,8.86 283.21,8.86
GND on TOP (solid shape): 81.05,104.35 88.2,97.2 95.35,104.35 95.35,111.2 99.29,111.2 99.55,110.94 99.29,110.69 95.86,110.69 95.86,104.35 89.06,96.74 80.73,102.65 80.47,102.91 79.62,102.91 79.21,102.5 79.21,102.03 79.71,101 79.17,99.99 79.17,97.32 78.79,96.94 78.16,96.94 77.71,97.38 77.71,99.73 78.25,100.27 78.45,100.27 79.18,100.82 78.83,101.67 78.74,101.77 78.7,101.9 78.7,112.75 81.05,112.75
GND on BOTTOM (solid shape): 61.2,9.4 61.2,6.1 60.88,5.78 58.2,5.78 57.94,6.04 57.94,9.24 58.17,9.47 61.14,9.47
GND on BOTTOM (solid shape): 73.65,64.28 73.65,62.18 72.83,61.36 70.45,61.36 70.31,61.49 70.31,64.18 70.63,64.49 73.44,64.49
GND on BOTTOM (solid shape): 88.37,59.51 88.37,56.01 88.16,55.8 85.55,55.8 85.45,55.9 85.45,59.49 85.6,59.64 88.24,59.64
GND on BOTTOM (solid shape): 142.45,94.36 142.45,93.48 141.29,92.32 141.03,92.32 140.44,92.91 140.44,94.28 140.54,94.39 142.42,94.39
GND on BOTTOM (solid shape): 189.28,67.92 189.28,67.31 189.08,67.11 186.22,67.11 186.1,67.23 186.1,67.93 186.24,68.07 189.13,68.07
GND on BOTTOM (solid shape): 230.2,81.33 230.2,78.38 230.1,78.28 227.86,78.28 227.61,78.54 227.61,81.1 227.97,81.46 230.07,81.46
GND on BOTTOM (solid shape): 266.38,84.29 266.38,81.52 266.01,81.15 264.25,81.15 263.97,81.43 263.97,84.3 264.24,84.57 266.1,84.57
GND on BOTTOM (solid shape): 271.88,45.87 271.88,44.78 271.06,43.95 270.33,43.95 270.1,44.18 270.1,44.45 271.54,45.88 271.87,45.88
GND on BOTTOM (solid shape): 165.47,92.11 165.47,88.98 165.05,88.56 163.78,88.56 162.94,89.39 162.94,92.19 162.99,92.24 165.34,92.24
GND on BOTTOM (solid shape): 112.89,95.41 113.46,95.41 113.56,95.31 113.56,93.93 112.26,92.62 109.33,92.62 109.21,92.75 109.21,95.73 109.33,95.86 112.45,95.86
GND on BOTTOM (solid shape): 232.84,75.03 232.84,70.36 232.74,70.26 231.65,70.26 231.45,70.46 231.45,72.64 231.04,73.05 231.04,74.93 231.24,75.13 232.74,75.13
GND on BOTTOM (solid shape): 97.79,8.9 97.79,5.33 97.07,4.61 90.91,4.61 89.71,5.8 89.71,8.91 90.03,9.23 97.46,9.23
GND on BOTTOM (solid shape): 181.48,65.48 181.48,62.74 181.28,62.53 178.21,62.53 177.88,62.86 177.88,65.53 178.18,65.84 181.13,65.84
GND on BOTTOM (solid shape): 195.06,65.19 195.06,63.73 194.93,63.6 194.11,63.6 193.92,63.79 193.92,64.19 194.02,64.29 194.02,65.29 194.08,65.35 194.89,65.35
GND on BOTTOM (solid shape): 182.74,78.84 182.74,78.02 183.6,77.16 183.6,71.32 183.5,71.22 181.15,71.22 181.09,71.28 181.09,72.49 180.14,73.44 180.14,78.84 180.26,78.97 182.61,78.97
GND on BOTTOM (solid shape): 272.57,68.35 281.31,68.35 281.48,68.17 281.48,67.28 281.25,67.06 271.15,67.06 270.92,67.28 270.92,68.27 271.07,68.43 272.49,68.43
GND on BOTTOM (solid shape): 205.31,69.32 205.31,66.41 202.68,66.41 202.31,66.04 201.8,66.04 201.79,66.05 201.33,66.05 201.11,66.27 201.11,67.11 200.89,67.34 200.89,68.99 201.27,69.37 205.26,69.37
GND on BOTTOM (solid shape): 267.79,87.21 267.79,86.83 268.44,86.18 268.44,84.81 268.29,84.66 266.65,84.66 266.1,85.2 266.1,87.2 266.23,87.32 267.68,87.32
GND on BOTTOM (solid shape): 110.16,15.79 110.48,15.79 110.73,15.53 110.73,14.26 110.54,14.07 107.87,14.07 107.62,14.33 104.64,14.33 104.32,14.64 104.32,15.98 104.51,16.17 109.78,16.17
GND on BOTTOM (solid shape): 150.29,90.06 150.29,89.46 150.15,89.32 149.62,89.32 149.53,89.23 149.53,88.69 149.45,88.62 147.96,88.62 147.91,88.67 147.91,89.46 147.56,89.81 147.56,90.38 147.66,90.48 149.87,90.48
GND on BOTTOM (solid shape): 230.75,90.93 230.75,88.24 230.62,88.11 228.59,88.11 228.11,88.59 228.08,88.65 228.08,91.66 228.08,92.11 228.14,92.18 229.5,92.18
GND on BOTTOM (solid shape): 86.95,80.67 87.72,80.67 87.72,81.2 88.15,81.2 88.15,80.66 88.91,80.66 88.91,81.2 89.45,81.2 89.52,81.12 89.52,80.31 88.63,79.41 85.59,79.41 85.42,79.58 85.42,81.01 85.61,81.2 86.95,81.2
GND on BOTTOM (solid shape): 198.6,82.37 198.6,81.81 198.55,81.76 197.99,81.76 197.87,81.64 197.87,81.18 197.71,81.03 196.75,81.03 196.67,81.1 196.67,82.07 196.72,82.12 197.23,82.12 197.54,82.42 198.55,82.42
GND on BOTTOM (solid shape): 234.96,87.45 234.96,85.22 234.81,85.06 233.92,85.06 233.86,85.13 233.86,85.5 233.65,85.7 232.97,85.7 232.92,85.75 232.92,87.71 233.06,87.85 234.56,87.85
GND on BOTTOM (solid shape): 202.96,65.09 205.45,65.09 205.58,64.97 205.58,63.89 205.46,63.78 202.72,63.78 202.36,64.13 201.2,64.13 201.1,64.23 201.1,65.74 201.25,65.89 202.17,65.89
