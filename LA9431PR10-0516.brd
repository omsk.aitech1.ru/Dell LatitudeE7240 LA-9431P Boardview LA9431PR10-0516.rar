# Allegro board LA9431PR10-0516.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
IMD2AT-108_SC74-6
  oval 0.508x1.473 smd: 1(0,0) 2(-0.95,0) 3(-1.9,0) 4(-1.9,2.55) 5(-0.95,2.55) 6(0,2.55)
INA199A2DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
JAE_WD2F144WB8-DT_144P-T
  round 1.092 hole 1.092 unplated: (-1.475,-0.6)
  oval 1.397x1.092 hole 1.397x1.092 unplated: (38.975,-7.4)
  oval 0.254x1.803 smd: 1(0,0) 2(0,-8) 3(0.5,0) 4(0.5,-8) 5(1,0) 6(1,-8) 7(1.5,0) 8(1.5,-8) 9(2,0) 10(2,-8) 11(2.5,0) 12(2.5,-8) 13(3,0) 14(3,-8) 15(3.5,0) 16(3.5,-8) 17(4,0) 18(4,-8) 19(4.5,0) 20(4.5,-8) 21(5,0) 22(5,-8) 23(5.5,0) 24(5.5,-8) 25(6,0) 26(6,-8) 27(6.5,0) 28(6.5,-8) 29(7,0) 30(7,-8) 31(7.5,0) 32(7.5,-8) 33(8,0) 34(8,-8) 35(8.5,0) 36(8.5,-8) 37(9,0) 38(9,-8) 39(9.5,0) 40(9.5,-8) 41(10,0) 42(10,-8) 43(10.5,0) 44(10.5,-8) 45(11,0) 46(11,-8) 47(11.5,0) 48(11.5,-8) 49(12,0) 50(12,-8) 51(13.5,0) 52(13.5,-8) 53(14,0) 54(14,-8) 55(14.5,0) 56(14.5,-8) 57(15,0) 58(15,-8) 59(15.5,0) 60(15.5,-8) 61(16,0) 62(16,-8) 63(16.5,0) 64(16.5,-8) 65(17,0) 66(17,-8) 67(17.5,0) 68(17.5,-8) 69(18,0) 70(18,-8) 71(18.5,0) 72(18.5,-8) 73(19,0) 74(19,-8) 75(19.5,0) 76(19.5,-8) 77(20,0) 78(20,-8) 79(20.5,0) 80(20.5,-8) 81(21,0) 82(21,-8) 83(21.5,0) 84(21.5,-8) 85(22,0) 86(22,-8) 87(22.5,0) 88(22.5,-8) 89(23,0) 90(23,-8) 91(23.5,0) 92(23.5,-8) 93(24,0) 94(24,-8) 95(25.5,0) 96(25.5,-8) 97(26,0) 98(26,-8) 99(26.5,0) 100(26.5,-8) 101(27,0) 102(27,-8) 103(27.5,0) 104(27.5,-8) 105(28,0) 106(28,-8) 107(28.5,0) 108(28.5,-8) 109(29,0) 110(29,-8) 111(29.5,0) 112(29.5,-8) 113(30,0) 114(30,-8) 115(30.5,0) 116(30.5,-8) 117(31,0) 118(31,-8) 119(31.5,0) 120(31.5,-8) 121(32,0) 122(32,-8) 123(32.5,0) 124(32.5,-8) 125(33,0) 126(33,-8) 127(33.5,0) 128(33.5,-8) 129(34,0) 130(34,-8) 131(34.5,0) 132(34.5,-8) 133(35,0) 134(35,-8) 135(35.5,0) 136(35.5,-8) 137(36,0) 138(36,-8) 139(36.5,0) 140(36.5,-8) 141(37,0) 142(37,-8) 143(37.5,0) 144(37.5,-8)
  oval 1.473x3.353 hole 0.711x2.591: 145(-6.425,-4) 148(43.925,-4)
  oval 1.753x1.473 hole 0.991x0.711: 146(-1.475,-2.725) 147(-1.475,-5.275) 149(38.975,-2.725) 150(38.975,-5.275)
  oval 3.759x1.524 hole 2.997x0.762: 151(-5.75,-0.075) 154(43.25,-0.075) 159(-5.75,-7.925) 162(43.25,-7.925)
  oval 1.753x1.6 hole 0.991x0.838: 152(12.75,-0.075) 153(24.75,-0.075) 160(12.75,-7.925) 161(24.75,-7.925)
  round 1.753 hole 0.991: 155(0.75,-4) 156(12.75,-4) 157(24.75,-4) 158(36.75,-4)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-S
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_1812-1806
  oval 1.016x3.708 smd: 1(0,0) 2(4.013,0)
LCN_AUF05-1922S10-0019_19P-T
  round 0.813 hole 0.508: 1(0,0) 2(0.5,1.2) 3(1,0) 4(1.5,1.2) 5(2,0) 6(2.5,1.2) 7(3,0) 8(3.5,1.2) 9(4,0) 10(4.5,1.2) 11(5,0) 12(5.5,1.2) 13(6,0) 14(6.5,1.2) 15(7,0) 16(7.5,1.2) 17(8,0) 18(8.5,1.2) 19(9,0)
  oval 1.397x2.794 hole 0.787x2.21: 20(-2.75,0.77) 21(11.75,0.77)
  oval 1.397x2.591 hole 0.787x2.007: 22(-4.75,-6.08) 23(13.75,-6.08)
LCN_DAN08-52216-0100_52P-T
  round 0.991 hole 0.991 unplated: (-26.2,-3) (2.6,-3)
  oval 0.406x0.991 smd: 1(0,0) 3(-0.8,0) 5(-1.6,0) 7(-2.4,0) 9(-3.2,0) 11(-4,0) 13(-4.8,0) 15(-5.6,0) 17(-9.6,0) 19(-10.4,0) 21(-11.2,0) 23(-12,0) 25(-12.8,0) 27(-13.6,0) 29(-14.4,0) 31(-15.2,0) 33(-16,0) 35(-16.8,0) 37(-17.6,0) 39(-18.4,0) 41(-19.2,0) 43(-20,0) 45(-20.8,0) 47(-21.6,0) 49(-22.4,0) 51(-23.2,0)
  oval 0.61x1.549 hole 0.406x0.787: 2(-0.4,-1.65) 4(-1.2,-1.65) 6(-2,-1.65) 8(-2.8,-1.65) 10(-3.6,-1.65) 12(-4.4,-1.65) 14(-5.2,-1.65) 16(-6,-1.65) 18(-10,-1.65) 20(-10.8,-1.65) 22(-11.6,-1.65) 24(-12.4,-1.65) 26(-13.2,-1.65) 28(-14,-1.65) 30(-14.8,-1.65) 32(-15.6,-1.65) 34(-16.4,-1.65) 36(-17.2,-1.65) 38(-18,-1.65) 40(-18.8,-1.65) 42(-19.6,-1.65) 44(-20.4,-1.65) 46(-21.2,-1.65) 48(-22,-1.65) 50(-22.8,-1.65) 52(-23.6,-1.65)
  oval 1.27x2.972 hole 0.508x2.21: 53(3.1,-6.2) 54(-26.7,-6.2)
LCN_DAN08-52406-0500_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(-2.85,0.6) 54(26.45,0.6)
LED_LTW-193ZDS5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LED_LTW-295DSKS-5A_4P
  rect 0.508x0.406 smd: 1(0,0) 2(1.2,0) 3(0,0.7) 4(1.2,0.7)
LM393DR_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MEC5075-LZY_DQFN132_11X11
  oval 0.279x0.711 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.711x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.305x0.61 smd: B1(-0.25,0.85) B2(0.25,0.85) B3(0.75,0.85) B4(1.25,0.85) B5(1.75,0.85) B6(2.25,0.85) B7(2.75,0.85) B8(3.25,0.85) B9(3.75,0.85) B10(4.25,0.85) B11(4.75,0.85) B12(5.25,0.85) B13(5.75,0.85) B14(6.25,0.85) B15(6.75,0.85) B16(7.25,0.85) B17(7.75,0.85) B35(7.75,10.05) B36(7.25,10.05) B37(6.75,10.05) B38(6.25,10.05) B39(5.75,10.05) B40(5.25,10.05) B41(4.75,10.05) B42(4.25,10.05) B43(3.75,10.05) B44(3.25,10.05) B45(2.75,10.05) B46(2.25,10.05) B47(1.75,10.05) B48(1.25,10.05) B49(0.75,10.05) B50(0.25,10.05) B51(-0.25,10.05)
  oval 0.61x0.305 smd: B18(8.35,1.45) B19(8.35,1.95) B20(8.35,2.45) B21(8.35,2.95) B22(8.35,3.45) B23(8.35,3.95) B24(8.35,4.45) B25(8.35,4.95) B26(8.35,5.45) B27(8.35,5.95) B28(8.35,6.45) B29(8.35,6.95) B30(8.35,7.45) B31(8.35,7.95) B32(8.35,8.45) B33(8.35,8.95) B34(8.35,9.45) B52(-0.85,9.45) B53(-0.85,8.95) B54(-0.85,8.45) B55(-0.85,7.95) B56(-0.85,7.45) B57(-0.85,6.95) B58(-0.85,6.45) B59(-0.85,5.95) B60(-0.85,5.45) B61(-0.85,4.95) B62(-0.85,4.45) B63(-0.85,3.95) B64(-0.85,3.45) B65(-0.85,2.95) B66(-0.85,2.45) B67(-0.85,1.95) B68(-0.85,1.45)
  rect 5.004x5.004 smd: C1(3.75,5.45)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15AG601SN1D_2P
  oval 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB221SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18AG102SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18AG221SN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MURAT_BLM18PG330SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_DLW21HN900SQ2L_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN670HQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_DLW21SN900HQ2L-0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900HQ2L-0805_4P-S
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L-0805_4P-S
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_LQM2MPN2R2NG0L_2P
  rect 0.787x1.803 smd: 1(0,0) 2(1.6,0)
NTGD4161PT1G_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
NX3DV221GM_XQFN10U10_2X1P55
  oval 0.305x0.533 smd: 1(0,0)
  oval 0.254x0.533 smd: 2(0.526,0) 3(1.025,0) 4(1.526,0) 6(1.526,1.475) 7(1.025,1.475) 8(0.526,1.475) 9(0.025,1.475)
  oval 0.533x0.254 smd: 5(1.75,0.738) 10(-0.2,0.738)
OZ777FJ2LN_QFN48_6X6
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,6.1) 26(4,6.1) 27(3.6,6.1) 28(3.2,6.1) 29(2.8,6.1) 30(2.4,6.1) 31(2,6.1) 32(1.6,6.1) 33(1.2,6.1) 34(0.8,6.1) 35(0.4,6.1) 36(0,6.1)
  oval 0.889x0.203 smd: 13(5.25,0.85) 14(5.25,1.25) 15(5.25,1.65) 16(5.25,2.05) 17(5.25,2.45) 18(5.25,2.85) 19(5.25,3.25) 20(5.25,3.65) 21(5.25,4.05) 22(5.25,4.45) 23(5.25,4.85) 24(5.25,5.25) 37(-0.85,5.25) 38(-0.85,4.85) 39(-0.85,4.45) 40(-0.85,4.05) 41(-0.85,3.65) 42(-0.85,3.25) 43(-0.85,2.85) 44(-0.85,2.45) 45(-0.85,2.05) 46(-0.85,1.65) 47(-0.85,1.25) 48(-0.85,0.85)
  rect 4.343x4.343 smd: 49(2.2,3.05)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PDTA114EU_SC70-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI3C3125LEX_TSSOP14
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(3.9,5.8) 9(3.25,5.8) 10(2.6,5.8) 11(1.95,5.8) 12(1.3,5.8) 13(0.65,5.8) 14(0,5.8)
PI3L720ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.057 smd: 43(4,1.725)
PI3USB3102ZLEX_TQFN32_6X3
  oval 0.203x0.864 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 17(4,3.126) 18(3.6,3.126) 19(3.2,3.126) 20(2.8,3.126) 21(2.4,3.126) 22(2,3.126) 23(1.6,3.126) 24(1.2,3.126) 25(0.8,3.126) 26(0.4,3.126) 27(0,3.126)
  oval 0.864x0.203 smd: 12(5.063,0.763) 13(5.063,1.163) 14(5.063,1.563) 15(5.063,1.963) 16(5.063,2.363) 28(-1.063,2.363) 29(-1.063,1.963) 30(-1.063,1.563) 31(-1.063,1.163) 32(-1.063,0.763)
  rect 5.004x2.007 smd: 33(2,1.563)
PI3VDP12412ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.057 smd: 43(4,1.725)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-S
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB717F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RB751VM-40TE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9818A-44GU3_SC70-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_130456-341_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  round 1.397 hole 0.991: 9(-3.395,1.1) 10(-1.105,2.6) 11(8.245,2.6) 12(9.39,1.1) 13(10.535,2.6)
  oval 1.473x3.15 hole 0.711x2.388: 14(13.095,-6.42) 15(-5.955,-6.42)
SANTA_373070-1_9P-T
  round 1.016 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(3.25,-0.47) 11(-10.25,-0.47)
  oval 1.397x2.388 hole 0.787x1.803: 12(4.35,-9.47) 13(-11.35,-9.47)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI4835DDY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI7121DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SI7326DN-T1-E3_PAK1212-8
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SINGA_2SJ3080-003111F_6P-T
  oval 0.991x1.905 hole 0.61x1.499: 1(0,0) 2(-9.51,5.49) 3(0,7.8) 4(-9.51,8.39) 5(-9.51,0) 6(-9.51,2.74) 7(0,4.1)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SLG55594AVTR_TDFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.651x0.889 smd: 9(0.75,1.1)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
TAIMA_IH-115-F_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAITW_PUBAUE-09FLBS1FF4H0_9P-T
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.43) 11(-11.35,-2.43)
  oval 1.397x2.311 hole 0.787x1.702: 12(-11.35,-9.23) 13(4.35,-9.23)
TAIYO_CBC2012T4R7M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_FDVE1040-H-3R3M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.8,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51218DSCR_SON10_3X3
  oval 0.279x0.813 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.925) 7(1.5,2.925) 8(1,2.925) 9(0.5,2.925) 10(0,2.925)
  custom 0.412x0.412 smd: 11(1,1.463)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS51622RSM_QFN32_4X4
  oval 0.203x0.914 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.077) 18(2.4,4.077) 19(2,4.077) 20(1.6,4.077) 21(1.2,4.077) 22(0.8,4.077) 23(0.4,4.077) 24(0,4.077)
  oval 0.914x0.203 smd: 9(3.438,0.639) 10(3.438,1.039) 11(3.438,1.438) 12(3.438,1.838) 13(3.438,2.239) 14(3.438,2.639) 15(3.438,3.039) 16(3.438,3.438) 25(-0.639,3.438) 26(-0.639,3.039) 27(-0.639,2.639) 28(-0.639,2.239) 29(-0.639,1.838) 30(-0.639,1.438) 31(-0.639,1.039) 32(-0.639,0.639)
  rect 2.794x2.794 smd: 33(1.4,2.039)
TS5A63157DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
TYCO_2-1775293-2_2P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0)
  rect 2.108x2.997 smd: 3(2.55,2.9) 4(-3.8,2.9)
unnamed#2
  round 0.991 hole 0.991 unplated: (0,0)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25X10BVSNIG_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
WGI218LM-QQ89-B0_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_7V25000034_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.8) 4(0,1.8)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q13FC135000040_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X1E000021042600_4P
  rect 1.397x1.143 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.675V_DDR_VTT_ON: PR210.1 QD1.2 R28.2 R32.2 U5.4
1.05V_A_PWRGD: PR300.2 PU300.1 U38.B28
1.05V_MODPHY_EN: C412.1 Q124.3 Q125.3 R445.2
1.5VSP: PC403.1 PC404.1 PJP401.2 PR402.1 PU400.3 PU400.4
1.35V_B+: PC200.1 PC201.1 PC202.1 PC203.1 PJP200.1 PQ200.5 PR206.1
1.35V_FB: PC213.2 PR205.2 PR209.2 PU11.6
1.35V_SUS_PWRGD: PR204.2 PU11.10 U38.B9
3.3V_CAM_EN#: R106.1 RC211.1 UC1.AM4
3.3V_HDD_EN: R129.1 RC295.2 UC1.K2
3.3V_TP_EN: RP8.5 UC1.L5
3.3V_TS_EN: Q17.2 RP8.8 UC1.N7
+0.9V_LAN: C177.1 C180.1 C183.1 C184.1 C185.1 C186.1 C187.1 L26.2 U21.8 U21.11 U21.16 U21.22 U21.37 U21.40 U21.43 U21.46 U21.47
+0.675V_DDR_VTT: CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD59.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP202.1
+0.675V_P: PC205.1 PJP202.2 PU11.2 PU11.20
+1.2V_LDO: C217.2 C218.2 C223.2 L36.1 U27.10 U27.41
+1.2V_LDO_AIN: C230.2 C231.2 C232.2 C233.2 C234.2 L36.2 U27.1 U27.28 U27.31 U27.36
+1.05V_M: CC46.1 CC47.1 CC73.1 LC4.1 PJP301.1 Q125.1 Q125.2 Q125.5 Q125.6 RC16.1 RC272.1 RC276.1 U43.6 U43.7 UC1.AE9 UC1.AF9 UC1.AG8 UC1.AG13 UC1.AG14
+1.05V_M_JTAG: RC10.2 RC16.2 RC17.2 RC18.2 RC20.2
+1.05V_MODPHY: C413.1 LC1.1 LC2.1 Q125.4 R447.1 RC262.1
+1.05V_MODPHY_PCH: CC27.1 CC29.1 CC74.1 RC262.2 UC1.K9 UC1.L10 UC1.M9
+1.05V_MP: PC307.1 PJP301.2 PL300.2 PR307.1
+1.05V_RUN: C458.2 C461.2 CC10.1 CC11.1 CC31.1 CC33.1 CC34.1 CC37.1 CC60.1 CC63.1 CC64.1 CC71.1 CC72.1 JXDP1.43 JXDP1.44 LC3.1 LC5.1 LC6.1 PJP11.1 PJP15.1 R335.1 R374.2 R403.1 RC118.1 RC119.1 RC120.1 RC122.1 RC242.2 RC253.1 RC280.1 U31.1 U31.2 UC1.AE8 UC1.AF22 UC1.AG16 UC1.AG17 UC1.H11 UC1.H15 UC1.J11 UC1.J17 UC1.N8 UC1.P9 UC1.R21 UC1.T21
+1.05V_RUN_U43: C393.1 PJP15.2 U43.8 U43.9
+1.05V_RUN_VMM: L1.1 L4.1 PJP12.1
+1.05V_RUN_VMM_U31: C432.1 PJP12.2 U31.13 U31.14
+1.5V_THERMAL: PJP401.1 UC1.J15
+1.05V_VCCST: CC26.1 CC50.1 PC511.1 PJP11.2 PR527.1 PR528.1 PR529.1 R24.1 RC113.1 RC114.1 RC243.2 RC244.1 RC249.1 RC255.1 UC1.AC22 UC1.AE22 UC1.AE23
+1.05V_VMM_VDD: C8.1 C9.1 C10.1 C11.1 C12.1 C17.1 C18.1 C25.1 C132.1 L1.2 U6.C8 U6.C9 U6.E3 U6.E5 U6.E6 U6.E7 U6.E8 U6.E9 U6.F12 U6.G3 U6.G12 U6.H6 U6.H7 U6.H8 U6.H9
+1.05V_VMM_VDDTX: C21.1 C22.1 C23.1 C24.1 L4.2 U6.C6 U6.C7 U6.D3 U6.D12 U6.E10 U6.E12 U6.F3 U6.H3 U6.H11 U6.J2 U6.J3 U6.J10 U6.K8 U6.K9 U6.K10
+1.8V_RUN_CARD: C228.1 C229.1 C246.1 C247.1 JSD1.14 U27.24
+1.35V_MEM: C452.1 C454.2 C460.2 C461.1 CC12.1 CC13.1 CC16.1 CC17.1 CC18.1 CC19.1 CC20.1 CC21.1 CC52.1 CC81.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJP203.1 PJP204.1 QD1.1 RC67.1 RC130.1 RC217.1 RD3.1 U5.5 UC1.AH26 UC1.AJ31 UC1.AJ33 UC1.AJ37 UC1.AN33 UC1.AP43 UC1.AR48 UC1.AY35 UC1.AY40 UC1.AY44 UC1.AY50
+1.35V_MEN_P: PC207.1 PC213.1 PC214.1 PJP201.1 PJP203.2 PJP204.2 PL200.1 PR205.1 PU11.5
+3.3V_ALW: C50.1 C322.1 C328.1 C348.1 C375.1 C386.1 C404.1 C430.1 C452.2 CC24.1 JKBTP1.11 JSH1.12 PC728.2 PC801.2 PC805.2 PJP6.1 PJP7.1 PJP102.2 PJP402.1 PR2.1 PR8.2 PR107.2 PR204.1 PR300.1 PR726.1 PR740.1 PR801.1 PR807.1 PR810.1 PR868.2 PR895.1 PU3.5 PU801.5 PU804.5 R36.1 R272.2 R281.1 R282.1 R284.1 R285.1 R287.1 R288.1 R289.1 R291.1 R292.1 R293.1 R295.1 R298.1 R317.2 R322.1 R339.1 R340.1 R343.1 R344.1 R345.1 R348.1 R350.1 R353.1 R359.1 R361.1 R363.1 R364.1 R365.1 R380.1 R385.1 R386.1 R387.1 R388.1 R391.1 R392.1 R393.1 R397.1 R398.1 R401.1 R402.1 R428.1 R432.1 R440.1 R451.1 R452.1 R453.1 RC264.1 RC267.1 RP1.1 RP1.2 RP1.3 RP1.4 RP3.1 RP3.2 RP3.3 RP3.4 RP11.1 RP11.2 RP11.3 U3.1 U3.2 U3.6 U3.7 U9.4 U9.5 U18.6 U18.7 U22.1 U22.2 U22.6 U22.7 U36.10 U42.5 U43.1 U43.2 U45.1 U45.2 U45.6 U45.7 U46.6 U46.7 U47.5 UC4.5
+3.3V_ALW2: CC82.1 PC100.2 PC808.2 PC810.2 PC812.2 PC814.2 PR103.1 PR730.1 PR738.1 PR751.1 PR808.1 PR816.2 PR819.2 PR823.2 PR824.2 PR829.1 PR846.1 PR849.1 PR862.1 PR864.1 PR875.1 PR894.1 PU100.3 PU805.5 PU806.5 PU807.5 PU808.5 R367.2 R442.1 UC7.5
+3.3V_ALW_PCH: C1.1 C388.2 CC28.1 CC44.1 JAPS1.1 JNFC1.2 JNFC1.3 JNFC1.15 PJP14.1 R38.1 RC3.1 RC28.1 RC30.1 RC34.1 RC36.2 RC37.2 RC38.1 RC39.1 RC74.1 RC102.2 RC166.2 RC190.1 RC200.2 RC205.2 RC261.1 RC265.1 RP5.1 RP5.2 RP5.3 RP5.4 RP7.1 RP7.2 RP7.3 RP7.4 RP9.1 RP9.2 RP10.1 RP10.2 RP10.3 RP10.4 U29.5 UC1.AA9 UC1.AC9 UC1.AE20 UC1.AE21 UC1.AH14
+3.3V_ALW_PCH_U43: C389.1 PJP14.2 U43.13 U43.14
+3.3V_ALW_U37: C329.1 C330.1 C331.1 C332.1 C334.1 PJP6.2 U37.A17 U37.A43 U37.A54 U37.B5 U37.B30
+3.3V_ALW_U38: C349.1 C350.1 C351.1 C354.1 C355.1 C356.1 PJP7.2 R336.1 R490.1 U38.A11 U38.A26 U38.A41 U38.A52 U38.B3 U38.B35
+3.3V_ALWP: PC112.1 PC113.1 PJP102.1 PL101.2 PR100.1
+3.3V_CAM: C68.1 JEDP1.33 PJP9.1
+3.3V_CAM_Q: PJP9.2 Q3.1
+3.3V_HDD: C113.1 C114.1 JMINI3.2 JMINI3.24 JMINI3.39 JMINI3.41 JMINI3.52 PJP22.1 R155.1
+3.3V_HDD_U3: C428.1 PJP22.2 U3.13 U3.14
+3.3V_LAN: C192.1 C193.1 C194.1 C198.1 C320.1 C321.1 JLOM1.9 JLOM1.12 PJP20.1 R171.1 R172.1 R173.1 R176.2 R178.1 R181.1 U23.1 U23.4 U23.8 U23.14 U23.21 U23.30 U23.39 U24.5
+3.3V_LAN_OUT: C182.1 R181.2 U21.4 U21.5 U21.15 U21.19 U21.29
+3.3V_LAN_U22: C426.1 PJP20.2 U22.13 U22.14
+3.3V_M: C5.1 C6.1 CC40.1 JTAA1.2 JTAA1.4 PJP17.1 R1.1 R2.1 U1.8 U2.8 UC1.Y8
+3.3V_M_U45: C399.1 PJP17.2 U45.8 U45.9
+3.3V_MSATA_WWAN: C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 PJP21.1 Q30.5 R160.1 R216.1 R217.1 R226.2
+3.3V_MSATA_WWAN_U22: C425.1 PJP21.2 U22.8 U22.9
+3.3V_RTC_LDO: PD3.3 PR103.2
+3.3V_RUN: C61.1 C64.1 C67.1 C151.1 C152.1 C153.1 C154.1 C207.1 C210.1 C211.1 C212.1 C219.2 C224.2 C225.2 C226.2 C338.1 C341.2 C383.1 C406.2 C411.1 C453.1 C459.2 CC8.1 CC9.1 CC41.1 CC43.1 CC45.1 CC59.1 CD24.1 CD25.1 CD60.1 CD61.1 JDIMM1.199 JDIMM2.199 JEDP1.1 JUSH1.13 L35.1 PJP5.1 PJP8.1 PJP19.1 PJP400.1 PR400.1 PR516.2 PR519.1 PU500.20 PU500.21 Q1.3 Q3.3 Q120.2 Q120.5 Q121.2 QC1.2 QC1.5 R35.1 R67.1 R94.1 R122.1 R123.1 R161.1 R163.1 R212.1 R296.1 R299.1 R300.1 R301.1 R304.1 R331.2 R358.1 R360.1 R362.1 R376.1 R408.1 R460.1 R473.1 R475.2 R480.1 RC11.2 RC12.2 RC55.1 RC56.1 RC57.1 RC81.1 RC116.1 RC137.1 RC139.1 RC140.1 RC141.1 RC143.1 RC145.1 RC147.1 RC149.1 RC170.2 RC178.1 RC181.1 RC185.1 RC189.1 RC191.1 RC193.1 RC199.2 RC201.1 RC202.1 RC203.1 RC204.1 RC208.1 RC216.2 RC218.1 RC222.1 RC259.1 RC282.1 RC283.1 RC284.1 RC285.1 RC289.1 RC295.1 RD10.2 RP2.1 RP2.2 RP2.3 RP2.4 RP4.1 RP4.2 RP4.3 RP4.4 RP6.1 RP6.2 RP6.3 RP6.4 RP8.1 RP8.2 RP8.3 RP8.4 U19.12 U19.21 U19.34 U20.5 U26.5 U27.11 U27.13 U27.23 U27.42 U30.5 U31.6 U31.7 U49.14 U50.1 UC1.K14 UC1.K16 UC1.T9 UC1.U8 UC1.V8 UC1.W9 UC2.5 UC3.5 UC6.14
+3.3V_RUN_AIN: C213.1 C214.1 C215.1 L35.2 U27.9 U27.27
+3.3V_RUN_AUDIO: C118.1 C119.1 C120.1 C405.1 PJP25.1 R140.1 R150.1 R158.1 R159.1 U17.3 U17.9
+3.3V_RUN_AUDIO_U18: C139.1 PJP25.2 U18.8 U18.9
+3.3V_RUN_CARD: C227.1 C239.1 C240.1 JSD1.4 U27.22
+3.3V_RUN_TPM: C200.1 C201.1 C202.1 C203.1 C204.1 C384.1 PJP5.2 U25.5 U25.10 U25.19 U25.24
+3.3V_RUN_U46: C403.1 PJP19.2 U46.8 U46.9
+3.3V_RUN_VDDA: C13.1 C14.1 C15.1 C16.1 L2.1 U6.C10 U6.H5 U6.H12 U6.J4 U6.K6 U6.K7
+3.3V_RUN_VDDIO: C26.1 C27.1 C28.1 C29.1 L5.2 U6.C3 U6.C4 U6.C11 U6.C12 U6.K3 U6.K4 U6.K11 U6.K12
+3.3V_RUN_VMM: C34.1 C93.1 C97.1 L2.2 L5.1 PJP13.1 R40.2 R42.2 R44.2 R46.2 R49.2 R52.2 R53.2 R54.2 R56.1 R60.1 R64.1 R65.1 R69.2 R70.2 R72.2 R74.1 R91.2 U7.8 U11.14 U13.14
+3.3V_RUN_VMM_U31: C392.2 PJP13.2 U31.8 U31.9
+3.3V_SUS: C206.1 C414.1 C415.1 C416.1 C417.1 C418.1 C419.1 C420.1 JUSH1.8 JUSH1.9 JUSH1.10 PJP16.1 R190.1 R191.1 U33.3 U33.9 U33.12 U33.16 U33.20 U33.29
+3.3V_SUS_U45: C396.1 PJP16.2 U45.13 U45.14
+3.3V_TP: C374.1 JKBTP1.5 PJP8.2 R404.1 R405.1
+3.3V_TSP: C62.1 JEDP1.40 PJP10.1
+3.3V_TSP_Q: PJP10.2 Q1.1
+3.3V_VTR: C346.1 C352.1 R336.2 U38.A22
+3.3V_VTR_ADC: C347.1 C353.1 R490.2 U38.A58
+3.3V_WLAN: C257.1 C258.1 C259.1 C260.2 C261.2 C262.1 JMINI1.2 JMINI1.24 JMINI1.39 JMINI1.41 JMINI1.52 PJP23.1 Q22.2 Q22.5 Q30.2 R227.2 R228.2 R229.2
+3.3V_WLAN_U3: C422.1 PJP23.2 U3.8 U3.9
+5V_ALW: C3.1 C284.1 C285.1 C287.1 C288.1 C289.1 C446.1 C447.1 C453.2 JLED1.1 LED7.2 LED7.4 PC209.2 PC305.1 PC400.1 PC724.1 PC725.1 PD5.3 PJP101.2 PR11.1 PR202.1 PR526.2 PR727.2 PR843.2 PU2.8 PU11.12 PU111.5 PU300.7 PU400.6 Q15.3 Q16.3 R28.1 R243.2 R244.2 R411.1 R434.2 R445.1 U3.4 U18.1 U18.2 U18.4 U22.4 U31.4 U32.2 U32.3 U35.2 U35.3 U39.5 U43.4 U45.4 U46.1 U46.2 U46.4 U52.2 U52.3
+5V_ALW2: PC118.1 PU100.13
+5V_ALW_U41: C387.1 R411.2 U41.1
+5V_ALWP: PC115.1 PC116.1 PJP101.1 PL102.2 PR101.1 PU100.14
+5V_HDMI_DDC: D65.1 R470.2 R471.2 R472.2
+5V_RUN: C7.1 C208.1 C333.1 C376.1 D1.1 D65.2 JFAN1.1 JKBTP1.12 JUSH1.14 PC509.2 PJP18.1 PU501.2 R354.1 R355.1 R356.1 R357.1 R472.1 U48.1
+5V_RUN_AUDIO: L21.2 PJP24.1 R130.1
+5V_RUN_AUDIO_U18: C188.1 PJP24.2 U18.13 U18.14
+5V_RUN_U46: C400.1 PJP18.2 U46.13 U46.14
+5V_USB_CHG_PWR: C290.1 C291.1 JUSB1.1 U35.6 U35.7 U35.8
+DVDD_CORE: C121.1 U17.1
+GND_CHASSIS: C327.2 R277.2 R278.2 R279.2 R280.2
+V1.05S_APLLOPI: CC55.1 CC56.1 LC5.2 UC1.AA21 UC1.W21
+V1.05SP_B+: PC300.1 PC301.1 PC302.1 PC303.1 PJP300.2 PQ300.5
+VCC_CORE: C454.1 C458.1 C459.1 C460.1 PC900.1 PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC907.1 PC908.1 PC909.1 PC910.1 PC911.1 PC912.1 PC913.1 PC914.1 PC915.1 PC916.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PC924.1 PC925.1 PC926.1 PC927.1 PC928.1 PC929.1 PL500.1 RC250.1 UC1.AB57 UC1.AD57 UC1.AG57 UC1.C24 UC1.C28 UC1.C32 UC1.C36 UC1.C40 UC1.C44 UC1.C48 UC1.C52 UC1.C56 UC1.E23 UC1.E25 UC1.E27 UC1.E29 UC1.E31 UC1.E33 UC1.E35 UC1.E37 UC1.E39 UC1.E41 UC1.E43 UC1.E45 UC1.E47 UC1.E49 UC1.E51 UC1.E53 UC1.E55 UC1.E57 UC1.F24 UC1.F28 UC1.F32 UC1.F36 UC1.F40 UC1.F44 UC1.F48 UC1.F52 UC1.F56 UC1.F59 UC1.G23 UC1.G25 UC1.G27 UC1.G29 UC1.G31 UC1.G33 UC1.G35 UC1.G37 UC1.G39 UC1.G41 UC1.G43 UC1.G45 UC1.G47 UC1.G49 UC1.G51 UC1.G53 UC1.G55 UC1.G57 UC1.H23 UC1.J23 UC1.K23 UC1.K57 UC1.L22 UC1.M23 UC1.M57 UC1.P57 UC1.U57 UC1.W57
+VCC_PWR_SRC: PC503.2 PC731.1 PC732.1 PC734.1 PC735.1 PC736.1 PC738.1 PJP500.2 PL501.2 PR511.1 PU501.5
+VCCIO_OUT: RC242.1 UC1.A59
+VCCIOA_OUT: RC134.1 UC1.E20
+VDDA_AVDD1: C115.1 C117.1 L21.1 U17.27
+VDDA_AVDD2: C116.1 C150.1 R140.2 U17.38
+VDDA_PVDD: C122.1 C123.1 C128.1 C129.1 R130.2 U17.39 U17.45
GND: C1.2 C3.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C34.2 C42.2 C43.2 C50.2 C52.2 C61.2 C62.2 C63.2 C64.2 C65.2 C67.2 C68.2 C76.1 C85.1 C87.2 C88.2 C93.2 C97.2 C113.2 C114.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C132.2 C135.2 C136.2 C139.2 C141.2 C142.2 C144.2 C147.2 C148.2 C151.2 C152.2 C153.2 C154.2 C171.2 C177.2 C180.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.1 C190.1 C192.2 C193.2 C194.2 C198.2 C200.2 C201.2 C202.2 C203.2 C204.2 C206.2 C207.2 C208.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.1 C217.1 C218.1 C219.1 C220.1 C221.1 C222.1 C223.1 C224.1 C225.1 C226.1 C227.2 C228.2 C229.2 C230.1 C231.1 C232.1 C233.1 C234.1 C239.2 C240.2 C241.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.1 C261.1 C262.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C284.2 C285.2 C287.2 C288.2 C289.2 C290.2 C291.2 C310.2 C311.2 C316.2 C317.2 C318.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C327.1 C328.2 C329.2 C330.2 C331.2 C332.2 C333.2 C334.2 C336.2 C337.2 C338.2 C339.2 C340.2 C341.1 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C360.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C371.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C382.2 C383.2 C384.2 C386.2 C387.2 C388.1 C389.2 C390.2 C391.2 C392.1 C393.2 C394.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.1 C407.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C422.2 C425.2 C426.2 C427.2 C428.2 C429.2 C430.2 C431.2 C432.2 C433.2 C444.2 C445.2 C446.2 C447.2 C451.2 C455.1 C456.1 C457.1 CC1.1 CC2.1 CC3.1 CC4.1 CC5.2 CC6.1 CC7.1 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC13.2 CC14.1 CC15.1 CC16.2 CC17.2 CC18.2 CC19.2 CC20.2 CC21.2 CC22.2 CC24.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC68.2 CC71.2 CC72.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC81.2 CC82.2 CC90.2 CC91.2 CC149.2 CC450.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CE1.2 CE2.2 CE7.2 CE8.2 CE9.2 CMOS1.1 D1.2 D8.1 D15.3 D16.1 D17.3 D18.1 D20.1 D33.1 D34.3 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JDEG1.1 JDEG1.11 JDEG1.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.148 JDOCK1.151 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JEDP1.3 JEDP1.14 JEDP1.15 JEDP1.17 JEDP1.18 JEDP1.19 JEDP1.20 JEDP1.35 JEDP1.37 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JFAN1.4 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JKBTP1.1 JKBTP1.2 JKBTP1.8 JKBTP1.14 JKBTP1.15 JKBTP1.17 JKBTP1.18 JLED1.7 JLED1.8 JLOM1.14 JLOM1.15 JMDP1.1 JMDP1.7 JMDP1.8 JMDP1.13 JMDP1.14 JMDP1.19 JMDP1.21 JMDP1.22 JMDP1.23 JMDP1.24 JMEDIA.6 JMEDIA.7 JMEDIA.8 JMINI1.4 JMINI1.9 JMINI1.15 JMINI1.18 JMINI1.21 JMINI1.26 JMINI1.27 JMINI1.29 JMINI1.34 JMINI1.35 JMINI1.43 JMINI1.50 JMINI1.53 JMINI1.54 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JMINI3.4 JMINI3.9 JMINI3.15 JMINI3.18 JMINI3.21 JMINI3.26 JMINI3.27 JMINI3.29 JMINI3.34 JMINI3.35 JMINI3.37 JMINI3.40 JMINI3.50 JMINI3.53 JMINI3.54 JNFC1.1 JNFC1.7 JNFC1.12 JNFC1.16 JNFC1.17 JRTC1.2 JRTC1.3 JRTC1.4 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.17 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSD1.26 JSF1.1 JSF1.5 JSF1.6 JSH1.2 JSH1.3 JSH1.5 JSH1.10 JSH1.13 JSH1.14 JSPK1.5 JSPK1.6 JTAA1.18 JTAA1.20 JTAA1.21 JTAA1.22 JTAA1.23 JTAA1.24 JTAG1.2 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSH1.1 JUSH1.4 JUSH1.18 JUSH1.19 JUSH1.21 JUSH1.22 JXDP1.1 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 LED5.1 LED6.1 ME1.1 PBATT1.6 PBATT1.8 PBATT1.9 PBATT1.10 PBATT1.11 PC1.2 PC2.2 PC3.2 PC4.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC100.1 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC112.2 PC113.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC200.2 PC201.2 PC202.2 PC203.2 PC205.2 PC207.2 PC209.1 PC211.2 PC212.2 PC214.2 PC215.2 PC300.2 PC301.2 PC302.2 PC303.2 PC305.2 PC307.2 PC308.2 PC400.2 PC401.2 PC402.2 PC404.2 PC500.1 PC501.2 PC503.1 PC505.1 PC507.1 PC508.2 PC509.1 PC510.1 PC511.2 PC514.1 PC706.2 PC707.2 PC709.2 PC711.2 PC712.2 PC715.2 PC716.2 PC717.2 PC718.2 PC724.2 PC725.2 PC726.2 PC727.2 PC728.1 PC729.2 PC730.2 PC731.2 PC732.2 PC733.2 PC734.2 PC735.2 PC736.2 PC737.2 PC738.2 PC740.2 PC741.2 PC742.2 PC801.1 PC803.2 PC805.1 PC806.2 PC808.1 PC810.1 PC811.2 PC812.1 PC813.2 PC814.1 PC815.2 PC816.2 PC817.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC922.2 PC923.2 PC924.2 PC925.2 PC926.2 PC927.2 PC928.2 PC929.2 PD1.1 PD2.1 PD5.2 PD6.2 PJP1.2 PJP4.2 PJP701.2 PQ3.3 PQ6.6 PQ102.1 PQ102.2 PQ102.3 PQ103.1 PQ103.2 PQ103.3 PQ201.1 PQ201.2 PQ201.3 PQ301.1 PQ301.2 PQ301.3 PQ706.1 PQ706.2 PQ706.3 PQ710.1 PQ710.4 PQ712.1 PQ712.4 PQ802.1 PQ805.1 PQ805.4 PQ806.1 PQ806.4 PQ807.1 PQ807.4 PQ812.4 PQ813.1 PQ813.4 PQ816.3 PQ817.3 PQ818.3 PQ819.1 PQ819.4 PQ821.1 PQ821.4 PQ824.3 PQ824.6 PQ825.3 PQ827.3 PQ828.3 PQ831.3 PQ832.3 PR12.1 PR15.2 PR16.2 PR18.2 PR102.1 PR104.1 PR105.2 PR106.2 PR111.2 PR112.2 PR114.1 PR203.2 PR209.1 PR302.1 PR305.2 PR306.2 PR308.1 PR401.2 PR403.2 PR505.1 PR506.1 PR507.1 PR508.1 PR509.1 PR510.1 PR513.2 PR724.1 PR735.2 PR742.2 PR743.2 PR744.2 PR814.1 PR817.2 PR844.2 PR858.2 PR874.2 PU2.4 PU3.3 PU11.1 PU11.3 PU11.14 PU11.21 PU100.21 PU111.2 PU300.11 PU400.1 PU500.19 PU500.22 PU500.29 PU500.33 PU501.3 PU501.9 PU700.14 PU703.1 PU703.2 PU800.5 PU800.14 PU800.23 PU800.32 PU800.37 PU801.3 PU804.3 PU805.3 PU806.3 PU807.3 PU808.3 Q4.3 Q5.1 Q5.4 Q6.3 Q7.3 Q9.3 Q10.3 Q17.1 Q29.3 Q31.3 Q124.1 Q124.4 R25.2 R26.2 R27.2 R32.1 R37.1 R47.2 R50.1 R51.1 R63.2 R85.2 R92.2 R95.2 R96.2 R104.1 R108.2 R120.1 R121.1 R153.2 R164.1 R165.1 R167.2 R168.1 R175.1 R182.2 R184.2 R185.2 R186.2 R194.2 R195.1 R205.1 R207.2 R211.2 R214.2 R268.2 R271.2 R303.1 R305.1 R307.1 R309.1 R310.1 R311.2 R312.2 R313.1 R320.1 R321.2 R326.2 R342.1 R351.2 R366.1 R368.1 R369.1 R370.2 R371.1 R372.1 R373.1 R377.1 R383.2 R384.2 R394.2 R399.1 R438.2 R447.2 R474.2 R493.2 RC2.2 RC22.2 RC46.2 RC47.2 RC50.2 RC52.2 RC69.2 RC76.2 RC78.1 RC83.2 RC115.2 RC125.2 RC127.1 RC128.2 RC129.2 RC131.1 RC132.2 RC133.2 RC136.1 RC151.1 RC152.1 RC153.1 RC154.2 RC155.1 RC158.2 RC159.2 RC168.2 RC169.2 RC180.2 RC195.2 RC210.2 RC211.2 RC215.2 RC221.2 RC232.2 RC233.2 RC235.2 RC236.1 RC237.2 RC238.2 RC239.2 RC240.2 RC241.2 RC258.2 RC260.2 RC287.2 RC288.2 RC292.2 RD5.1 RD6.1 RD11.2 RP11.4 ST1.1(TP-1) ST2.1(TP-1) SW1.1 SW1.3 U1.4 U2.4 U3.11 U3.15 U5.3 U6.B13 U6.B14 U6.C5 U6.C13 U6.C14 U6.D4 U6.D5 U6.D6 U6.D7 U6.D8 U6.D9 U6.D10 U6.D11 U6.D13 U6.D14 U6.E4 U6.E11 U6.F4 U6.F5 U6.F6 U6.F7 U6.F8 U6.F9 U6.F10 U6.F11 U6.G4 U6.G5 U6.G6 U6.G7 U6.G8 U6.G9 U6.G10 U6.G11 U6.H4 U6.H10 U6.J5 U6.J6 U6.J7 U6.J8 U6.J9 U6.J11 U6.J12 U6.K5 U6.L6 U6.L7 U6.L8 U7.4 U9.2 U11.7 U13.7 U17.7 U17.42 U17.49 U18.11 U18.15 U19.1 U19.17 U19.22 U19.43 U20.3 U21.49 U22.11 U22.15 U23.43 U24.3 U25.1 U25.2 U25.3 U25.4 U25.8 U25.11 U25.18 U25.25 U26.3 U27.49 U29.3 U30.3 U31.11 U31.15 U32.1 U33.11 U33.21 U33.28 U33.33 U35.1 U36.5 U36.6 U37.B27 U37.C1 U38.B11 U38.B18 U38.B54 U38.B60 U38.B66 U38.C1 U39.9 U41.2 U42.3 U43.11 U43.15 U45.11 U45.15 U46.11 U46.15 U47.3 U48.2 U49.7 U50.2 U52.1 UC1.A11 UC1.A14 UC1.A18 UC1.A24 UC1.A28 UC1.A32 UC1.A36 UC1.A40 UC1.A44 UC1.A48 UC1.A52 UC1.A56 UC1.AA1 UC1.AA58 UC1.AB7 UC1.AB10 UC1.AB20 UC1.AB22 UC1.AC61 UC1.AD3 UC1.AD21 UC1.AD63 UC1.AE5 UC1.AE10 UC1.AE58 UC1.AF11 UC1.AF12 UC1.AF14 UC1.AF15 UC1.AF17 UC1.AF18 UC1.AG1 UC1.AG11 UC1.AG21 UC1.AG23 UC1.AG60 UC1.AG61 UC1.AG62 UC1.AG63 UC1.AH16 UC1.AH17 UC1.AH19 UC1.AH20 UC1.AH22 UC1.AH24 UC1.AH28 UC1.AH30 UC1.AH32 UC1.AH34 UC1.AH36 UC1.AH38 UC1.AH40 UC1.AH42 UC1.AH44 UC1.AH46 UC1.AH49 UC1.AH51 UC1.AH53 UC1.AH55 UC1.AH57 UC1.AJ13 UC1.AJ14 UC1.AJ23 UC1.AJ25 UC1.AJ27 UC1.AJ29 UC1.AJ35 UC1.AJ39 UC1.AJ41 UC1.AJ43 UC1.AJ45 UC1.AJ47 UC1.AJ50 UC1.AJ52 UC1.AJ54 UC1.AJ56 UC1.AJ58 UC1.AJ60 UC1.AJ63 UC1.AK3 UC1.AK23 UC1.AK52 UC1.AL10 UC1.AL13 UC1.AL17 UC1.AL20 UC1.AL22 UC1.AL23 UC1.AL26 UC1.AL29 UC1.AL31 UC1.AL33 UC1.AL36 UC1.AL39 UC1.AL40 UC1.AL45 UC1.AL46 UC1.AL51 UC1.AL52 UC1.AL54 UC1.AL57 UC1.AL60 UC1.AL61 UC1.AM1 UC1.AM17 UC1.AM23 UC1.AM31 UC1.AM52 UC1.AN7 UC1.AN17 UC1.AN23 UC1.AN31 UC1.AN32 UC1.AN35 UC1.AN36 UC1.AN39 UC1.AN40 UC1.AN42 UC1.AN43 UC1.AN45 UC1.AN46 UC1.AN48 UC1.AN49 UC1.AN51 UC1.AN52 UC1.AN60 UC1.AN63 UC1.AP3 UC1.AP10 UC1.AP17 UC1.AP20 UC1.AP22 UC1.AP23 UC1.AP26 UC1.AP29 UC1.AP31 UC1.AP38 UC1.AP39 UC1.AP48 UC1.AP52 UC1.AP54 UC1.AP57 UC1.AR5 UC1.AR11 UC1.AR15 UC1.AR17 UC1.AR23 UC1.AR31 UC1.AR33 UC1.AR39 UC1.AR43 UC1.AR49 UC1.AR52 UC1.AT13 UC1.AT35 UC1.AT37 UC1.AT40 UC1.AT42 UC1.AT43 UC1.AT46 UC1.AT49 UC1.AT61 UC1.AT62 UC1.AT63 UC1.AU1 UC1.AU16 UC1.AU18 UC1.AU20 UC1.AU22 UC1.AU24 UC1.AU26 UC1.AU28 UC1.AU30 UC1.AU33 UC1.AU51 UC1.AU53 UC1.AU55 UC1.AU57 UC1.AU59 UC1.AV8 UC1.AV14 UC1.AV16 UC1.AV20 UC1.AV24 UC1.AV28 UC1.AV33 UC1.AV34 UC1.AV36 UC1.AV39 UC1.AV41 UC1.AV43 UC1.AV46 UC1.AV49 UC1.AV51 UC1.AV55 UC1.AV59 UC1.AW4 UC1.AW16 UC1.AW24 UC1.AW33 UC1.AW35 UC1.AW37 UC1.AW40 UC1.AW42 UC1.AW44 UC1.AW47 UC1.AW50 UC1.AW51 UC1.AW59 UC1.AW60 UC1.AY4 UC1.AY6 UC1.AY11 UC1.AY16 UC1.AY18 UC1.AY22 UC1.AY24 UC1.AY26 UC1.AY30 UC1.AY33 UC1.AY51 UC1.AY53 UC1.AY57 UC1.AY59 UC1.B4 UC1.B20 UC1.B24 UC1.B26 UC1.B28 UC1.B32 UC1.B36 UC1.B40 UC1.B44 UC1.B48 UC1.B52 UC1.B56 UC1.B60 UC1.C11 UC1.C14 UC1.C18 UC1.C20 UC1.C25 UC1.C27 UC1.C38 UC1.C39 UC1.C57 UC1.D2 UC1.D5 UC1.D8 UC1.D12 UC1.D14 UC1.D18 UC1.D21 UC1.D23 UC1.D25 UC1.D26 UC1.D27 UC1.D29 UC1.D30 UC1.D31 UC1.D33 UC1.D34 UC1.D35 UC1.D37 UC1.D38 UC1.D39 UC1.D41 UC1.D42 UC1.D43 UC1.D45 UC1.D46 UC1.D47 UC1.D49 UC1.D50 UC1.D51 UC1.D53 UC1.D54 UC1.D55 UC1.D57 UC1.D59 UC1.D62 UC1.D63 UC1.E11 UC1.E17 UC1.F20 UC1.F26 UC1.F30 UC1.F34 UC1.F38 UC1.F42 UC1.F46 UC1.F50 UC1.F54 UC1.F58 UC1.F61 UC1.G3 UC1.G5 UC1.G6 UC1.G8 UC1.G18 UC1.G22 UC1.H13 UC1.H17 UC1.H57 UC1.J10 UC1.J22 UC1.J59 UC1.J63 UC1.K1 UC1.K12 UC1.L7 UC1.L13 UC1.L15 UC1.L17 UC1.L18 UC1.L20 UC1.L58 UC1.L61 UC1.M22 UC1.N3 UC1.N10 UC1.N21 UC1.P22 UC1.P59 UC1.P62 UC1.P63 UC1.R8 UC1.R10 UC1.R22 UC1.T1 UC1.T58 UC1.U9 UC1.U20 UC1.U22 UC1.U61 UC1.V3 UC1.V7 UC1.V10 UC1.V23 UC1.V58 UC1.W20 UC1.W22 UC1.Y10 UC1.Y59 UC1.Y63 UC2.3 UC3.3 UC4.3 UC6.7 UC6.15 UC7.3 Y1.2 Y1.4 Y3.2 Y3.4
GNDA: C115.2 C116.2 C117.2 C131.2 C137.2 C138.2 C140.2 C141.1 C142.1 C144.1 C150.2 C167.1 C169.2 C385.2 C408.2 C440.2 C441.2 C442.2 C443.2 D30.1 D31.1 D32.1 JHP1.7 PJP4.1 Q20.4 Q21.1 Q21.4 Q123.1 Q123.4 R39.2 R481.2 U17.26 U17.36
GNDA_CHG: PC703.1 PC705.2 PC708.2 PC719.1 PC720.1 PC722.2 PJP701.1 PR714.2 PR746.2 PU700.21
VCCSENSE: PR531.2 RC250.2 UC1.E63
VCCST_PWRGD: RC245.2 UC1.B59
VDD_1.35V: PC211.1 PR201.1 PR202.2 PU11.11
VSSSENSE: PR532.2 RC260.1 UC1.E62
3301_ACAV_IN_NB: PR855.1 PU800.24
3301_DSCHRG_FET_GC: PR821.2 PR841.1
3301_PWRSRC: PR877.1 PU800.15
+ALC290_LDO_CAP: C140.1 U17.21
+ALC3226_CPVEE: C138.1 U17.34
+ALC3226_VREF: C167.2 C169.1 U17.25
+AUX_LDO: C221.2 C222.2 U27.12
+BATT_SUM: PD800.2 PD800.3 PD806.1 PQ800.5 PQ800.6 PQ800.7 PQ800.8 PQ809.1 PQ809.2 PQ809.3 PQ815.5 PQ815.6 PQ815.7 PQ815.8 PR813.2
+BL_PWR_SRC: C52.1 C65.1 JEDP1.24 JEDP1.25 JEDP1.26 JEDP1.27 Q2.1 Q2.2 Q2.5 Q2.6
+CAP_LDO: C336.1 U37.B46
+CHGR_DC_IN: PR708.1 PR833.1
+COINCELL: JRTC1.1 JSH1.1 PR1.1
+DC1_PWR_SRC: PC101.1 PC102.1 PC103.1 PC104.1 PC105.1 PC106.1 PC107.1 PC108.1 PC117.1 PJP100.2 PL100.1 PQ100.5 PQ101.5 PU100.12
+DC_IN: PC5.2 PC11.1 PL4.2 PQ4.1 PQ4.2 PQ4.3 PQ6.3 PR14.1 PR16.1 PR737.1 PR835.1
+DC_IN_SS: PC6.1 PC7.1 PC8.1 PC10.1 PD701.3 PQ4.5 PQ700.5 PQ822.3 PR15.1 PR831.1 PR840.2
+DCIN: PC706.1 PR745.2 PU700.20
+DCIN_JACK: PC9.1 PD6.1 PJPDC1.2 PJPDC1.3 PL4.1
+DCPRRTC: CC36.1 UC1.AE7
+DIMM1_VREF_DQ: CD1.1 CD2.1 JDIMM1.1 RD1.2
+DIMM2_VREF_DQ: CD32.1 CD33.1 JDIMM2.1 RD7.2
+DOCK_PWR_BAR: C317.1 C318.1 CE7.1 D20.2 D20.3 JDOCK1.146 JDOCK1.147 JDOCK1.149 JDOCK1.150 PD701.2 PD808.2 PD808.3 PQ810.5 PQ810.6 PQ810.7 PQ810.8 PQ826.5 PR814.2 PR832.1
+LCDVDD: C63.1 C431.1 JEDP1.11 JEDP1.12 U9.1
+LOM_VCT: C316.1 JDOCK1.116 JDOCK1.118
+NBDOCK_DC_IN_SS: JDOCK1.41 PQ801.1 PQ814.3 PQ823.1 PR827.2
+PBATT: PL1.2 PL2.2 PQ811.1 PQ811.2 PQ811.3 PQ830.3 PR836.2 PR838.1
+PBATT_IN_SS: PD806.2 PD806.3 PD807.2 PQ809.5 PQ809.6 PQ809.7 PQ809.8 PQ811.5 PQ811.6 PQ811.7 PQ811.8 PR817.1
+PCH_ASATA3PLL: CC49.1 CC77.1 LC2.2 RC14.1 RC19.2 UC1.B11
+PCH_AUSB3PLL: CC42.1 CC76.1 LC1.2 RC161.1 RC163.1 UC1.B18
+PCH_DCPSUS: CC61.1 CC62.1 CC66.1 RC276.2 UC1.AH13 UC1.J13
+PCH_DCPSUS1: CC54.1 RC272.2 UC1.AD8 UC1.AD10
+PCH_DCPSUS4: CC53.1 CC75.1 LC4.2 UC1.AB8
+PCH_RTC_VCCSUS3_3: CC30.1 RC261.2 RC264.2 UC1.AH11
+PCH_VCC1P05: CC51.1 CC79.1 LC3.2 UC1.J18 UC1.K19
+PCH_VCCACLKPLL: CC58.1 CC78.1 LC6.2 RC45.2 UC1.A20
+PCH_VCCDSW: RC275.2 UC1.AG19 UC1.AG20
+PCH_VCCDSW3_3: CC32.1 JAPS1.3 JAPS1.7 RC71.1 RC197.2 RC206.2 RC265.2 RC267.2 RP9.3 RP9.4 UC1.AH10
+PCH_VCCDSW_R: CC65.1 RC275.1
+PECI_VREF: C360.1 R374.1 U38.B51
+PWR_SRC: C66.1 PC716.1 PC737.1 PJP100.1 PJP200.2 PJP300.1 PJP500.1 PL100.2 PL501.1 PL701.1 PR716.4 Q2.4 R97.1
+PWR_SRC_AC: PC803.1 PC806.1 PC807.1 PD808.1 PJP700.1 PL700.2 PQ810.1 PQ810.2 PQ810.3 PR700.1 PR877.2
+RSVD_VCC3P3_1: R178.2 U21.1
+RTC_CELL: CC35.1 CC38.1 CC39.1 PC1.1 PD3.1 R202.1 R327.1 R328.1 R332.1 R346.1 R347.1 RC1.1 RC6.1 RC7.1 RC8.1 RC73.2 UC1.AG10
+RTC_CELL_VBAT: C345.1 R332.2 U38.B64
+SD_IO_LDO: C216.2 C220.2 U27.25
+SDC_IN: PC700.1 PC733.1 PQ700.1 PQ700.2 PQ700.3 PR700.4 PR713.2 PR725.1 PR854.1 PU703.3
+SIM_PWR: JMINI2.8 JSH1.9
+SM_VREF_CA: CC67.1 RC68.2 UC1.AP49
+SM_VREF_CA_DIMM: RC67.2 RC68.1 RC69.1 RD12.2 RD13.2
+SM_VREF_CA_DIMM1: CD12.1 CD13.1 JDIMM1.126 RD12.1
+SM_VREF_CA_DIMM2: CD43.1 CD44.1 JDIMM2.126 RD13.1
+SM_VREF_DQ0: CC70.1 RC173.2 UC1.AR51
+SM_VREF_DQ0_DIMM1: RC173.1 RC217.2 RC221.1 RD1.1
+SM_VREF_DQ1: CC69.1 RC126.2 UC1.AP51
+SM_VREF_DQ1_DIMM2: RC126.1 RC130.2 RC132.1 RD7.1
+USB_PWR: C280.1 C281.1 JUSB2.1 U32.6 U32.7 U32.8
+USB_SIDE_PWR: C444.1 C445.1 JUSB3.1 U52.6 U52.7 U52.8
+V_DDR_REF: PC212.1 PU11.4
+VCHGR: PC715.1 PC717.1 PC718.1 PD800.1 PQ800.1 PQ800.2 PQ800.3 PR716.1
+VDISPLAY_VCC: C171.1 JMDP1.20 U50.3
+VHDMI_VCC: C87.1 C88.1 JHDMI1.18 U48.3
+VLDOIN_1.35V: PJP201.2 PU11.19
+VR_CAP: C366.1 U38.B12
+VREFOUT: C131.1 R187.2 R197.2 U17.23
-DCIN_JACK: PC12.1 PJP1.1 PJPDC1.4 PJPDC1.5
A_ON: PR304.1 R372.2 R424.1 U38.B24
AC_DIS: PQ6.5 PR828.1 U37.B12
AC_PRESENT: RP9.5 U38.A54 UC1.AJ8
ACAV_DOCK_SRC#: JDOCK1.42 PR846.2 PR847.1
ACAV_IN: PQ712.5 PR717.1 PR746.1 PR747.2 PR859.1 PR872.1 U38.A64
ACAV_IN#: PQ819.5 PQ825.1 PR820.2 PR864.2
ACAV_IN_NB: PR741.2 PR855.2 U38.B20
ACAVDK_SRC: PR847.2 PU800.4
ACAVIN: PR859.2 PU800.8
ALS_INT#: R281.2 U37.A46
ALW_PWRGD_3V_5V: PR108.1 U38.A1
ALWON: PR113.2 U38.A60
AUD_HP_NB_SENSE: C137.1 C408.1 D31.3 JHP1.6 Q20.5 R481.1 U37.A41
AUD_HP_OUT_L: L51.2 R162.2
AUD_HP_OUT_L1: C442.1 D32.3 JHP1.1 L51.1
AUD_HP_OUT_R: L52.2 R166.2
AUD_HP_OUT_R1: C441.1 D30.2 JHP1.2 L52.1
AUD_NB_MUTE#: C410.1 R150.2 R220.2 U17.47 U37.A39
AUD_OUT_L: R162.1 U17.33
AUD_OUT_R: R166.1 U17.32
AUD_PC_BEEP: C145.2 C146.2 U17.12
AUD_SENSE_A: R152.1 U17.13
AUD_SENSE_B: R156.1 R157.1 U17.14
AUX_EN_WOWL: R51.2 U3.5 U37.B67
B-RAMP: PR502.1 PR507.2 PU500.11
BAT1_LED#: Q23.1 R433.1 U37.B64
BAT1_LED#_Q: Q23.6 R431.1
BAT2_LED#: Q23.4 R429.1 U37.A9
BAT2_LED#_Q: Q23.3 R427.1
BATDRV#: PQ800.4 PR722.2
BATT_WHITE#: LED7.1 R427.2
BATT_WHITE_LED#: JLED1.2 R429.2
BATT_YELLOW#: LED7.3 R431.2
BATT_YELLOW_LED#: JLED1.3 R433.2
BAY_SMBCLK: R452.2 U38.A7
BAY_SMBDAT: R453.2 U38.B7
BBS_BIT: RC218.2 RC287.1 UC1.L8
BC_CLK_ECE1117: JKBTP1.7 U38.A20
BC_CLK_ECE5048: U37.A30 U38.A43
BC_DAT_ECE1117: JKBTP1.9 R344.2 U38.B21
BC_DAT_ECE5048: R343.2 U37.B31 U38.B45
BC_INT#_ECE1117: JKBTP1.10 U38.A19
BC_INT#_ECE5048: U37.A29 U38.A42
BCM5882_ALERT#: JUSH1.7 U37.B62
BEEP: R151.2 U38.B19
BIA_PWM: D10.1 LE1.2 R95.1
BIA_PWM_EC: D10.2 U38.B25
BLUE_DOCK: JDOCK1.45 R76.2 R351.1
BOARD_ID: C368.1 R392.2 U38.B10
BOOT_1.35V: PR200.2 PU11.18
BQ24715_REGN: PC709.1 PD702.2 PR711.1 PR739.1 PR747.1 PU700.16
BREATH_LED#: JDOCK1.98 Q28.1 R436.1 U37.B39
BREATH_LED#_Q: LED1.1 Q28.6
BREATH_WHITE_LED#: JLED1.5 R436.2
BREATH_WHITE_LED_SNIFF: LED1.2 R434.1
BST_3V: PR110.2 PU100.9
BST_5V: PR109.1 PU100.17
BST_+V1.05SP: PR301.1 PU300.10
BT_LED#: JMINI1.46 Q30.1 R229.1
BT_RADIO_DIS#: D14.1 R225.1 R298.2 U37.A13
BT_RADIO_DIS#_R: D14.2 JMINI1.51 R225.2
CAM_MIC_CBL_DET#: JEDP1.30 RC193.2 UC1.F4
CARD_SMBCLK: RP3.5 U38.A49
CARD_SMBDAT: RP3.8 U38.B52
CCD_OFF: R102.1 U37.B43
CD3301_DCIN: PC813.1 PR835.2 PU800.1
CD3301_SDC_IN: PR854.2 PU800.6
CD_PBATT_OFF: PR843.1 PU800.27
