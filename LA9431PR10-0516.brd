# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS2: length 91.8
  IN1 w0.084: v2(134.47,64.92) 134.23,64.68 134.1,64.68 133.89,64.48 133.89,62.36 135.62,60.64 135.62,59.93 137.03,58.53 137.03,51.41
  IN1 w0.114: 137.03,51.41 137.03,50.45 140.19,47.28 150.03,47.28 152.05,45.26 175.83,45.26 184.94,36.16 184.94,25.57 184.59,25.22 184.59,23.45 184.96,23.08 184.96,22.68 184.57,22.29 184.57,21 184.37,20.8 183.69,20.8 v2(183.45,21.04)
  BOTTOM w0.076: v2(134.47,64.92) 134.8,65.25 UC1.AM28
  BOTTOM w0.114: JDIMM2.154 184.3,18.77 184.15,18.93 184.15,19.47 184.64,19.97 184.64,20.57 184.35,20.86 183.63,20.86 v2(183.45,21.04)
DDR_B_DQS3: length 52.3
  IN4 w0.084: v2(136.38,64.92) 136.22,64.76 136.03,64.76 135.81,64.54 135.81,61.47 137.44,59.84 137.44,59 137.91,58.53 137.91,52.76 138.97,51.7 138.97,51.41
  IN4 w0.114: 138.97,51.41 138.97,43.73 139.27,43.43 140.72,43.43 140.84,43.32 140.84,42.98 140.72,42.86 139.27,42.86 138.99,42.58 138.99,42 139.27,41.72 140.72,41.72 140.84,41.6 140.84,41.26 140.72,41.15 139.27,41.15 138.99,40.86 138.99,40.28 139.27,40 140.72,40 140.84,39.89 140.84,35.24 144.2,31.88 144.2,31.06 143.79,30.65 143.79,29.06 144.08,28.76 144.27,28.76 v2(144.5,28.53)
  BOTTOM w0.076: UC1.AM25 136.7,65.25 v2(136.38,64.92)
  BOTTOM w0.114: v2(144.5,28.53) 144.27,28.76 144.02,28.76 143.89,28.63 143.89,27.69 144.21,27.37 144.21,27.1 144.4,26.91 JDIMM2.29
DDR_B_DQS4: length 87.5
  IN1 w0.084: v2(138.57,57.58) 139.32,57.58 139.54,57.36 139.54,53.29 141.42,51.41
  IN1 w0.114: v2(190.53,28.55) 190.3,28.55 189.83,29.02 189.83,35.32 189.74,35.4 189.74,36.98 188.93,37.79 188.93,38.19 188.96,38.21 188.96,38.39 188.74,38.62 188.56,38.62 188.53,38.59 188.13,38.59 187.37,39.35 187.37,39.75 187.79,40.18 187.79,40.34 187.55,40.58 187.39,40.58 186.96,40.16 186.56,40.16 186.15,40.57 186.15,40.97 186.58,41.39 186.58,41.55 186.33,41.8 186.17,41.8 185.75,41.37 185.35,41.37 184.94,41.78 184.94,42.18 185.36,42.61 185.36,42.77 185.12,43.01 184.96,43.01 184.53,42.59 184.13,42.59 183.72,43 183.72,43.4 184.15,43.82 184.15,43.98 183.9,44.23 183.74,44.23 183.32,43.8 182.92,43.8 182.49,44.23 182.49,44.77 182.83,45.11 182.83,45.35 179.23,48.95 153.77,48.95 151.75,50.97 141.86,50.97 141.42,51.41
  BOTTOM w0.076: UC1.AV22 138.31,61.81 137.92,61.42 137.92,61.4 137.85,61.26 137.85,61.06 137.88,61 137.92,60.9 137.92,60.77 137.85,60.61 137.85,60.41 137.88,60.36 137.88,60.35 137.92,60.25 137.92,60.06 137.81,59.95 137.81,59.33 138.13,59.01 138.13,58.01 v2(138.57,57.58)
  BOTTOM w0.114: v2(190.53,28.55) 190.47,28.61 189.34,28.61 189.23,28.5 189.23,27.28 189.4,27.1 JDIMM2.171
DDR_B_DQS5: length 48.6
  IN4 w0.084: v2(142.28,55.63) 142.07,55.42 141.88,55.42 141.61,55.15 141.61,52.79 142.7,51.7 142.7,51.43
  IN4 w0.114: 142.7,51.43 142.7,50.11 144.53,48.29 144.53,43.99 144.81,43.71 146.21,43.71 146.32,43.6 146.32,43.37 146.21,43.25 144.81,43.25 144.53,42.97 144.53,42.38 144.8,42.11 146.13,42.11 146.24,41.99 146.24,41.65 146.13,41.54 145.45,41.54 145.18,41.27 145.18,40.66 145.45,40.39 146.13,40.39 146.24,40.28 146.24,35.06 149.76,31.54 149.76,29.1 150.09,28.76 150.26,28.76 150.38,28.76 v2(150.61,28.53)
  BOTTOM w0.076: v2(142.28,55.63) 142.09,55.44 141.99,55.44 141.77,55.66 141.77,56.25 141.19,56.83 141.19,58.51 140.28,59.41 140.28,59.75 140.52,60 140.52,60.29 140.5,60.34 140.45,60.45 140.45,60.58 140.46,60.6 140.5,60.68 140.52,60.73 140.52,60.94 UC1.AW18
  BOTTOM w0.114: JDIMM2.47 149.8,26.97 149.62,27.16 149.62,27.87 149.25,28.24 149.25,28.54 149.64,28.93 150.38,28.93 150.61,28.7 v2(150.61,28.53)
DDR_B_DQS6: length 96.2
  IN1 w0.084: 143.88,58.07 143.87,58.08 143.87,58.1 143.11,58.86 143.11,59.11 140.98,61.25 140.15,61.25 139.71,61.69 139.39,61.69 138.55,62.53 138.55,64.6 138.58,64.63 138.76,64.81 138.93,64.81 v2(139.11,64.99)
  IN1 w0.114: 143.88,58.07 145.09,56.86 145.6,56.86 147.31,55.16 148.2,55.16 149.32,54.04 154.53,54.04 155.18,53.39 157.58,53.39 157.92,53.05 159.46,53.05 159.8,53.39 162.15,53.39 162.55,53 180.4,53 195.67,37.73 195.67,36.85 195.95,36.57 196.23,36.57 196.35,36.44 196.35,36.12 196.23,36 195.95,36 195.67,35.71 195.67,35.13 195.95,34.85 196.2,34.85 196.33,34.72 196.33,34.41 196.2,34.28 195.95,34.28 195.67,34 195.67,33.42 195.95,33.13 196,33.13 196.13,33.01 196.13,32.69 196,32.56 195.95,32.56 195.67,32.28 195.67,22.96 195.24,22.53 194.18,22.53 193.78,22.13 193.78,20.78 194.05,20.52 194.51,20.52 v2(194.74,20.28)
  BOTTOM w0.076: UC1.AM21 139.36,65.25 v2(139.11,64.99)
  BOTTOM w0.114: v2(194.74,20.28) 194.49,20.53 194.41,20.53 194.31,20.42 194.31,19.1 194.5,18.9 JDIMM2.188
DDR_B_DQS7: length 55.9
  IN4 w0.084: v2(141.04,64.92) 140.87,64.75 140.69,64.75 140.46,64.53 140.46,62.65 140.43,62.62 140.43,62.37 140.43,62.36 140.43,61.8 142.75,59.48 142.75,59.03 145.81,55.96 145.81,53.52 146.95,52.38 146.95,52.11
  IN4 w0.114: v2(155.14,21.1) 154.98,21.26 154.73,21.26 154.4,21.59 154.4,26.03 155.36,26.99 155.36,31.16 151.33,35.18 151.33,42.39 150.08,43.65 150.08,48.47 146.95,51.6 146.95,52.11
  BOTTOM w0.076: UC1.AM18 141.36,65.25 v2(141.04,64.92)
  BOTTOM w0.114: JDIMM2.64 154.9,18.73 154.62,19.01 154.62,21.16 154.75,21.29 154.95,21.29 v2(155.14,21.1)
DDR_B_DQS#0: length 84.4
  IN1 w0.084: v2(132.95,59.01) 132.95,58.87 133.13,58.69 133.95,58.69 134.21,58.43 134.21,52.91 133.61,52.32 133.61,51.43 133.63,51.42 133.63,51.41
  IN1 w0.114: 133.63,51.41 133.63,48.54 138.29,43.88 148.4,43.88 150.42,41.86 172.94,41.86 173.13,41.67 173.29,41.67 173.49,41.86 173.9,41.86 174.3,41.47 174.3,41.05 173.84,40.59 173.84,40.41 174.06,40.19 174.24,40.19 174.88,40.83 175.3,40.83 175.69,40.44 175.69,40.02 175.05,39.38 175.05,39.2 175.28,38.97 175.46,38.97 176.09,39.61 176.49,39.61 176.9,39.2 176.9,38.8 176.27,38.16 176.27,37.98 176.49,37.76 176.67,37.76 176.89,37.98 177.31,37.98 177.7,37.58 177.7,37.17 177.48,36.95 177.48,36.77 177.71,36.54 179.29,34.96 179.29,29.04 179.4,28.93 179.88,28.93 180.04,29.08 v2(180.04,29.31)
  BOTTOM w0.076: v2(132.95,59.01) 132.95,58.84 132.83,58.71 132.64,58.71 132.52,58.83 132.52,59.54 132.96,59.97 132.96,60.29 132.93,60.34 132.88,60.45 132.88,60.58 132.89,60.6 132.93,60.68 132.96,60.73 132.96,61.06 133.06,61.16 UC1.AW30
  BOTTOM w0.114: v2(180.04,29.31) 180.04,29.24 179.78,28.98 179.29,28.98 178.78,28.47 178.78,27.09 178.6,26.92 JDIMM2.135
DDR_B_DQS#1: length 49.4
  IN4 w0.084: v2(136.54,55.63) 136.23,55.93 136.05,55.93 135.56,55.44 135.56,51.41
  IN4 w0.114: 135.56,51.41 135.56,33.68 138.96,30.28 138.96,21.72 139.06,21.62 139.31,21.62 v2(139.54,21.86)
  BOTTOM w0.076: UC1.AV26 135.38,61.59 135.38,61.41 135.22,61.25 135.22,60.77 135.15,60.61 135.15,60.41 135.22,60.25 135.22,59.94 134.85,59.57 134.85,59.06 135.31,58.6 135.31,56.23 135.78,55.76 136.4,55.76 v2(136.54,55.63)
  BOTTOM w0.114: v2(139.54,21.86) 139.54,21.79 139.41,21.66 139.13,21.66 138.89,21.43 138.89,19.1 138.7,18.9 JDIMM2.10
DDR_B_DQS#2: length 92
  IN1 w0.084: 137.32,51.41 137.32,51.42 137.3,51.43 137.3,51.52 137.29,51.54 137.29,58.63 135.88,60.04 135.88,60.74 134.1,62.52 134.1,64.32 134.21,64.42 134.32,64.42 v2(134.47,64.27)
  IN1 w0.114: 137.32,51.41 137.32,50.57 140.31,47.57 150.15,47.57 152.17,45.55 175.95,45.55 185.23,36.28 185.23,25.45 184.88,25.1 184.88,23.57 185.25,23.19 185.25,22.56 184.86,22.17 184.86,20.89 184.49,20.52 183.45,20.52 183.35,20.41 183.35,20.38 v2(183.45,20.28)
  BOTTOM w0.076: UC1.AN28 134.8,64.6 v2(134.47,64.27)
  BOTTOM w0.114: v2(183.45,20.28) 183.45,20.5 183.57,20.62 184.26,20.62 184.41,20.47 184.41,20.06 183.91,19.57 183.91,18.96 183.7,18.75 JDIMM2.152
DDR_B_DQS#3: length 52.4
  IN4 w0.084: 139.26,51.41 139.26,51.42 139.24,51.43 139.24,51.52 139.23,51.54 139.23,51.8 138.17,52.87 138.17,58.63 137.7,59.1 137.7,59.95 136.1,61.54 136.01,61.54 136,61.55 136,64.45 136.11,64.56 136.27,64.56 136.38,64.45 v2(136.38,64.27)
  IN4 w0.114: v2(144.5,29.29) 144.5,29.16 144.4,29.05 144.2,29.05 144.08,29.18 144.08,30.53 144.49,30.94 144.49,32 141.13,35.36 141.13,40 140.84,40.29 139.39,40.29 139.28,40.4 139.28,40.74 139.39,40.86 140.84,40.86 141.13,41.14 141.13,41.72 140.84,42 139.39,42 139.28,42.12 139.28,42.46 139.39,42.58 140.84,42.58 141.13,42.86 141.13,43.44 140.84,43.72 139.39,43.72 139.26,43.85 139.26,51.41
  BOTTOM w0.076: v2(136.38,64.27) 136.38,64.42 136.55,64.6 UC1.AN25
  BOTTOM w0.114: JDIMM2.27 143.8,26.93 143.98,27.1 143.98,27.27 143.65,27.59 143.65,28.73 143.92,29 144.4,29 144.5,29.1 v2(144.5,29.29)
DDR_B_DQS#4: length 87.6
  IN1 w0.084: v2(138.57,58.23) 138.96,57.83 139.42,57.83 139.79,57.46 139.79,53.4 141.51,51.68 141.53,51.68 141.59,51.62 141.62,51.62 141.62,51.61
  IN1 w0.114: 141.62,51.61 141.98,51.26 151.87,51.26 153.88,49.24 179.35,49.24 183.12,45.47 183.12,45 182.78,44.65 182.78,44.35 183.04,44.09 183.2,44.09 183.62,44.51 184.02,44.51 184.43,44.1 184.43,43.7 184.01,43.28 184.01,43.12 184.25,42.87 184.41,42.87 184.84,43.3 185.24,43.3 185.65,42.89 185.65,42.49 185.23,42.06 185.23,41.9 185.47,41.66 185.63,41.66 186.05,42.08 186.45,42.08 186.86,41.67 186.86,41.27 186.44,40.85 186.44,40.69 186.68,40.44 186.84,40.44 187.27,40.87 187.67,40.87 188.08,40.46 188.08,40.06 187.66,39.63 187.66,39.47 188.25,38.88 188.41,38.88 188.44,38.9 188.86,38.9 189.25,38.51 189.25,38.09 189.22,38.07 189.22,37.9 190.03,37.09 190.03,35.52 190.12,35.44 190.12,29.14 190.31,28.95 190.44,28.95 190.53,29.04 v2(190.53,29.31)
  BOTTOM w0.076: v2(138.57,58.23) 138.4,58.23 138.3,58.33 138.3,59.08 137.97,59.4 137.97,59.88 138.09,60 138.09,60.29 138.07,60.34 138.02,60.45 138.02,60.58 138.02,60.6 138.07,60.68 138.09,60.73 138.09,60.94 138.02,61.1 138.02,61.23 138.07,61.33 138.1,61.36 138.23,61.36 138.31,61.29 UC1.AW22
  BOTTOM w0.114: JDIMM2.169 188.8,27.1 188.99,27.3 188.99,28.6 189.24,28.85 190.07,28.85 v2(190.53,29.31)
DDR_B_DQS#5: length 48.9
  IN4 w0.084: 142.99,51.5 142.99,51.51 142.96,51.54 142.96,51.8 141.87,52.9 141.87,55.04 141.98,55.16 142.09,55.16 v2(142.28,54.98)
  IN4 w0.114: 142.99,51.5 142.99,50.23 144.81,48.41 144.81,44.11 144.93,44 146.33,44 146.61,43.72 146.61,43.25 146.33,42.97 144.93,42.97 144.81,42.85 144.81,42.5 144.91,42.4 146.25,42.4 146.53,42.11 146.53,41.53 146.25,41.25 145.57,41.25 145.47,41.15 145.47,40.78 145.57,40.68 146.25,40.68 146.53,40.4 146.53,35.17 150.04,31.66 150.04,29.22 150.21,29.05 150.38,29.05 v2(150.61,29.29)
  BOTTOM w0.076: UC1.AV18 140.51,61.59 140.51,61.35 140.36,61.19 140.36,60.77 140.28,60.61 140.28,60.41 140.36,60.25 140.36,60.06 140.11,59.82 140.11,59.35 141.02,58.44 141.02,56.74 141.59,56.17 141.59,55.58 141.92,55.26 141.99,55.26 v2(142.28,54.98)
  BOTTOM w0.114: JDIMM2.45 149.2,26.97 149.4,27.17 149.4,27.78 149.03,28.15 149.03,28.63 149.55,29.15 150.47,29.15 v2(150.61,29.29)
DDR_B_DQS#6: length 96.2
  IN1 w0.084: 144.09,58.27 144.07,58.29 144.05,58.29 143.37,58.97 143.37,59.22 141.08,61.51 140.26,61.51 139.81,61.95 139.5,61.95 138.76,62.69 138.76,64.45 138.86,64.55 139.05,64.55 139.19,64.42 139.19,64.3 v2(139.13,64.24)
  IN1 w0.114: 144.09,58.27 145.21,57.15 145.72,57.15 147.43,55.44 148.32,55.44 149.43,54.32 154.65,54.32 155.3,53.68 157.7,53.68 158.04,53.33 159.34,53.33 159.69,53.68 162.27,53.68 162.67,53.28 180.52,53.28 195.96,37.85 195.96,36.97 196.07,36.85 196.35,36.85 196.64,36.56 196.64,36 196.35,35.71 196.07,35.71 195.96,35.59 195.96,35.25 196.07,35.14 196.32,35.14 196.62,34.84 196.62,34.29 196.32,33.99 196.07,33.99 195.96,33.88 195.96,33.53 196.07,33.42 196.12,33.42 196.41,33.13 196.41,32.57 196.12,32.27 196.07,32.27 195.96,32.16 195.96,22.84 195.36,22.24 194.3,22.24 194.07,22.01 194.07,20.9 194.17,20.8 194.67,20.8 194.74,20.88 v2(194.74,21.04)
  BOTTOM w0.076: v2(139.13,64.24) 139.49,64.6 UC1.AN21
  BOTTOM w0.114: v2(194.74,21.04) 194.74,20.81 194.68,20.74 194.32,20.74 194.09,20.51 194.09,19.09 193.9,18.9 JDIMM2.186
DDR_B_DQS#7: length 56
  IN4 w0.084: 147.2,52.17 147.2,52.49 146.07,53.62 146.07,56.07 143,59.14 143,59.59 140.69,61.91 140.69,62.62 140.66,62.65 140.66,64.45 140.77,64.56 140.96,64.56 141.04,64.48 v2(141.04,64.27) ; 147.2,51.75 147.22,51.73
  IN4 w0.114: 147.2,52.17 147.2,51.75 ; v2(155.14,21.86) 155.14,21.64 155.05,21.55 154.84,21.55 154.68,21.71 154.68,25.91 155.64,26.87 155.64,31.28 151.62,35.3 151.62,42.51 150.36,43.77 150.36,48.59 147.33,51.62 147.22,51.73
  BOTTOM w0.076: v2(141.04,64.27) 141.36,64.6 UC1.AN18
  BOTTOM w0.114: v2(155.14,21.86) 155.14,21.58 155.07,21.5 154.68,21.5 154.66,21.52 154.65,21.52 154.39,21.26 154.39,18.95 154.3,18.86 JDIMM2.62
DDR_B_MA0: length 83
  IN1 w0.084: v2(126.75,63.62) 126.31,63.62 126.05,63.36 125.48,63.36 125.26,63.14 125.26,54.92 123.43,53.1 123.43,51.41
  IN1 w0.132: v2(167.95,20.71) 168.37,21.13 168.37,23.49 167.56,24.3 167.56,24.52 167.11,24.97 167.11,25.46 165.84,26.73 165.84,30.55 164.72,31.67 159.27,31.67 158.02,32.92 136.86,32.92 123.43,46.35 123.43,51.41
  BOTTOM w0.076: v2(126.75,63.62) 127.08,63.95 UC1.AP40
  BOTTOM w0.17: JDIMM2.98 167.5,19.24 167.38,19.37 167.38,20.14 v2(167.95,20.71)
DDR_B_MA1: length 84.3
  IN1 w0.084: v2(126.75,62.97) 126.62,62.97 125.71,62.06 125.71,54.31 124.2,52.81 124.2,51.41
  IN1 w0.132: 124.2,51.41 124.2,46.74 137.25,33.7 158.91,33.7 159.04,33.57 159.04,32.99 159.17,32.87 159.45,32.87 159.58,32.99 159.58,33.63 159.71,33.76 159.99,33.76 160.12,33.63 160.12,32.57 160.25,32.44 160.53,32.44 160.66,32.57 160.66,33.57 160.78,33.7 161.07,33.7 161.2,33.57 161.2,32.57 161.32,32.44 161.61,32.44 161.73,32.57 161.73,33.63 161.86,33.76 162.14,33.76 162.27,33.63 162.27,32.57 162.4,32.44 162.68,32.44 162.81,32.57 162.81,33.63 162.94,33.76 163.22,33.76 163.35,33.63 163.35,32.57 163.48,32.44 163.76,32.44 163.89,32.57 163.89,33.57 164.01,33.7 164.3,33.7 164.43,33.57 164.43,32.64 164.62,32.44 165.49,32.44 167.45,30.48 167.45,29.82 167.33,29.69 v2(166.85,29.69)
  BOTTOM w0.076: v2(126.75,62.97) 127.08,63.3 UC1.AR40
  BOTTOM w0.17: JDIMM2.97 167.2,27.09 167.33,27.22 167.33,29.21 v2(166.85,29.69)
DDR_B_MA2: length 86.5
  IN1 w0.084: v2(125.86,63.77) 125.51,64.11 124.51,64.11 124.38,63.98 124.38,62.87 124.96,62.29 124.96,59.01 124.79,58.85 124.79,54.7 122.99,52.9 122.99,51.41
  IN1 w0.132: v2(167.95,22.24) 167.95,22 167.82,21.88 167.25,21.88 167.12,22 167.12,23.14 167.26,23.27 167.51,23.27 167.64,23.4 167.64,23.67 167.51,23.8 167.26,23.8 167.12,23.93 167.12,24.41 166.08,25.46 166.08,25.64 166.14,25.71 166.14,25.89 165.95,26.08 165.77,26.08 165.7,26.02 165.52,26.02 165.23,26.31 165.23,26.53 165.46,26.76 165.46,27.03 165.23,27.25 165.23,30.62 164.56,31.29 159.11,31.29 157.86,32.54 136.7,32.54 122.99,46.25 122.99,51.41
  BOTTOM w0.076: v2(125.86,63.77) 126.04,63.95 UC1.AP42
  BOTTOM w0.17: JDIMM2.96 166.9,21.19 v2(167.95,22.24)
DDR_B_MA3: length 86
  IN1 w0.084: v2(125.78,62.98) 125.46,62.66 125.46,54.89 123.82,53.24 123.82,51.41
  IN1 w0.132: v2(166.85,28.17) 167.33,28.17 167.45,28.04 167.45,27.43 167.58,27.3 168.99,27.3 169.12,27.17 169.12,25.34 168.99,25.22 168.7,25.22 168.58,25.34 168.58,26.63 168.45,26.76 168.17,26.76 168.04,26.63 168.04,25.13 167.91,25 167.63,25 167.5,25.13 167.5,26.63 167.37,26.76 166.36,26.76 166.23,26.89 166.23,31.16 165.33,32.06 159.43,32.06 158.18,33.31 137.02,33.31 123.82,46.51 123.82,51.41
  BOTTOM w0.076: v2(125.78,62.98) 126.01,62.98 UC1.AR42
  BOTTOM w0.17: v2(166.85,28.17) 166.39,27.7 166.39,27.21 166.6,27 JDIMM2.95
DDR_B_MA4: length 90.7
  IN1 w0.084: v2(123.96,63.08) 123.96,59.54 124.6,58.9 124.6,54.76 122.52,52.68 122.52,51.41
  IN1 w0.132: v2(165.71,22.24) 165.94,22.24 166.13,22.04 166.13,19.45 166.26,19.32 166.61,19.32 166.74,19.45 166.74,19.63 166.87,19.76 167.4,19.76 167.52,19.88 167.52,20.16 167.4,20.29 166.87,20.29 166.74,20.42 166.74,20.69 166.87,20.82 167.47,20.82 167.6,20.95 167.6,21.22 167.47,21.35 166.87,21.35 166.74,21.48 166.74,22.58 166.55,22.77 166.37,22.77 166.24,22.9 166.24,24.75 164.84,26.15 164.84,30.46 164.4,30.9 158.95,30.9 157.7,32.15 136.54,32.15 122.52,46.17 122.52,51.41
  BOTTOM w0.076: v2(123.96,63.08) 124.18,63.3 UC1.AR45
  BOTTOM w0.17: v2(165.71,22.24) 166.24,21.71 166.24,19.75 165.7,19.21 JDIMM2.92
DDR_B_MA5: length 89.4
  IN1 w0.084: v2(123.98,63.71) 123.98,63.72 123.85,63.84 123.5,63.84 123.37,63.72 123.37,62.39 123.5,62.26 123.61,62.26 123.73,62.14 123.73,59.47 124.41,58.79 124.41,54.81 122.13,52.53 122.13,51.41
  IN1 w0.132: 122.13,51.41 122.13,46.01 125.15,43 125.15,42.82 124.86,42.54 124.86,42.36 125.05,42.17 125.24,42.17 125.53,42.46 125.69,42.46 125.98,42.17 125.98,41.99 125.26,41.27 125.26,41.08 125.46,40.89 125.64,40.89 126.36,41.6 126.54,41.6 126.74,41.4 126.74,41.22 126.02,40.5 126.02,40.32 126.22,40.12 126.4,40.12 127.12,40.84 127.3,40.84 127.5,40.64 127.5,40.46 126.75,39.71 126.75,39.53 126.96,39.33 127.13,39.33 127.88,40.08 128.06,40.08 128.26,39.88 128.26,39.7 126.93,38.36 126.93,38.18 127.13,37.98 127.31,37.98 128.65,39.32 128.83,39.32 129.03,39.12 129.03,38.94 127.69,37.6 127.69,37.42 127.89,37.22 128.07,37.22 129.41,38.56 129.59,38.56 136.38,31.76 157.54,31.76 158.79,30.51 163.59,30.51 164.25,29.85 v2(164.25,29.69)
  BOTTOM w0.076: UC1.AP45 124.22,63.95 v2(123.98,63.71)
  BOTTOM w0.17: v2(164.25,29.69) 165.4,28.54 JDIMM2.91
DDR_B_MA6: length 94.1
  IN1 w0.084: v2(122.96,60.48) 122.85,60.59 122.73,60.59 122.6,60.46 122.6,59.68 122.82,59.46 123.15,59.46 124.03,58.58 124.03,55.12 121.26,52.35 121.26,51.41
  IN1 w0.132: v2(165.71,20.71) 164.61,20.71 164.47,20.85 164.47,21.68 164.6,21.81 165.05,21.81 165.18,21.94 165.18,22.22 165.05,22.35 164.6,22.35 164.47,22.48 164.47,22.76 164.6,22.89 165.05,22.89 165.18,23.02 165.18,23.3 165.05,23.43 164.6,23.43 164.47,23.56 164.47,26.06 160.78,29.74 158.47,29.74 157.22,30.99 136.06,30.99 135.07,31.98 134.78,31.98 133.96,31.16 133.5,30.7 133.32,30.7 133.12,30.9 133.12,31.08 134.45,32.42 134.45,32.6 134.25,32.8 134.07,32.8 132.74,31.47 132.55,31.47 132.36,31.66 132.36,31.85 133.69,33.18 133.69,33.36 133.49,33.56 133.31,33.56 131.98,32.23 131.79,32.23 131.53,32.49 131.53,32.68 132.27,33.43 132.27,33.61 132.09,33.8 131.9,33.8 131.15,33.05 130.97,33.05 126,38.02 126,39.25 121.26,43.99 121.26,51.41
  BOTTOM w0.076: UC1.AW46 123.32,60.84 v2(122.96,60.48)
  BOTTOM w0.17: JDIMM2.90 165.1,20.1 v2(165.71,20.71)
DDR_B_MA7: length 95.8
  IN1 w0.084: v2(123,59.08) 123.28,59.08 123.86,58.5 123.86,58.3 123.77,58.22 123.5,58.22 123.41,58.12 123.41,57.98 123.5,57.88 123.77,57.88 123.86,57.8 123.86,57.63 123.77,57.55 123.54,57.55 123.46,57.46 123.46,57.3 123.54,57.21 123.77,57.21 123.86,57.13 123.86,55.19 120.87,52.21 120.87,51.41
  IN1 w0.132: v2(163.01,22.24) 163.31,22.24 163.43,22.11 163.43,21.31 163.56,21.18 163.95,21.18 164.08,21.31 164.08,25.9 160.62,29.36 158.31,29.36 157.66,30.01 157.28,30.01 157.15,30.14 157.15,30.48 157.02,30.61 156.67,30.61 156.55,30.48 156.55,29.12 156.42,28.99 156.14,28.99 156.01,29.12 156.01,30.48 155.88,30.61 155.6,30.61 155.47,30.48 155.47,29.06 155.34,28.93 155.06,28.93 154.93,29.06 154.93,30.48 154.81,30.61 154.06,30.61 153.93,30.48 153.93,29.12 153.81,28.99 153.52,28.99 153.4,29.12 153.4,30.48 153.27,30.61 152.98,30.61 152.86,30.48 152.86,29.12 152.73,28.99 152.45,28.99 152.32,29.12 152.32,30.48 152.19,30.61 135.99,30.61 135.19,29.81 133.67,29.81 132.47,31 131.36,31 130.69,31.67 130.69,32.79 125.61,37.86 125.61,39.09 120.87,43.83 120.87,51.41
  BOTTOM w0.076: UC1.AY46 123.38,59.46 v2(123,59.08)
  BOTTOM w0.17: v2(163.01,22.24) 164,21.25 164,19.18 163.9,19.08 JDIMM2.86
DDR_B_MA8: length 93.1
  IN1 w0.084: 121.7,51.41 121.7,52.34 124.22,54.86 124.22,58.66 123.05,59.84 v2(122.97,59.84)
  IN1 w0.132: 121.7,51.41 121.7,45.9 122.03,45.57 122.03,45.39 121.77,45.13 121.77,44.94 121.96,44.76 122.14,44.76 122.4,45.01 122.59,45.01 122.77,44.82 122.77,44.64 122.52,44.38 122.52,44.2 122.7,44.01 122.89,44.01 123.15,44.26 123.33,44.26 124.48,43.12 124.48,41.32 126.39,39.41 126.39,38.18 127.98,36.58 128.17,36.58 129.5,37.92 129.68,37.92 129.88,37.71 129.88,37.54 128.55,36.2 128.55,36.02 128.74,35.82 128.93,35.82 130.26,37.15 130.44,37.15 130.64,36.95 130.64,36.77 129.31,35.44 129.31,35.25 129.51,35.06 129.69,35.06 131.03,36.39 131.2,36.39 131.41,36.19 131.41,36.01 130.07,34.68 130.07,34.49 130.27,34.3 130.46,34.3 131.79,35.63 131.97,35.63 132.22,35.38 132.22,35.19 131.59,34.56 131.59,34.38 131.78,34.19 131.96,34.19 132.59,34.82 132.78,34.82 132.97,34.63 132.97,34.44 132.82,34.3 132.82,34.12 133.02,33.93 133.2,33.93 133.34,34.07 133.53,34.07 136.22,31.38 157.38,31.38 158.63,30.13 161.55,30.13 161.68,30 161.68,29.4 161.8,29.27 162.09,29.27 162.21,29.4 162.21,30 162.34,30.13 162.63,30.13 162.75,30 162.75,28.32 162.88,28.19 163.16,28.19 163.29,28.32 163.29,29.56 163.42,29.69 163.7,29.69 163.83,29.56 163.83,28.29 163.96,28.17 v2(164.25,28.17)
  BOTTOM w0.076: UC1.AY47 122.62,60.19 v2(122.97,59.84)
  BOTTOM w0.17: JDIMM2.89 164.8,27.88 164.52,28.17 v2(164.25,28.17)
DDR_B_MA9: length 97.3
  IN1 w0.084: 120.49,51.41 120.49,52.07 123.68,55.26 123.68,56.75 v2(123.02,57.41)
  IN1 w0.132: 120.49,51.41 120.49,43.66 125.23,38.92 125.23,37.7 130.3,32.63 130.3,31.51 131.2,30.61 132.31,30.61 133.51,29.42 135.35,29.42 136.15,30.22 143.96,30.22 144.08,30.09 144.08,27.06 144.21,26.93 154.75,26.93 154.88,27.06 154.88,28.1 155.01,28.23 155.28,28.23 155.41,28.1 155.41,27.06 155.54,26.93 155.88,26.93 156.01,27.06 156.01,28.1 156.13,28.23 156.42,28.23 156.55,28.1 156.55,27.06 156.67,26.93 157.39,26.93 157.52,27.07 157.52,29.06 157.65,29.19 157.93,29.19 158.06,29.06 158.06,27.07 158.19,26.93 158.47,26.93 158.6,27.07 158.6,28.8 158.73,28.93 159.01,28.93 159.14,28.8 159.14,27.07 159.27,26.93 159.54,26.93 159.68,27.07 159.68,28.8 159.81,28.93 160.08,28.93 160.22,28.8 160.22,27.07 160.35,26.93 162.5,26.93 163.64,25.79 163.64,24.39 v2(163.01,23.76)
  BOTTOM w0.076: v2(123.02,57.41) 122.41,58.02 122.41,59.5 122.09,59.81 122.09,61.63 122.16,61.7 122.16,62.21 122.38,62.43 122.64,62.43 122.76,62.3 123.26,62.3 UC1.AU46
  BOTTOM w0.17: v2(163.01,23.76) 163.6,24.35 JDIMM2.85
DDR_B_MA10: length 99.4
  IN1 w0.084: v2(129.18,66.38) 128.8,66 128.8,57.48 128.58,57.26 128.58,56.92 128.66,56.84 129,56.84 129.08,56.76 129.08,56.59 129,56.51 128.66,56.51 128.58,56.42 128.58,56.25 128.66,56.17 129,56.17 129.08,56.09 129.08,55.92 129,55.84 128.66,55.84 128.58,55.75 128.58,53.56 128.03,53.02 128.03,51.41
  IN1 w0.132: 128.03,51.41 128.03,47.01 136.17,38.87 138.37,38.87 138.49,38.74 138.49,38.14 138.62,38.01 138.9,38.01 139.03,38.14 139.03,38.74 139.16,38.87 139.44,38.87 139.57,38.74 139.57,36.3 139.7,36.17 139.98,36.17 140.11,36.3 140.11,38.74 140.24,38.87 140.52,38.87 140.65,38.74 140.65,36.3 140.77,36.17 141.06,36.17 141.19,36.3 141.19,38.74 141.31,38.87 141.6,38.87 141.72,38.74 141.72,36.3 141.85,36.17 142.14,36.17 142.26,36.3 142.26,38.74 142.39,38.87 142.67,38.87 142.8,38.74 142.8,36.3 142.93,36.17 166.55,36.17 167.13,35.59 167.32,35.59 167.88,36.15 168.06,36.15 168.26,35.94 168.26,35.76 167.7,35.2 167.7,35.02 167.89,34.82 168.08,34.82 168.64,35.38 168.82,35.38 169.02,35.18 169.02,35 168.46,34.44 168.46,34.26 170.73,31.98 170.73,30.18 v2(171.22,29.69)
  BOTTOM w0.076: v2(129.18,66.38) 129.35,66.55 UC1.AK36
  BOTTOM w0.17: JDIMM2.107 170.2,28.67 v2(171.22,29.69)
DDR_B_MA11: length 96.4
  IN1 w0.084: v2(123.02,57.97) 122.61,57.55 122.61,55.43 120.1,52.92 120.1,51.41
  IN1 w0.132: v2(163.01,20.71) 162.56,21.16 162.56,26.16 162.17,26.55 143.7,26.55 143.56,26.68 143.56,29.12 143.44,29.25 143.15,29.25 143.03,29.12 143.03,26.68 142.89,26.55 142.21,26.55 142.08,26.68 142.08,28.87 141.95,28.99 141.67,28.99 141.54,28.87 141.54,26.68 141.41,26.55 141.13,26.55 141,26.68 141,28.93 140.87,29.06 140.59,29.06 140.46,28.93 140.46,26.68 140.33,26.55 137.48,26.55 137.35,26.67 137.35,29.69 137.21,29.83 136.31,29.83 135.51,29.04 133.35,29.04 132.15,30.23 131.04,30.23 129.91,31.35 129.91,32.47 124.84,37.54 124.84,38.76 120.1,43.5 120.1,51.41
  BOTTOM w0.076: v2(123.02,57.97) 122.57,58.42 122.57,59.68 122.26,60 122.26,61.19 UC1.AV47
  BOTTOM w0.17: JDIMM2.84 163.3,19.23 163.57,19.5 163.57,20.15 v2(163.01,20.71)
DDR_B_MA12: length 92.6
  IN1 w0.084: 119.72,51.41 119.72,52.78 122.38,55.44 122.38,61.48 122.84,61.93 v2(122.98,61.93)
  IN1 w0.132: 119.72,51.41 119.72,43.34 124.46,38.6 124.46,37.38 129.53,32.31 129.53,31.19 130.88,29.84 131.99,29.84 133.19,28.65 133.63,28.65 133.75,28.52 133.75,28.08 133.88,27.95 134.17,27.95 134.29,28.08 134.29,28.52 134.42,28.65 134.7,28.65 134.83,28.52 134.83,27 134.96,26.88 135.24,26.88 135.37,27 135.37,28.52 135.5,28.65 135.78,28.65 135.91,28.52 135.91,26.29 136.04,26.16 136.32,26.16 136.45,26.29 136.45,29.32 136.57,29.45 136.84,29.45 136.97,29.32 136.97,26.29 137.09,26.16 162.01,26.16 162.14,26.03 162.14,22.36 162.01,22.24 v2(161.19,22.24)
  BOTTOM w0.076: UC1.AU47 122.8,62.14 122.99,61.95 122.99,61.93 v2(122.98,61.93)
  BOTTOM w0.17: JDIMM2.83 163,25.15 162.48,24.63 162.48,23.53 v2(161.19,22.24)
DDR_B_MA13: length 101.1
  IN1 w0.084: 129.98,51.41 129.98,53.25 130.04,53.31 130.04,56.47 130.58,57.01 130.58,57.53 131.48,58.42 131.48,65.89 v2(131.08,66.29)
  IN1 w0.132: v2(174.8,29.69) 174.8,29.46 174.68,29.33 174.44,29.33 174.18,29.59 174.18,30.9 174.31,31.04 175.39,31.04 175.52,31.16 175.52,31.44 175.39,31.56 174.31,31.56 174.18,31.7 174.18,31.96 174.31,32.09 175.39,32.09 175.52,32.22 175.52,32.49 175.39,32.62 174.31,32.62 174.02,32.92 174.02,33.1 174.56,33.65 174.75,33.65 175.04,33.35 175.22,33.35 175.43,33.55 175.43,33.73 175.13,34.03 175.13,34.22 175.31,34.4 175.31,34.58 175.12,34.77 174.94,34.77 173.64,33.48 173.46,33.48 173.27,33.66 173.27,33.85 174.57,35.15 174.57,35.33 174.37,35.52 174.19,35.52 172.9,34.22 172.71,34.22 172.52,34.41 172.52,34.6 173.18,35.25 173.18,35.39 172.95,35.62 172.8,35.62 172.15,34.97 171.96,34.97 171.78,35.16 171.78,35.34 172.4,35.97 172.4,36.12 172.17,36.35 172.03,36.35 171.4,35.72 171.22,35.72 171.03,35.9 171.03,36.09 171.68,36.75 171.68,36.89 171.45,37.12 171.31,37.12 170.65,36.47 170.47,36.47 170.28,36.65 170.28,36.84 171.2,37.76 171.2,37.94 171.01,38.14 170.83,38.14 169.91,37.21 169.72,37.21 168.83,38.1 152.6,38.1 151.92,38.78 149.15,38.78 147.13,40.8 136.97,40.8 129.98,47.79 129.98,51.41
  BOTTOM w0.076: UC1.AK33 131.35,66.55 v2(131.08,66.29)
  BOTTOM w0.17: JDIMM2.119 173.8,28.69 v2(174.8,29.69)
DDR_B_MA14: length 97.9
  IN1 w0.084: v2(122.94,63.1) 122.94,62.55 122.56,62.17 121.24,62.17 121.02,61.94 121.02,60.94 121.21,60.74 121.65,60.74 121.97,60.43 121.97,56.7 118.94,53.67 118.94,51.41
  IN1 w0.132: v2(161.19,20.71) 160.77,21.13 160.77,25.26 160.64,25.39 158.48,25.39 158.35,25.26 158.35,24.33 158.22,24.2 148.55,24.2 148.43,24.33 148.43,25.26 148.3,25.39 148.01,25.39 147.89,25.26 147.89,24.33 147.76,24.2 147.48,24.2 147.35,24.33 147.35,25.26 147.22,25.39 146.94,25.39 146.81,25.26 146.81,24.33 146.68,24.2 146.4,24.2 146.27,24.33 146.27,25.26 146.14,25.39 145.86,25.39 145.73,25.26 145.73,24.33 145.61,24.2 145.32,24.2 145.19,24.33 145.19,25.26 145.07,25.39 144.78,25.39 144.66,25.26 144.66,24.57 144.53,24.45 144.24,24.45 144.12,24.57 144.12,25.26 143.99,25.39 143.42,25.39 143.29,25.26 143.29,24.33 143.16,24.2 142.88,24.2 142.75,24.33 142.75,25.26 142.62,25.39 142.34,25.39 142.22,25.26 142.22,24.33 142.09,24.2 141.81,24.2 141.68,24.33 141.68,25.26 141.55,25.39 135.35,25.39 132.36,28.38 131.06,28.38 130.21,29.23 129.5,29.23 128.76,29.98 128.76,31.99 128.18,32.56 127.27,32.56 126.6,33.23 126.6,34.14 123.68,37.06 123.68,38.28 118.94,43.02 118.94,51.41
  BOTTOM w0.076: v2(122.94,63.1) 123.28,63.1 UC1.AR46
  BOTTOM w0.17: JDIMM2.80 162.1,19.8 v2(161.19,20.71)
DDR_B_MA15: length 96.9
  IN1 w0.084: 118.56,51.41 118.56,53.77 121.8,57.01 121.8,60.35 121.58,60.57 121.14,60.57 120.84,60.86 120.84,62.09 121.1,62.34 122.19,62.34 122.57,62.72 122.57,63.37 v2(122.96,63.75)
  IN1 w0.132: 118.56,51.41 118.56,42.86 123.3,38.12 123.3,36.9 123.86,36.34 123.86,36.15 123.3,35.59 123.3,35.41 123.57,35.14 123.75,35.14 124.31,35.71 124.49,35.71 124.69,35.51 124.69,35.33 124.05,34.68 124.05,34.5 124.24,34.3 124.43,34.3 125.07,34.94 125.25,34.94 125.45,34.74 125.45,34.56 124.81,33.92 124.81,33.73 125.01,33.54 125.19,33.54 125.83,34.18 126.01,34.18 126.22,33.98 126.22,33.8 125.26,32.84 125.26,32.66 125.46,32.46 125.64,32.46 126.14,32.96 126.32,32.96 126.52,32.76 126.52,32.58 126.02,32.08 126.02,31.9 126.22,31.7 126.4,31.7 126.92,32.22 127.1,32.22 127.3,32.01 127.3,31.84 126.8,31.33 126.8,31.12 129.11,28.82 130.08,28.82 130.82,28.07 130.82,27.23 131.07,26.98 133.21,26.98 135.19,25 140.46,25 141.65,23.82 158.51,23.82 158.74,24.04 158.74,24.88 158.86,25 159.87,25 160,24.88 160,22.15 159.87,22.02 159.39,22.02 159.27,22.15 v2(159.27,22.24)
  BOTTOM w0.076: UC1.AP46 123.28,63.75 v2(122.96,63.75)
  BOTTOM w0.17: JDIMM2.78 161.5,18.59 160.21,19.88 160.21,21.29 v2(159.27,22.24)
DDR_B_RAS#: length 99.8
  IN1 w0.084: 128.82,51.41 128.82,52.82 129.52,53.52 129.52,56.68 130.06,57.23 130.06,61.98 129.76,62.29 129.76,64.49 130.15,64.88 v2(130.15,64.92)
  IN1 w0.132: v2(171.05,20.71) 170.46,20.71 170.33,20.59 170.33,19.6 170.46,19.47 171.25,19.47 171.48,19.7 174.1,19.7 174.23,19.83 174.23,20.16 174.1,20.29 172.43,20.29 172.19,20.54 172.19,21.06 172.05,21.19 171.59,21.19 171.47,21.32 171.47,21.6 171.59,21.73 172.05,21.73 172.19,21.86 172.19,23.32 172.31,23.45 173.68,23.45 173.81,23.58 173.81,23.85 173.68,23.98 172.36,23.98 172.23,24.11 172.23,33.06 168.35,36.94 144.78,36.94 144.65,37.07 144.65,37.88 144.52,38.01 144.24,38.01 144.11,37.88 144.11,37.07 143.98,36.94 143.7,36.94 143.57,37.07 143.57,39.52 143.45,39.64 136.49,39.64 128.82,47.31 128.82,51.41
  BOTTOM w0.076: v2(130.15,64.92) 130.48,65.25 UC1.AM35
  BOTTOM w0.17: v2(171.05,20.71) 171.51,20.25 171.51,19.76 171.1,19.35 JDIMM2.110
DDR_B_WE#: length 98.3
  IN1 w0.084: 129.21,51.41 129.21,52.97 129.69,53.45 129.69,56.61 130.24,57.15 130.24,62.53 130.54,62.83 130.54,65.82 130.14,66.22 v2(130.13,66.22)
  IN1 w0.132: v2(172.78,29.69) 172.91,29.57 173.28,29.57 173.41,29.69 173.41,30.84 173.28,30.97 172.75,30.97 172.62,31.1 172.62,31.37 172.75,31.5 173.28,31.5 173.41,31.63 173.41,31.9 173.28,32.03 172.78,32.03 172.65,32.15 172.65,33.19 168.51,37.33 150.55,37.33 150.42,37.46 150.42,37.88 150.29,38.01 150.01,38.01 149.88,37.88 149.88,37.46 149.75,37.33 149.48,37.33 149.34,37.46 149.34,37.88 149.22,38.01 148.93,38.01 148.81,37.88 148.81,37.46 148.67,37.33 148.4,37.33 148.27,37.46 148.27,38.57 148.14,38.7 147.86,38.7 147.73,38.57 147.73,37.46 147.6,37.33 147.32,37.33 147.19,37.46 147.19,39.65 147.06,39.77 146.78,39.77 146.65,39.65 146.65,37.46 146.52,37.33 146.25,37.33 146.11,37.46 146.11,39.9 145.99,40.03 145.7,40.03 145.57,39.9 145.57,37.46 145.45,37.33 145.16,37.33 145.04,37.46 145.04,39.9 144.91,40.03 144.62,40.03 144.5,39.9 144.5,38.52 144.37,38.39 144.09,38.39 143.96,38.52 143.96,39.9 143.83,40.03 136.65,40.03 129.21,47.47 129.21,51.41
  BOTTOM w0.076: v2(130.13,66.22) 130.46,66.55 UC1.AK35
  BOTTOM w0.17: JDIMM2.113 172,26.79 171.84,26.95 171.84,28.75 v2(172.78,29.69)
DDR_CKE0_DIMMA: length 76.5
  IN4 w0.084: 119.88,51.41 119.88,52.75 122.61,55.47 123.18,55.47 124.56,56.85 124.56,58.68 125.12,59.24 125.12,61.28 124.57,61.82 124.57,61.83 124.57,61.83 v2(124.57,61.82)
  IN4 w0.132: v2(82.9,28.29) 82.48,28.71 82.48,32.11 90.43,40.07 111.65,40.07 115.14,43.56 115.33,43.56 115.51,43.38 115.65,43.38 115.88,43.61 115.88,43.75 115.7,43.93 115.7,44.12 115.89,44.31 116.08,44.31 116.99,43.39 117.14,43.39 117.37,43.62 117.37,43.76 116.45,44.68 116.45,44.86 116.64,45.06 116.82,45.06 117.74,44.13 117.89,44.13 118.12,44.36 118.12,44.51 117.19,45.43 117.19,45.61 117.39,45.8 117.57,45.8 118.49,44.88 118.63,44.88 118.86,45.11 118.86,45.25 118.56,45.56 118.06,46.06 118.06,46.47 119.88,48.3 119.88,51.41
  BOTTOM w0.076: UC1.AU43 124.88,62.14 v2(124.57,61.82)
  BOTTOM w0.17: JDIMM1.73 83.5,27.69 v2(82.9,28.29)
DDR_CKE1_DIMMA: length 75.2
  IN4 w0.084: v2(124.56,60.55) 124.94,60.17 124.94,59.32 124.38,58.75 124.38,56.92 123.16,55.7 122.52,55.7 119.45,52.63 119.45,51.41
  IN4 w0.132: 119.45,51.41 119.45,48.41 111.6,40.57 90.38,40.57 82.09,32.27 82.09,27.92 82.48,27.54 82.48,21.74 v2(84.32,19.9)
  BOTTOM w0.076: v2(124.56,60.55) 124.84,60.84 UC1.AW43
  BOTTOM w0.17: JDIMM1.74 83.8,19.37 v2(84.32,19.9)
DDR_CKE2_DIMMB: length 80
  IN1 w0.084: v2(121.4,59.86) 121.02,59.48 121.02,58.71 121.53,58.2 121.53,57.36 118.17,54.01 118.17,51.41
  IN1 w0.132: v2(159.27,23.76) 158.93,23.43 140.81,23.43 140.68,23.56 140.68,24.24 140.55,24.36 140.27,24.36 140.14,24.24 140.14,23.56 140.01,23.43 139.73,23.43 139.6,23.56 139.6,23.97 139.47,24.1 139.2,24.1 139.06,23.97 139.06,23.56 138.93,23.43 138.66,23.43 138.53,23.56 138.53,24.49 138.4,24.62 138.11,24.62 137.99,24.49 137.99,23.56 137.85,23.43 137.58,23.43 137.45,23.56 137.45,23.97 137.32,24.1 137.04,24.1 136.91,23.97 136.91,23.56 136.78,23.43 136.39,23.43 136.26,23.56 136.26,24.49 136.13,24.62 135.03,24.62 133.05,26.6 130.91,26.6 130.43,27.07 130.43,27.91 130,28.35 129.03,28.35 122.91,34.46 122.91,37.96 118.17,42.7 118.17,51.41
  BOTTOM w0.076: UC1.AY49 121.72,60.19 v2(121.4,59.86)
  BOTTOM w0.17: v2(159.27,23.76) 160,24.5 JDIMM2.73
DDR_CKE3_DIMMB: length 82
  IN1 w0.084: 117.78,51.41 117.78,54.26 v2(121.14,57.62)
  IN1 w0.132: 117.78,51.41 117.78,42.54 122.53,37.8 122.53,34.3 130.62,26.21 132.89,26.21 134.04,25.07 134.04,23.91 134.91,23.04 157.64,23.04 157.77,22.92 157.77,21.56 157.89,21.44 158.18,21.44 158.3,21.56 158.3,22.92 158.43,23.04 158.72,23.04 158.84,22.92 158.84,21.13 v2(159.27,20.71)
  BOTTOM w0.076: UC1.AU50 120.87,61.8 120.68,61.61 120.68,61.44 120.66,61.17 120.6,61.1 120.55,61.01 120.52,60.94 120.52,60.73 120.54,60.68 120.59,60.58 120.59,60.45 120.52,60.29 120.52,59.47 121.14,58.84 v2(121.14,57.62)
  BOTTOM w0.17: v2(159.27,20.71) 159.74,20.24 159.74,19.55 160.3,18.99 JDIMM2.74
DDR_CS0_DIMMA#: length 77.6
  IN4 w0.084: 132.8,51.41 132.8,51.57 133.37,52.14 133.37,58.87 133.47,58.97 133.47,61.22 132.61,62.08 132.61,63.58 132.5,63.69 v2(131.11,63.69)
  IN4 w0.132: 132.8,51.41 132.8,39.25 127.84,34.29 127.84,33.38 126.7,32.24 126.58,32.24 116.56,22.22 100.47,22.22 100.34,22.09 100.34,21.51 100.21,21.39 99.94,21.39 99.81,21.51 99.81,22.09 99.68,22.22 99.41,22.22 99.28,22.09 99.28,21.56 99.15,21.44 98.88,21.44 98.75,21.56 98.75,22.09 98.62,22.22 98.27,22.22 98.17,22.12 98.17,21.52 98.07,21.42 v2(97.56,21.42)
  BOTTOM w0.076: UC1.AP33 131.37,63.95 v2(131.11,63.69)
  BOTTOM w0.17: JDIMM1.114 95.8,19.66 v2(97.56,21.42)
DDR_CS1_DIMMA#: length 77.9
  IN4 w0.084: 130.9,51.41 130.89,51.41 130.42,51.87 130.42,54.72 131.11,55.4 131.11,57.56 131.58,58.03 131.58,58.05 131.59,58.06 131.59,59.7 131.18,60.11 130.74,60.11 130.33,60.52 130.33,61.95 130.9,62.52 131.43,62.52 131.91,62.99 v2(132.07,62.99)
  IN4 w0.132: 130.9,51.41 130.95,51.36 130.95,50.64 130.49,50.17 130.49,41.6 130.62,41.47 131.1,41.47 131.21,41.36 131.21,41.04 131.1,40.94 130.62,40.94 130.49,40.81 130.49,40.54 130.62,40.41 131.1,40.41 131.21,40.31 131.21,39.98 131.1,39.88 130.62,39.88 130.49,39.75 130.49,39.12 122.59,31.23 122.59,30.44 121.47,29.31 120.85,29.31 119.93,30.24 119.46,30.24 119.15,29.93 119.15,27 117.55,25.4 116.77,25.4 116.2,24.83 116.2,24.04 115.92,23.77 104.06,23.77 103.96,23.86 103.96,24.53 103.47,25.01 102.04,25.01 100.64,26.42 100.42,26.42 100.09,26.09 99.91,26.09 99.72,26.28 99.72,26.46 99.94,26.68 99.94,26.87 99.75,27.06 99.57,27.06 99.35,26.84 99.16,26.84 98.97,27.02 98.97,27.21 99.19,27.43 99.19,27.62 v2(98.52,28.29)
  BOTTOM w0.076: v2(132.07,62.99) 132.38,63.3 UC1.AR32
  BOTTOM w0.17: v2(98.52,28.29) 98.05,27.83 98.05,26.98 97.9,26.83 JDIMM1.121
DDR_CS2_DIMMB#: length 88.5
  IN1 w0.084: 130.75,51.41 130.75,51.45 130.43,51.78 130.43,56.37 130.93,56.87 130.93,57.38 131.84,58.3 131.84,62.24 132.45,62.84 132.45,64.56 132.07,64.93 v2(132.07,64.93)
  IN1 w0.132: v2(172.61,22.24) 173.01,22.24 176.29,25.51 176.29,34.7 172.07,38.92 166.24,38.92 166.23,38.91 159.98,38.91 159.33,39.55 149.47,39.55 147.45,41.57 137.33,41.57 131.98,46.92 130.75,48.15 130.75,51.41
  BOTTOM w0.076: UC1.AM32 132.39,65.25 v2(132.07,64.93)
  BOTTOM w0.17: JDIMM2.114 172.3,19.2 172.13,19.37 172.13,21.76 v2(172.61,22.24)
DDR_CS3_DIMMB#: length 86.6
  IN1 w0.084: v2(132.01,66.32) 132.01,65.97 131.67,65.63 131.67,58.37 130.76,57.45 130.76,56.94 130.21,56.39 130.21,53.57 130.25,53.52 130.25,51.57 130.37,51.46 130.37,51.41
  IN1 w0.132: 130.37,51.41 130.37,47.99 131.6,46.76 137.17,41.19 147.29,41.19 149.31,39.17 152.46,39.17 152.59,39.04 152.59,38.65 152.72,38.52 153,38.52 153.13,38.65 153.13,39.02 153.26,39.15 153.54,39.15 153.67,39.02 153.67,38.65 153.8,38.52 154.08,38.52 154.21,38.65 154.21,39.02 154.34,39.15 154.61,39.15 154.75,39.02 154.75,38.65 154.88,38.52 155.15,38.52 155.28,38.65 155.28,39.02 155.42,39.15 155.69,39.15 155.82,39.02 155.82,38.65 155.95,38.52 156.23,38.52 156.36,38.65 156.36,39.02 156.49,39.15 156.77,39.15 156.9,39.02 156.9,38.65 157.03,38.52 157.31,38.52 157.44,38.65 157.44,39.04 157.57,39.17 157.85,39.17 157.98,39.04 157.98,38.65 158.11,38.52 158.38,38.52 158.52,38.65 158.52,39.04 158.64,39.17 158.93,39.17 159.05,39.04 159.05,38.65 159.19,38.52 171.92,38.52 175.9,34.54 175.9,28.65 175.78,28.53 174.93,28.53 174.8,28.4 v2(174.8,28.17)
  BOTTOM w0.076: v2(132.01,66.32) 132.24,66.55 UC1.AK32
  BOTTOM w0.17: JDIMM2.121 174.4,26.92 174.34,26.98 174.34,27.79 174.72,28.17 v2(174.8,28.17)
DDR_HVREF_RST_GATE: length 2.5
  TOP w0.102: U38.A34 27.94,20.81 v1(28.42,21.3) 28.69,21.56 R353.2
DDR_PG_CTRL: length 64.8
  TOP w0.102: U5.2 126.16,22.1 127.27,20.99 128.96,20.99 130.16,22.2 130.16,24.22 129.14,25.24 v1(129.14,26.03) 129.14,29.8 128.19,30.75 v2(128.12,30.75)
  IN3 w0.122: v2(107.4,59.71) 107.4,59.69 107.41,59.69 107.41,58.81 118.94,47.28 118.94,37.05 123.09,32.9 125.34,32.9 127.49,30.75 v2(128.12,30.75)
  BOTTOM w0.076: UC1.AV61 113.91,61.83 112.8,61.83 112.78,61.81 112.51,61.81 112.5,61.8 112.42,61.8
  BOTTOM w0.102: v2(107.4,59.71) 108.39,58.72 110.8,58.72 111.68,59.61 111.68,61.06 112.42,61.8
DDR_XDP_SMBCLK_R1: length 4.3
  TOP w0.102: RC112.2 69.2,64.61 69.2,63.98 68.82,63.6 68.82,63.47 67.99,62.63 JXDP1.53
DDR_XDP_SMBDAT_R1: length 3.8
  TOP w0.102: RC111.2 69.08,63.53 69.08,63.22 v1(68.63,62.78) 67.99,62.13 JXDP1.51
DDR_XDP_WAN_SMBCLK: length 308.3
  TOP w0.102: v2(63.35,31.11) 63.16,31.31 63.16,32.16 63.55,32.55 63.55,35.89 71.26,43.6 71.26,49.95 73.15,51.84 73.15,61.87 72.94,62.09 72.94,63.04 71.23,64.74 70.91,64.74 RC112.1 ; v2(190.7,68.64) 190.91,68.43 190.91,67.8 191.46,67.26 202.08,67.26 202.49,66.85 202.49,65.13 203.35,64.27 203.35,63.05 203.68,62.72 203.68,57.03 204.93,55.79 204.93,51.76 204.27,51.1 204.27,49.78 204.61,49.44 204.85,49.44 v2(205.03,49.26) 205.2,49.44 205.35,49.44 R218.2 ; v2(125.01,30.05) 125.16,29.9 125.16,29.08 R123.2 ; QC1.1 163.23,71.36 v2(163.49,71.62)
  IN1 w0.084: v2(190.7,68.64) 190.93,68.87 190.93,69.59 190.21,70.32 179.99,70.32 179.54,69.86 172.34,69.86 171.35,68.87 170.13,68.87 168.1,70.9 164.99,70.9 164.81,70.72 164.38,70.72 163.49,71.61 v2(163.49,71.62)
  IN2 w0.122: v2(205.03,49.26) 205.22,49.45 205.36,49.45 205.51,49.3 205.51,48.42 205.06,47.97 205.06,46.33 205.56,45.82 205.56,41.31 203.9,39.66 203.9,33.93 204.09,33.74 204.09,31.93 207.02,29.01 207.02,28.61 206.9,28.5 206.71,28.5 v2(206.57,28.64) ; v2(163.49,71.62) 164.74,71.62 165.09,71.27 165.09,70.95 164.98,70.84 164.98,68.41 164.82,68.25 164.82,66.88 165.11,66.59 165.76,66.59 166.51,65.84 166.51,62.93 167,62.43 167,56.29 167.42,55.87 167.42,49.77 149.98,32.33 134.54,32.33 133.24,31.03 130.29,31.03 128.83,29.57 126.26,29.57 126.05,29.35 125.52,29.35 125.15,29.73 125.15,29.9 v2(125.01,30.05) 125.16,30.2 125.16,31.16 124.1,32.23 63.59,32.23 63.18,31.82 63.18,31.28 v2(63.35,31.11)
  BOTTOM w0.102: JDIMM1.202 122.2,16.1 122.01,15.92 122.01,15.82 122.12,15.71 123.11,15.71 123.84,16.45 123.84,20.26 123.46,20.64 123.46,22.67 124.66,23.87 124.66,28.89 125.06,29.29 125.06,30 v2(125.01,30.05) ; JDIMM2.202 198.7,16.76 198.53,16.59 198.53,16.4 198.6,16.33 199.48,16.33 200.1,16.95 200.1,19.05 201.03,19.98 203.06,19.98 203.4,20.32 203.4,21.89 205.64,24.13 205.64,27.89 206.22,28.47 206.39,28.47 206.57,28.65 206.57,28.65 v2(206.57,28.64)
DDR_XDP_WAN_SMBDAT: length 306.6
  TOP w0.102: RC111.1 70.58,64.32 70.75,64.49 71.17,64.49 72.71,62.95 72.71,61.99 72.92,61.78 72.92,51.94 71.03,50.05 71.03,43.69 63.32,35.98 63.32,32.64 62.93,32.25 62.93,31.28 v2(62.77,31.11) ; QC1.4 164.53,71.23 v2(164.61,71.15) ; R122.2 125.39,29.21 125.39,29.84 v2(125.59,30.05) ; v2(191.29,68.64) 191.14,68.5 191.14,67.9 191.55,67.49 202.17,67.49 202.72,66.94 202.72,65.23 203.58,64.36 203.58,63.15 203.91,62.82 203.91,57.13 205.16,55.88 205.16,51.66 204.5,51 204.5,49.88 204.7,49.67 204.85,49.67 v2(205.03,49.85) 205.2,49.67 205.35,49.67 R219.2
  IN1 w0.084: v2(164.61,71.15) 168.15,71.15 170.22,69.08 171.26,69.08 172.25,70.07 179.45,70.07 179.91,70.53 190.29,70.53 191.14,69.68 191.14,68.78 v2(191.29,68.64)
  IN2 w0.122: v2(205.03,49.85) 205.17,49.7 205.47,49.7 205.76,49.41 205.76,48.32 205.31,47.87 205.31,46.43 205.81,45.93 205.81,41.21 204.15,39.55 204.15,34.04 204.34,33.84 204.34,32.04 207.26,29.12 207.26,28.51 207,28.25 206.77,28.25 v2(206.57,28.05) ; v2(62.77,31.11) 62.93,31.28 62.93,31.92 63.49,32.48 124.2,32.48 125.41,31.27 125.41,30.24 125.59,30.05 v2(125.59,30.05) 125.5,29.96 125.5,29.73 125.63,29.6 125.95,29.6 126.16,29.81 128.73,29.81 130.19,31.27 133.14,31.27 134.44,32.58 149.88,32.58 167.18,49.87 167.18,55.76 166.75,56.19 166.75,62.33 166.26,62.82 166.26,65.73 165.65,66.34 165.01,66.34 164.57,66.78 164.57,68.35 164.73,68.51 164.73,71.04 v2(164.61,71.15)
  BOTTOM w0.102: v2(125.59,30.05) 125.39,29.84 125.39,29.29 124.89,28.8 124.89,23.78 123.69,22.57 123.69,20.74 124.07,20.36 124.07,16.35 123.2,15.49 122.02,15.49 121.79,15.72 121.79,15.92 121.6,16.1 JDIMM1.200 ; v2(206.57,28.05) 206.57,28.07 206.39,28.24 206.32,28.24 205.87,27.79 205.87,24.03 203.63,21.8 203.63,20.22 203.16,19.75 201.12,19.75 200.33,18.96 200.33,16.86 199.57,16.1 198.5,16.1 198.3,16.31 198.3,16.52 198.1,16.72 JDIMM2.200
DEVICE_DET#: length 3.3
  TOP w0.102: U38.B1 20.69,9.63 19.64,8.57 19.64,7.64 R365.2
DGPU_PWROK: length 19.1
  BOTTOM w0.076: UC1.P4 149.7,74.43 150.09,74.43 150.13,74.39 150.92,74.39 151.08,74.55 151.4,74.55 151.52,74.68 152.42,74.68 153.17,75.43 153.35,75.43 153.5,75.58
  BOTTOM w0.102: RP4.8 v1(164.06,79.31) 162.6,77.85 162.6,77.25 161.33,75.98 159.42,75.98 159.16,76.24 156.75,76.24 156.08,75.58 153.5,75.58
DGPU_SELECT#: length 9.9
  TOP w0.102: T121.1 25.91,27.33 v2(25.91,26.56) ; U37.B14 22.68,30.55 v2(22.39,30.85)
  BOTTOM w0.102: v2(22.39,30.85) 22.66,30.58 22.66,30.16 23.31,29.51 23.75,29.51 24.08,29.17 26.28,29.17 26.62,28.83 26.62,27.41 25.91,26.69 25.91,26.56 v2(25.91,26.56)
DH_1.35V: length 6.2
  TOP w0.102: v3(106.65,7.98) v1(105.69,7.98)
  IN4 w1.016: 112.93,9.93 110.21,9.93 108.41,8.13
  vias: v3(107.29,7.98) v3(112.65,10.87) v3(113.28,10.87)
DIS_BAT_PROCHOT#: length 176.4
  TOP w0.102: U37.B51 16.18,38.39 v2(16.31,38.26)
  TOP w0.254: v2(123.23,14.65) v1(123.23,13.79) 123.23,13.15 122.73,12.65 PR812.1
  IN1 w0.084: v2(16.31,38.26) 16.31,38.73 15.04,40 14.3,40 14.08,39.78 13.06,39.78 12.57,39.29 12.57,37.98 12.12,37.53 12.12,34.26 11.21,33.36 11.21,32.19 12.11,31.29 12.11,23.15 13.58,21.68 13.58,20.74 12.88,20.04 12.88,18.94 11.92,17.98 11.92,8.74 12.15,8.51 12.15,5.45 12.33,5.27 13.18,5.27 14.37,6.45 15.97,6.45 17.38,5.04 28.54,5.04 29.29,5.78 34.12,5.78 34.86,5.05 39.61,5.05 40.85,6.29 45.36,6.29 46.02,6.94 46.02,9.93 46.76,10.68 46.76,12.16 48.06,13.46 48.06,14.73 51.79,18.47 51.79,20.78 53.72,22.71 56.96,22.71 57.37,23.11 63.04,23.11 63.53,23.6 80.7,23.6 81.05,23.24 81.05,18.94 82.68,17.32 120.55,17.32 123.22,14.65 v2(123.23,14.65)
DISP_ON: length 14.6
  TOP w0.102: D21.1 58.86,83.83 R96.1 v1(58.9,82.46) 58.9,81.84 59.49,81.25 62.23,81.25 v2(63.09,80.39)
  BOTTOM w0.102: JEDP1.21 61.75,74.77 61.75,75.63 62.64,76.52 62.64,79.93 v2(63.09,80.39)
DK_AC_OFF: length 6.3
  TOP w0.254: PD815.3 4.84,35.52 v1(4.14,34.82) 3.68,34.37 3.68,33.84 5.78,31.74 PU800.25
DK_AC_OFF_EN: length 2.5
  TOP w0.254: PU800.22 7.28,31.72 7.48,31.91 v1(7.48,32.23) 7.48,32.42 6.97,32.93 PR857.1
DK_CSS_GC: length 53.7
  TOP w0.102: v1(40.35,3.42) 40.3,3.47 40.27,3.47 39.67,4.07 v2(39.66,4.07)
  TOP w0.254: PU800.11 10.3,26.6 10.58,26.33 v2(10.85,26.33) ; 40.18,4.58 40.17,4.58 39.75,4.17 39.75,4.14 39.66,4.05 v2(39.66,4.07)
  IN2 w0.254: v2(10.85,26.33) 10.8,26.33 10.36,25.89 10.36,25.49 10.67,25.18 11.45,25.18 11.77,24.86 11.77,22.86 11.09,22.17 11.09,19.07 12,18.16 12,9.46 12.62,8.83 12.62,7.24 13.2,6.67 17.59,6.67 18.03,6.23 18.03,4.98 18.32,4.7 28.78,4.7 29.23,5.15 37.67,5.15 37.67,5.14 38.57,5.14 39.64,4.07 v2(39.66,4.07)
DK_PWRBAR: length 1.7
  TOP w0.254: PU800.33 2.72,27.6 PR832.2
DL_1.35V: length 11.6
  TOP w0.102: v1(114.02,13.51) 113.92,13.41 v3(113.92,12.62)
  IN4 w1.016: 103.91,13.59 104.34,14.02 113.74,14.02 114.17,13.59
  vias: v3(102.98,13.91) v3(102.98,13.25) v3(114.55,12.62)
DMIC0: length 301.3
  TOP w0.254: U17.4 272.08,29.63 v2(272.33,29.39)
  IN1 w0.084: v2(178.07,84.62) 177.54,85.15 170.24,85.15 169.08,86.31 166.13,86.31 164.77,87.66 163.44,87.66 162.08,89.03 154.34,89.03 152.9,90.46 152.32,90.46 151.99,90.79 151.99,91.37 151.75,91.61 148.97,91.61 145.79,94.8 144.72,94.8 144.48,95.04 126.91,95.04 126.35,94.47 125.26,94.47 125.12,94.61 122.93,94.61 122.5,94.19 122.5,91.84 122.97,91.36 122.97,90.68 124.36,89.29 124.36,85.31 125.26,84.4 v2(125.51,84.4)
  IN2 w0.122: v2(223.6,85.86) 223.6,84.89 225.02,83.46 238.91,83.46 240.03,82.35 240.73,82.35 243.1,79.98 245.39,79.98 246.03,79.34 254.15,79.34 254.41,79.09 257.88,79.09 260.37,81.58 263.93,81.58 265.21,80.3 265.21,77.14 265.61,76.75 268.59,76.75 269.48,75.86 269.48,55.81 273.13,52.16 273.13,51.07 275.33,48.87 275.33,46.33 275.99,45.67 275.99,41.41 276.24,41.15 276.24,38.85 275.99,38.6 275.99,33.35 272.33,29.69 v2(272.33,29.39) ; v2(178.07,84.62) 178.07,84.72 181.65,88.3 181.65,89.16 182.84,90.36 185.81,90.36 186.3,90.84 187.68,90.84 188.52,91.68 v2(189.19,91.68)
  IN3 w0.122: v2(221.58,91.34) 217.43,91.34 216.56,92.21 204.29,92.21 204.24,92.16 189.67,92.16 v2(189.19,91.68)
  IN4 w0.084: v2(73.94,75.6) 73.94,78.23 78.73,83.03 81.36,83.03 81.79,83.46 81.79,84 81.99,84.2 82.63,84.2 84.35,82.48 93.32,82.48 94.01,81.8 96.29,81.8 98.52,79.57 106.77,79.57 106.99,79.35 109.53,79.35 110.03,79.86 112.38,79.86 114.44,81.91 123.03,81.91 v2(125.51,84.4)
  BOTTOM w0.102: JEDP1.36 69.38,75.8 69.38,75.52 69.77,75.13 70.74,75.13 71.55,74.32 74,74.32 CE2.1 74.38,75.17 73.95,75.6 v2(73.94,75.6) ; v2(221.58,91.34) 222.28,90.64 v1(222.28,89.66) 222.28,87.18 v2(223.6,85.86)
DMIC_CLK: length 367.1
  TOP w0.102: v2(271.84,26.2) 271.12,26.2 C130.1 R170.2
  IN1 w0.084: v2(64.95,39.33) 64.95,43.99 68.07,47.11 68.07,53.91 69.68,55.52 69.68,56.99 68.07,58.6 68.07,62.04 70.02,63.99 70.02,70.63 70.47,71.08 73.24,71.08 v2(73.56,71.4)
  IN2 w0.122: v2(195.29,43.54) 196.71,44.95 202.22,44.95 202.92,45.66 202.92,46.59 203.51,47.18 203.51,51.62 203.78,51.89 203.78,52.65 202.96,53.46 202.96,55.3 203.26,55.59 203.26,61.55 202.63,62.18 202.63,66.97 203.02,67.37 203.02,68.46 201.32,70.16 201.32,72.64 203.53,74.85 203.53,77.46 205.31,79.23 207.41,79.23 208.23,80.05 216.34,80.05 221.11,84.83 223.31,84.83 224.93,83.2 238.77,83.2 239.91,82.07 240.61,82.07 242.95,79.73 245.29,79.73 245.92,79.1 254.05,79.1 254.31,78.84 257.99,78.84 260.48,81.33 263.83,81.33 264.96,80.2 264.96,76.76 265.35,76.36 268.53,76.36 269.23,75.67 269.23,71.16 269.18,71.11 269.18,54.02 275.08,48.12 275.08,46.23 275.74,45.57 275.74,41.69 275.59,41.54 275.15,41.54 274.78,41.17 274.78,39.5 275.74,38.53 275.74,33.47 272.54,30.28 271.55,30.28 270.79,29.51 270.79,27.01 271.6,26.2 v2(271.84,26.2)
  IN3 w0.122: v2(195.29,43.54) 195.25,43.54 194.15,42.43 172.29,42.43 168.08,38.23 136.48,38.23 131.02,32.76 130.27,32.76 128.97,31.47 128.97,30.59 128.47,30.08 127.46,30.08 125.13,32.41 122.88,32.41 118.45,36.83 67.44,36.83 v2(64.95,39.33)
  BOTTOM w0.102: v2(73.56,71.4) 73.89,71.4 74.38,71.89 CE1.1 74.04,72.39 73,72.39 v1(72.21,73.18) 70.54,74.85 69.58,74.85 68.91,75.53 68.45,75.53 68.41,75.57 JEDP1.34
DMIC_CLK_L: length 1.9
  TOP w0.254: U17.2 271.08,29.59 270.52,29.03 R170.1
DOCK_AC_OFF: length 164
  TOP w0.254: v2(5.09,37.64) 4.85,37.88 PD815.1 4.19,38.63 PR844.1
  IN3 w0.122: v2(38.79,50.46) 39.45,51.12 41.94,51.12 42.2,51.38 43.01,51.38 43.27,51.11 45.73,51.11 46.77,50.07 52.65,50.07 54.26,51.69 54.26,56.06 54.5,56.3 54.5,64.17 53.86,64.81 53.86,69 53.14,69.72 53.14,77.06 54.15,78.08 54.15,79.61 60.06,85.51 62.3,85.51 65.25,88.45 68.55,88.45 75.8,95.7 94.22,95.7 96.11,97.6 96.11,98.36 102.76,105 102.76,105.52 104.97,107.73 104.97,108.99 105.81,109.83 108.16,109.83 109.63,111.3 110.69,111.3 112.34,109.65 v2(112.98,109.65)
  IN4 w0.084: v2(38.79,50.46) 38.14,49.81 36.43,49.81 33.14,46.52 31.66,46.52 30.35,45.22 28.73,45.22 27.8,44.29 25.59,44.29 24.74,43.44 21.95,43.44 21.01,42.5 19.84,42.5 19.75,42.41 18.01,42.41 17.99,42.43 16.02,42.43 15.91,42.32 12.78,42.32 12.6,42.51 9.78,42.51 7.7,40.43 7.7,39.93 5.41,37.64 v2(5.09,37.64)
  BOTTOM w0.102: v2(112.98,109.65) 113.28,109.65 113.45,109.49 JDOCK1.2 ; v2(38.79,50.46) 39.01,50.69 v1(39.01,50.96)
DOCK_AC_OFF_EC: length 13.1
  TOP w0.102: 6.08,34.71 6.08,34.75 v2(6.07,34.76)
  TOP w0.254: U37.A63 13.9,31.27 v1(13.68,31.05) 13.37,30.75 v2(13.37,30.33) ; 6.08,34.71 PR858.1 PR857.2
  IN3 w0.254: v2(6.07,34.76) 6.49,34.76 8.34,32.91 8.34,32.19 9.88,30.66 12.09,30.66 12.29,30.45 13.25,30.45 v2(13.37,30.33)
DOCK_DCIN_IS+: length 206.6
  TOP w0.102: v2(50.7,48.64) 50.82,48.52 50.82,48.01 50.6,47.79 49.2,47.79 48.27,46.86 48.27,45.6 49.37,44.5 49.37,41.42 49.14,41.19 49.14,40.44 46.49,37.8 46.49,35.97 49,33.46 49.51,33.46 50.09,32.88 50.09,30.84 47.57,28.33 47.57,25.91 44.56,22.9 43.53,22.9 41.86,21.23 41.86,19.51 42.1,19.27 42.1,18.54 42.56,18.09 42.56,16.52 43.42,15.66 PQ703.6
  IN2 w0.122: v2(50.7,48.64) 50.89,48.83 50.89,49.34 50.28,49.95 46.75,49.95 46.13,50.57 45.74,50.57 45.5,50.33 45.5,50.25 v2(45.64,50.11)
  IN4 w0.084: v2(45.64,50.11) 45.45,50.3 45.45,50.38 45.72,50.65 48.28,50.65 52.08,54.44 52.08,55.52 53.93,57.37 53.93,60.22 51.82,62.33 51.82,62.71 49.46,65.06 49.46,69.83 50.11,70.48 50.11,77.27 57.9,85.06 60.88,85.06 67.83,92.01 81.34,92.01 83.85,94.53 87.98,94.53 88.58,93.92 96.86,93.92 99.87,96.93 99.87,103.35 106.6,110.08 113.22,110.08 114.72,111.58 148.29,111.58 148.66,111.22 148.66,110.62 v2(148.47,110.44)
  BOTTOM w0.102: v2(148.47,110.44) 148.65,110.26 148.65,109.8 148.45,109.6 JDOCK1.134
