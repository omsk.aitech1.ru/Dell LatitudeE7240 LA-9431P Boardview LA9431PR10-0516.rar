# Allegro board LA9431PR10-0516.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 194.67,79.32 194.67,77.12 193.56,76.02 192.51,76.02 192.41,76.12 192.41,77.67 192.53,77.8 193.24,77.8 193.42,77.98 193.42,78.71 193.52,78.82 193.83,78.82 194.13,79.12 194.13,79.37 194.26,79.5 194.49,79.5
GND on BOTTOM (solid shape): 205.49,56.92 205.49,55.6 205.43,55.41 205.49,55.22 205.49,53.64 205.18,53.34 203.67,53.34 202.63,54.37 202.63,56.9 202.84,57.11 205.29,57.11
GND on BOTTOM (solid shape): 49.78,14.65 51.09,14.65 51.61,14.12 51.61,11.79 51.54,11.71 50.98,11.71 50.93,11.76 50.93,12.18 50.91,12.19 50.91,13.69 50.66,13.94 47.23,13.94 46.98,14.2 46.98,15.15 47.23,15.4 49.02,15.4
GND on BOTTOM (solid shape): 106.83,71.81 106.85,71.79 106.86,71.77 106.86,71.04 106.82,71.01 105.4,71.01 105.4,71.02 96.72,71.02 96.72,71.03 95.05,71.03 95.01,71.05 95,71.08 95,71.78 95.02,71.81
GND on BOTTOM (solid shape): 89.59,76.81 89.59,76.49 89.78,76.3 90.16,76.3 90.35,76.11 90.35,75.6 90.67,75.29 91.69,75.29 92.35,74.62 92.35,72.97 92.76,72.57 92.76,71.83 92.66,71.73 87.3,71.73 87.24,71.79 87.24,72.36 88.06,73.19 88.06,76.11 88.82,76.87 89.52,76.87
GND on BOTTOM (solid shape): 169.56,79.3 169.56,77.86 170.03,77.39 170.43,77.39 170.55,77.28 170.55,75.82 170.43,75.7 169.44,75.7 169.35,75.62 168.95,75.62 168.73,75.83 168.73,77.81 168.97,78.05 168.97,78.52 168.81,78.68 168.55,78.68 168.55,78.67 168.35,78.67 168.29,78.73 168.29,79.25 168.41,79.37 169.48,79.37
GND on BOTTOM (solid shape): 273.53,85.74 274.25,85.42 274.97,85.74 281.47,85.74 281.99,85.22 281.99,83.46 281.69,83.16 271.46,83.16 271.2,83.42 271.2,85.37 271.57,85.74
GND on BOTTOM (solid shape): 83.41,69.71 83.41,69.11 83.59,68.94 83.59,67.24 83.61,67.22 84.62,67.22 84.7,67.15 84.7,67.07 84.64,67.02 83.69,67.02 83.59,66.92 83.59,63.56 84.71,62.45 86.19,62.45 86.41,62.22 86.41,61.62 86.32,61.53 84.73,61.53 84.34,61.14 83.55,61.14 83.31,60.9 83.31,60.22 83.03,59.94 81.46,59.94 81.28,60.12 81.28,63.27 81.34,63.33 81.34,69.2 81.35,69.2 81.35,69.79 81.59,70.03 83.1,70.03
GND on BOTTOM (solid shape): 106.64,75.17 106.72,75.14 106.75,75.06 106.74,75.01 106.74,74.68 106.75,74.58 106.78,74.5 106.76,74.4 106.68,74.36 101.92,74.36 101.92,74.37 96.72,74.37 96.72,74.38 95.05,74.38 95.01,74.4 95,74.43 95,75.17
GND on BOTTOM (solid shape): 207.6,104.08 207.26,103.74 203.8,103.74 203.22,103.16 203.22,102.45 202.97,102.19 202.22,102.19 201.36,103.06 201.36,105.15 203,105.15 203.74,105.77 203.25,106.61 203.25,112.75 207.6,112.75
GND on BOTTOM (solid shape): 283.21,8.35 283.1,8.35 282.57,8.13 282.35,7.6 282.35,3.21 281.84,3.21 281.84,7.6 282.21,8.49 283.1,8.86 283.21,8.86
GND on BOTTOM (solid shape): 95.67,78.52 96.52,78.52 96.55,78.53 96.59,78.54 97.39,78.54 97.4,78.52 98.39,78.52 98.42,78.53 98.45,78.54 99.18,78.54 99.22,78.53 99.25,78.52 100.02,78.52 100.05,78.53 100.09,78.54 100.83,78.54 100.84,78.52 101.63,78.52 101.65,78.53 101.69,78.54 106.78,78.54 106.83,78.49 106.83,77.77 106.79,77.74 105.04,77.74 105.04,77.72 101.59,77.72 101.59,77.71 94.67,77.71 94.67,77.7 93.27,77.7 93.27,78.46 93.28,78.5 93.32,78.51 94.64,78.51 94.68,78.52 94.73,78.54 95.66,78.54
GND on BOTTOM (solid shape): 77.73,20.59 77.79,20.5 77.79,19.72 77.73,19.63 77.63,19.64 77.35,19.7 77.12,19.53 77.04,19.53 76.42,18.91 76.42,18.82 76.4,18.8 76.38,18.78 76.3,18.75 76.23,18.78 76.2,18.8 76.18,18.82 76.18,19.37 77.33,20.53 77.36,20.52 77.5,20.52 77.63,20.58
GND on BOTTOM (solid shape): 200.86,81.41 200.86,79.06 200.85,79.02 200.82,79.01 200.69,78.98 200.59,78.9 200.5,78.63 200.68,78.31 200.66,78.23 200.61,78.18 198.86,78.18 198.73,78.31 198.73,79.7 198.73,79.71 198.73,80.09 198.81,80.16 199.06,80.16 199.23,79.99 199.97,79.99 200.12,80.13 200.12,80.13 200.18,80.19 200.18,80.8 200.15,80.82 200.15,81.51 200.2,81.56 200.72,81.56
GND on BOTTOM (solid shape): 154.15,21.17 154.2,21.08 154.2,20.35 154.15,20.26 154.05,20.26 153.67,20.25 153.52,19.89 153.53,19.86 152.92,19.26 152.92,18.82 152.9,18.8 152.88,18.78 152.8,18.75 152.73,18.78 152.7,18.8 152.68,18.82 152.68,20.03 153.78,21.13 153.81,21.13 153.93,21.13 154.05,21.17
GND on BOTTOM (solid shape): 68.38,20.54 68.44,20.64 68.55,20.62 68.7,20.53 68.86,20.52 68.89,20.53 69.82,19.6 69.82,18.82 69.8,18.8 69.78,18.78 69.7,18.75 69.62,18.78 69.6,18.81 69.57,18.83 69.14,19.26 69.15,19.28 68.97,19.66 68.55,19.6 68.44,19.58 68.38,19.68
GND on BOTTOM (solid shape): 283.65,95.3 276.79,95.3 276.32,94.98 276.45,94.43 276.51,94.34 276.54,94.24 276.54,87.06 276.28,86.81 276.03,87.06 276.03,94.13 275.78,94.84 276.09,95.53 276.09,96.63 275.83,96.89 271.35,96.89 271.35,97.4 283.65,97.4
GND on BOTTOM (solid shape): 175.02,20.34 175.02,18.92 174.97,18.83 174.86,18.83 174.66,18.88 174.48,18.78 174.4,18.75 174.1,18.88 173.8,18.75 173.5,18.88 173.2,18.75 172.9,18.88 172.6,18.75 172.53,18.78 172.49,18.82 172.49,19.28 172.32,19.45 172.32,21.06 172.37,21.14 172.46,21.15 172.65,21.12 172.83,21.2 174.17,21.2
GND on BOTTOM (solid shape): 233.95,103.65 234.17,103.12 234.7,102.9 235.01,102.9 235.01,102.39 234.7,102.39 233.81,102.76 233.44,103.65 233.44,112.24 230.91,112.24 230.38,111.71 230.38,107.19 228.91,105.71 222.49,105.71 222.11,105.33 222.11,102.03 222.61,100.99 222.07,99.98 222.07,97.34 221.73,97 221.09,97 220.65,97.45 220.65,99.86 221.06,100.27 221.35,100.27 222.08,100.82 221.73,101.67 221.64,101.77 221.6,101.9 221.6,112.75 233.95,112.75
GND on BOTTOM (solid shape): 283.39,52.96 283.65,52.71 283.39,52.45 282.4,52.45 281.1,51.15 282.4,49.85 283.65,49.85 283.65,39.86 283.65,36.65 283.57,36.48 283.4,36.4 283.1,36.4 282.57,36.18 282.35,35.65 282.35,27.49 282.57,26.96 283.1,26.74 283.6,26.74 283.77,26.66 283.85,26.49 283.85,14.03 283.34,14.03 283.34,26.23 283.1,26.23 282.21,26.6 281.84,27.49 281.84,35.65 282.21,36.54 283.1,36.91 283.14,36.91 283.14,39.86 283.14,49.34 282.4,49.34 280.59,51.15 282.4,52.96
GND on BOTTOM (solid shape): 40.6,55.28 40.78,55.24 42.36,54.25 42.14,53.8 40.69,54.7 29.82,46.43 16.48,43.5 6.4,43.5 2,43.5 1.12,43.14 0.76,42.26 0.76,20.68 0.87,20.4 0.91,20.09 0.91,19.71 5.01,19.71 6.16,19.93 6.81,18.95 6.81,18.92 6.3,18.92 6.3,18.95 5.88,19.49 5.26,19.2 0.4,19.2 0.4,20.09 0.37,20.33 0.25,20.54 0.25,42.26 0.77,43.49 2,44.01 6.4,44.01 16.48,44.01 29.7,46.94 40.44,55.19
GND on BOTTOM (solid shape): 187.05,106.78 187.01,106.65 186.92,106.55 186.55,105.85 187.01,105.2 187.18,105.04 188.44,105.04 188.69,104.79 188.69,102.47 188.5,102.28 187.68,102.28 187.53,102.43 187.53,103.57 187.42,103.68 187.42,104.22 187.01,104.62 184.13,104.62 176.2,96.69 168.54,104.35 168.54,110.69 165.11,110.69 164.85,110.94 165.11,111.2 169.05,111.2 169.05,104.35 176.2,97.2 183.35,104.35 183.35,112.75 187.05,112.75
GND on BOTTOM (solid shape): outline of 114 points within 92.85,67.03 106.96,68.91
GND on BOTTOM (solid shape): 172.6,16.75 172.68,16.72 172.71,16.68 172.71,16.09 172.93,15.87 172.95,15.76 172.86,15.7 168.02,15.7 167.73,15.99 167.2,15.99 166.9,15.7 164.58,15.7 164.49,15.76 164.52,15.87 164.59,15.96 164.62,16.07 164.63,16.09 164.78,16.25 164.78,16.58 164.83,16.67 164.94,16.67 165.14,16.62 165.33,16.72 165.4,16.75 165.48,16.72 165.53,16.67 165.59,16.64 165.65,16.59 165.65,16.51 165.9,16.04 166.34,16.33 166.34,16.34 166.58,16.58 166.63,16.67 166.74,16.67 166.94,16.62 167.13,16.72 167.2,16.75 167.5,16.62 167.8,16.75 168.1,16.62 168.4,16.75 168.7,16.62 169,16.75 169.08,16.72 169.3,16.62 169.53,16.73 169.62,16.69 169.62,16.58 169.61,16.56 169.9,16 170.19,16.56 170.18,16.58 170.18,16.69 170.27,16.73 170.5,16.62 170.73,16.72 170.8,16.75 170.88,16.72 170.95,16.66 171.04,16.62 171.12,16.56 171.1,16.46 171.23,15.91 171.73,16.17 171.73,16.19 171.98,16.44 171.98,16.58 172.03,16.67 172.14,16.67 172.34,16.62 172.53,16.72
GND on BOTTOM (solid shape): outline of 339 points within 168.85,37.82 175.13,68.22
GND on BOTTOM (solid shape): outline of 87 points within 0.25,0.25 274.33,11.07
GND on BOTTOM (solid shape): outline of 384 points within 116.26,80.01 138.08,82.67
GND on BOTTOM (solid shape): outline of 1493 points within 46.12,63.97 161.55,112.75
GND on BOTTOM (solid shape): outline of 7548 points within 136.03,15.7 197.64,31.46
GND on BOTTOM (solid shape): outline of 7891 points within 58.79,15.53 121.35,34.89
GND on IN1 (solid shape): 83.69,68.44 83.69,60.44 83.27,60.02 81.33,60.02 81.13,60.22 81.13,68.17 81.13,68.17 81.13,68.37 81.69,68.93 83.2,68.93
GND on IN1 (solid shape): 273.53,85.74 274.25,85.42 274.97,85.74 281.47,85.74 281.99,85.22 281.99,83.46 281.69,83.16 271.74,83.16 271.58,83.33 271.58,85.5 271.82,85.74
GND on IN1 (solid shape): 207.6,104.08 207.26,103.74 203.8,103.74 203.22,103.16 203.22,102.47 202.88,102.13 202.28,102.13 201.36,103.06 201.36,105.15 203,105.15 203.74,105.77 203.25,106.61 203.25,112.75 207.6,112.75
GND on IN1 (solid shape): 283.65,95.3 276.79,95.3 276.32,94.98 276.45,94.43 276.51,94.34 276.54,94.24 276.54,87.06 276.28,86.81 276.03,87.06 276.03,94.13 275.78,94.84 276.09,95.53 276.09,96.63 275.83,96.89 271.35,96.89 271.35,97.4 283.65,97.4
GND on IN1 (solid shape): 233.95,103.65 234.17,103.12 234.7,102.9 235.01,102.9 235.01,102.39 234.7,102.39 233.81,102.76 233.44,103.65 233.44,112.24 222.11,112.24 222.11,109.26 222.43,108.94 223,108.94 223.19,108.75 223.19,106.59 222.94,106.34 222.49,106.34 222.11,105.96 222.11,102.03 222.61,100.99 222.07,99.98 222.07,97.34 221.73,97 221.09,97 220.65,97.45 220.65,99.86 221.06,100.27 221.35,100.27 222.08,100.82 221.73,101.67 221.64,101.77 221.6,101.9 221.6,112.75 233.95,112.75
GND on IN1 (solid shape): 64.7,101.9 64.66,101.77 64.57,101.67 64.22,100.82 64.95,100.27 65.85,100.27 66.4,99.72 66.4,97.7 67.06,97.04 69.67,97.04 70.14,96.57 70.14,95.88 62.91,88.65 62.91,88.55 62.9,88.45 61.29,86.84 58.58,86.84 58.54,86.8 58.29,86.8 52.59,81.1 52.59,75.32 51.53,74.26 51.53,73.5 51.53,73.42 51.53,73.34 51.53,69.92 51.45,69.84 50.65,69.84 50.17,69.35 50.17,64.19 49.95,63.97 48.06,63.97 46.25,65.1 46.14,65.23 46.14,65.4 47.33,70.27 47.73,75.26 47.73,87.64 47.81,87.82 47.99,87.9 61.65,87.9 62.18,88.12 62.4,88.65 62.4,112.75 64.7,112.75
GND on IN1 (solid shape): 283.39,52.96 283.65,52.71 283.39,52.45 282.4,52.45 281.1,51.15 282.4,49.85 283.65,49.85 283.65,40.04 283.65,36.65 283.57,36.48 283.4,36.4 283.1,36.4 282.57,36.18 282.35,35.65 282.35,27.49 282.57,26.96 283.1,26.74 283.6,26.74 283.77,26.66 283.85,26.49 283.85,14.03 283.34,14.03 283.34,26.23 283.1,26.23 282.21,26.6 281.84,27.49 281.84,35.65 282.21,36.54 283.1,36.91 283.14,36.91 283.14,40.04 283.14,49.34 282.4,49.34 280.59,51.15 282.4,52.96
GND on IN1 (solid shape): 40.6,55.28 40.78,55.24 42.39,54.23 42.14,53.79 40.69,54.7 29.82,46.43 16.48,43.5 6.36,43.5 2,43.5 1.12,43.14 0.76,42.26 0.76,20.68 0.87,20.4 0.91,20.09 0.91,19.71 5.01,19.71 6.16,19.93 6.81,18.95 6.81,18.92 6.3,18.92 6.3,18.95 5.88,19.49 5.26,19.2 0.4,19.2 0.4,20.09 0.37,20.33 0.25,20.54 0.25,42.26 0.77,43.49 2,44.01 6.36,44.01 16.48,44.01 29.7,46.94 40.44,55.19
GND on IN1 (solid shape): 187.05,106.78 187.01,106.65 186.92,106.55 186.56,106.02 186.73,105.41 187.14,105 188.29,105 188.63,104.66 188.63,102.46 188.25,102.08 187.71,102.08 187.44,102.35 187.44,103.65 186.47,104.62 184.13,104.62 176.2,96.69 168.54,104.35 168.54,110.69 165.11,110.69 164.85,110.94 165.11,111.2 169.05,111.2 169.05,104.35 176.2,97.2 183.35,104.35 183.35,112.75 187.05,112.75
GND on IN1 (solid shape): outline of 104 points within 0.25,0.25 283.21,11.07
GND on IN1 (solid shape): outline of 723 points within 77.71,96.74 161.55,112.75
GND on IN1 (solid shape): outline of 1044 points within 116.79,77.66 138.14,81.55
GND on IN2 (solid shape): 83.69,68.33 83.69,60.44 83.27,60.02 81.33,60.02 81.13,60.22 81.13,68.39 81.68,68.94 83.09,68.94
GND on IN2 (solid shape): 272.57,68.35 281.31,68.35 281.48,68.17 281.48,67.28 281.25,67.06 271.15,67.06 270.94,67.26 270.94,68.3 271.07,68.43 272.49,68.43
GND on IN2 (solid shape): 281.99,85.22 281.99,83.46 281.69,83.16 271.46,83.16 271.2,83.42 271.2,85.27 273.35,85.27 273.69,85.6 274.36,85.43 274.97,85.74 281.47,85.74
GND on IN2 (solid shape): 207.6,104.08 207.26,103.74 203.8,103.74 203.22,103.16 203.22,102.47 203.02,102.27 202.17,102.27 201.36,103.08 201.36,105.15 203,105.15 203.74,105.77 203.25,106.61 203.25,112.75 207.6,112.75
GND on IN2 (solid shape): 268.58,95.42 270.16,94.11 270.75,92.15 270.75,92.11 268.39,89.74 264.59,89.74 263.73,92.9 265.82,95.42
GND on IN2 (solid shape): 283.65,95.3 276.79,95.3 276.32,94.98 276.45,94.43 276.51,94.34 276.54,94.24 276.54,87.06 276.28,86.81 276.03,87.06 276.03,94.13 275.78,94.84 276.09,95.53 276.09,96.63 275.83,96.89 271.35,96.89 271.35,97.4 283.65,97.4
GND on IN2 (solid shape): 161.55,109.65 163.2,108 164.85,109.65 164.85,111.2 165.77,111.2 166.2,109.49 165.59,107.83 165.57,107.83 165.54,107.86 162.66,107.86 162.63,107.83 160.81,107.83 160.2,109.49 160.63,111.2 161.55,111.2
GND on IN2 (solid shape): 233.95,103.65 234.17,103.12 234.7,102.9 235.01,102.9 235.01,102.39 234.7,102.39 233.81,102.76 233.44,103.65 233.44,112.24 222.11,112.24 222.11,109.26 222.43,108.94 223,108.94 223.19,108.75 223.19,106.59 222.94,106.34 222.49,106.34 222.11,105.96 222.11,102.03 222.61,100.99 222.07,99.98 222.07,97.34 221.73,97 221.09,97 220.65,97.45 220.65,99.86 221.06,100.27 221.35,100.27 222.08,100.82 221.73,101.67 221.64,101.77 221.6,101.9 221.6,112.75 233.95,112.75
GND on IN2 (solid shape): 283.39,52.96 283.65,52.71 283.39,52.45 282.4,52.45 281.1,51.15 282.4,49.85 283.65,49.85 283.65,39.86 283.65,36.65 283.57,36.48 283.4,36.4 283.1,36.4 282.57,36.18 282.35,35.65 282.35,27.49 282.57,26.96 283.1,26.74 283.6,26.74 283.77,26.66 283.85,26.49 283.85,14.03 283.34,14.03 283.34,26.23 283.1,26.23 282.21,26.6 281.84,27.49 281.84,35.65 282.21,36.54 283.1,36.91 283.14,36.91 283.14,39.86 283.14,49.34 282.4,49.34 280.59,51.15 282.4,52.96
GND on IN2 (solid shape): 40.6,55.28 40.78,55.24 42.38,54.24 42.14,53.8 40.69,54.7 29.82,46.43 16.48,43.5 6.22,43.5 2,43.5 1.12,43.14 0.76,42.26 0.76,20.68 0.87,20.4 0.91,20.09 0.91,19.71 5.01,19.71 6.16,19.93 6.81,18.95 6.81,18.92 6.3,18.92 6.3,18.95 5.88,19.49 5.26,19.2 0.4,19.2 0.4,20.09 0.37,20.33 0.25,20.54 0.25,42.26 0.77,43.49 2,44.01 6.22,44.01 16.48,44.01 29.7,46.94 40.44,55.19
GND on IN2 (solid shape): 187.05,106.78 187.01,106.65 186.92,106.55 186.55,106.01 186.75,105.39 187.1,105.03 188.43,105.03 188.68,104.78 188.68,102.42 188.28,102.02 187.67,102.02 187.47,102.22 187.47,103.75 186.59,104.62 184.13,104.62 176.2,96.69 168.54,104.35 168.54,110.69 165.11,110.69 164.85,110.94 165.11,111.2 169.05,111.2 169.05,104.35 176.2,97.2 183.35,104.35 183.35,112.75 187.05,112.75
GND on IN2 (solid shape): outline of 104 points within 0.25,0.25 283.21,11.07
GND on IN2 (solid shape): outline of 776 points within 118.9,78.19 131.23,84.14
GND on IN2 (solid shape): outline of 2286 points within 46.12,63.96 161.55,112.75
GND on IN2 (solid shape): outline of 5695 points within 119.57,52.16 140.67,68.55
GND on IN3 (solid shape): 83.69,68.31 83.69,60.44 83.27,60.02 81.33,60.02 81.13,60.22 81.13,68.39 81.68,68.94 83.06,68.94
GND on IN3 (solid shape): 272.57,68.35 281.31,68.35 281.48,68.17 281.48,67.28 281.25,67.06 271.15,67.06 270.92,67.28 270.92,68.27 271.07,68.43 272.49,68.43
GND on IN3 (solid shape): 273.53,85.74 274.25,85.42 274.97,85.74 281.47,85.74 281.99,85.22 281.99,83.46 281.69,83.16 271.69,83.16 271.57,83.28 271.57,85.58 271.73,85.74
GND on IN3 (solid shape): 207.6,104.08 207.26,103.74 203.8,103.74 203.22,103.16 203.22,102.55 202.91,102.24 202.3,102.24 201.36,103.18 201.36,105.15 203,105.15 203.74,105.77 203.25,106.61 203.25,112.75 207.6,112.75
GND on IN3 (solid shape): 283.65,95.3 276.79,95.3 276.32,94.98 276.45,94.43 276.51,94.34 276.54,94.24 276.54,87.06 276.28,86.81 276.03,87.06 276.03,94.13 275.78,94.84 276.09,95.53 276.09,96.63 275.83,96.89 271.35,96.89 271.35,97.4 283.65,97.4
GND on IN3 (solid shape): 233.95,103.65 234.17,103.12 234.7,102.9 235.01,102.9 235.01,102.39 234.7,102.39 233.81,102.76 233.44,103.65 233.44,112.24 222.11,112.24 222.11,109.26 222.43,108.94 223,108.94 223.19,108.75 223.19,106.59 222.94,106.34 222.49,106.34 222.11,105.96 222.11,102.03 222.61,100.99 222.07,99.98 222.07,97.34 221.73,97 221.09,97 220.65,97.45 220.65,99.86 221.06,100.27 221.35,100.27 222.08,100.82 221.73,101.67 221.64,101.77 221.6,101.9 221.6,112.75 233.95,112.75
GND on IN3 (solid shape): 283.39,52.96 283.65,52.71 283.39,52.45 282.4,52.45 281.1,51.15 282.4,49.85 283.65,49.85 283.65,40 283.65,36.65 283.57,36.48 283.4,36.4 283.1,36.4 282.57,36.18 282.35,35.65 282.35,27.49 282.57,26.96 283.1,26.74 283.6,26.74 283.77,26.66 283.85,26.49 283.85,14.03 283.34,14.03 283.34,26.23 283.1,26.23 282.21,26.6 281.84,27.49 281.84,35.65 282.21,36.54 283.1,36.91 283.14,36.91 283.14,40 283.14,49.34 282.4,49.34 280.59,51.15 282.4,52.96
GND on IN3 (solid shape): 40.6,55.28 40.78,55.24 42.38,54.24 42.13,53.8 40.69,54.7 29.82,46.43 16.48,43.5 6.43,43.5 2,43.5 1.12,43.14 0.76,42.26 0.76,20.68 0.87,20.4 0.91,20.09 0.91,19.71 5.01,19.71 6.16,19.93 6.81,18.95 6.81,18.92 6.3,18.92 6.3,18.95 5.88,19.49 5.26,19.2 0.4,19.2 0.4,20.09 0.37,20.33 0.25,20.54 0.25,42.26 0.77,43.49 2,44.01 6.43,44.01 16.48,44.01 29.7,46.94 40.44,55.19
GND on IN3 (solid shape): 187.05,106.78 187.01,106.65 186.92,106.55 186.56,106.07 186.68,105.48 186.76,105.35 186.9,105.25 187.13,105.03 188.4,105.03 188.63,104.79 188.63,102.4 188.24,102.01 187.74,102.01 187.46,102.29 187.46,103.84 186.68,104.62 184.13,104.62 176.2,96.69 168.54,104.35 168.54,110.69 165.11,110.69 164.85,110.94 165.11,111.2 169.05,111.2 169.05,104.35 176.2,97.2 183.35,104.35 183.35,112.75 187.05,112.75
GND on IN3 (solid shape): outline of 102 points within 0.25,0.25 283.21,11.07
GND on IN3 (solid shape): outline of 119 points within 46.14,62.52 161.55,112.75
GND on IN3 (solid shape): outline of 3531 points within 118.87,52.02 134.94,68.72
GND on IN4 (solid shape): 83.69,68.32 83.69,60.44 83.27,60.02 81.33,60.02 81.13,60.22 81.13,68.38 81.69,68.94 83.07,68.94
GND on IN4 (solid shape): 272.57,68.35 281.31,68.35 281.48,68.17 281.48,67.28 281.25,67.06 271.15,67.06 270.92,67.28 270.92,68.27 271.07,68.43 272.49,68.43
GND on IN4 (solid shape): 273.53,85.74 274.25,85.42 274.97,85.74 281.47,85.74 281.99,85.22 281.99,83.46 281.69,83.16 271.46,83.16 271.2,83.42 271.2,85.37 271.57,85.74
GND on IN4 (solid shape): 207.6,104.08 207.26,103.74 203.8,103.74 203.22,103.16 203.22,102.53 202.94,102.25 202.25,102.25 201.36,103.14 201.36,105.15 203,105.15 203.74,105.77 203.25,106.61 203.25,112.75 207.6,112.75
GND on IN4 (solid shape): 283.65,95.3 276.79,95.3 276.32,94.98 276.45,94.43 276.51,94.34 276.54,94.24 276.54,87.06 276.28,86.81 276.03,87.06 276.03,94.13 275.78,94.84 276.09,95.53 276.09,96.63 275.83,96.89 271.35,96.89 271.35,97.4 283.65,97.4
GND on IN4 (solid shape): 64.7,101.9 64.66,101.77 64.57,101.67 64.22,100.82 64.95,100.27 65.87,100.27 66.33,99.81 66.33,97.98 67.31,97 72.76,97 73.3,96.46 73.3,93.71 72.8,93.2 67.47,93.2 62.91,88.65 62.58,87.79 61.75,87.39 60.57,86.21 57.63,86.21 49.21,77.79 49.21,70.92 48.63,70.33 48.63,64.1 48.5,63.96 48.07,63.96 46.25,65.1 46.14,65.23 46.14,65.4 47.33,70.27 47.73,75.26 47.73,87.64 47.81,87.82 47.99,87.9 61.65,87.9 62.18,88.12 62.4,88.65 62.4,112.75 64.7,112.75
GND on IN4 (solid shape): 283.39,52.96 283.65,52.71 283.39,52.45 282.4,52.45 281.1,51.15 282.4,49.85 283.65,49.85 283.65,39.95 283.65,36.65 283.57,36.48 283.4,36.4 283.1,36.4 282.57,36.18 282.35,35.65 282.35,27.49 282.57,26.96 283.1,26.74 283.6,26.74 283.77,26.66 283.85,26.49 283.85,14.03 283.34,14.03 283.34,26.23 283.1,26.23 282.21,26.6 281.84,27.49 281.84,35.65 282.21,36.54 283.1,36.91 283.14,36.91 283.14,39.95 283.14,49.34 282.4,49.34 280.59,51.15 282.4,52.96
GND on IN4 (solid shape): 40.6,55.28 40.78,55.24 42.37,54.25 42.14,53.79 40.69,54.7 29.82,46.43 16.48,43.5 6.4,43.5 2,43.5 1.12,43.14 0.76,42.26 0.76,20.68 0.87,20.4 0.91,20.09 0.91,19.71 5.01,19.71 6.16,19.93 6.81,18.95 6.81,18.92 6.3,18.92 6.3,18.95 5.88,19.49 5.26,19.2 0.4,19.2 0.4,20.09 0.37,20.33 0.25,20.54 0.25,42.26 0.77,43.49 2,44.01 6.4,44.01 16.48,44.01 29.7,46.94 40.44,55.19
GND on IN4 (solid shape): outline of 247 points within 220.65,97 235.01,112.75
GND on IN4 (solid shape): 187.05,106.78 187.01,106.65 186.92,106.55 186.55,105.9 186.92,105.25 187.1,105.07 188.42,105.07 188.72,104.77 188.72,102.47 188.46,102.21 187.68,102.21 187.63,102.27 187.63,103.57 187.43,103.77 187.43,104.1 186.92,104.62 184.13,104.62 176.2,96.69 168.54,104.35 168.54,110.69 165.11,110.69 164.85,110.94 165.11,111.2 169.05,111.2 169.05,104.35 176.2,97.2 183.35,104.35 183.35,112.75 187.05,112.75
GND on IN4 (solid shape): 81.05,104.35 88.2,97.2 95.35,104.35 95.35,111.2 99.29,111.2 99.55,111.2 99.55,109.65 101.2,108 102.85,109.65 102.85,111.2 103.11,111.2 105,111.2 105.53,111.42 105.75,111.95 105.75,112.75 158.65,112.75 158.65,111.95 158.87,111.42 159.4,111.2 161.29,111.2 161.55,110.94 161.29,110.69 159.4,110.69 158.51,111.06 158.14,111.95 158.14,112.24 106.26,112.24 106.26,111.95 105.89,111.06 105,110.69 104.01,110.69 103.83,108.21 101.84,106.72 100.75,105.63 100.03,105.63 97.69,103.29 96.14,103.29 95.72,102.87 89.71,96.84 81.84,100.08 79.29,100.08 79.23,100.03 79.17,99.99 79.17,97.32 78.79,96.94 78.16,96.94 77.71,97.38 77.71,99.73 78.25,100.27 78.45,100.27 79.18,100.82 78.83,101.67 78.74,101.77 78.7,101.9 78.7,112.75 81.05,112.75
GND on IN4 (solid shape): outline of 105 points within 0.25,0.25 283.21,11.07
GND on IN4 (solid shape): outline of 826 points within 120.19,66.78 143.29,74.46
GND on IN4 (solid shape): outline of 973 points within 113.51,67.79 118.67,76.86
GND on IN4 (solid shape): outline of 949 points within 116.03,78.41 138.33,81.81
GND on IN4 (solid shape): outline of 1672 points within 93.62,57.25 107.95,76.35
GND on GND1: outline of 223 points within 0.26,0.26 283.85,112.75 ; 10 cut-outs
GND on GND2: outline of 218 points within 0.26,0.26 283.85,112.75
GND on VCC: 206.05,97 203.82,99.24 187.81,99.24 186.42,100.63 183.19,100.63 183.85,102.33 184.11,104.14 184.12,104.14 184.12,111.98 186.28,111.98 186.28,107.03 185.85,105.46 187.07,104.4 187.09,104.38 203.21,104.38 203.23,104.4 204.45,105.46 204.02,107.03 204.02,111.98 206.83,111.98 206.83,102.15 206.4,100.59 207.62,99.52 207.64,99.51 221.56,99.51 221.58,99.52 221.89,99.6 222.17,99.75 222.17,97.36 221.81,97
GND on VCC: 63.17,93.93 63.17,100.01 63.19,100.01 63.84,99.33 64.73,99.01 64.74,99 78.66,99 78.67,99.01 80.17,99.95 80.35,101.71 80.64,102 81.48,100.16 82.76,98.6 78.1,93.93
GND on VCC: 95.15,18.14 94.26,19.02 56.93,19.02 56.44,19.51 56.44,32.63 68.61,44.81 69.24,44.81 72.24,47.81 72.24,48.44 80.67,56.87 95.91,56.87 100.67,61.63 100.67,61.64 103.45,64.42 103.46,64.42 105.06,66.01 106.46,66.01 108.87,68.43 111.83,68.43 112.72,67.54 142.69,67.54 144.98,65.25 151.33,65.25 154.1,62.48 154.1,37.97 159.82,32.25 159.82,18.62 159.33,18.14
GND on VCC: 271.3,66.78 270.43,67.64 270.43,84.66 269.62,85.47 269.62,85.49 269.52,85.75 269.26,85.85 269.24,85.85 264.6,90.49 264.6,95.12 270.74,95.12 271.39,95.77 271.39,96.63 282.88,96.63 282.88,96.07 276.58,96.07 276.56,96.04 276.54,96.04 275.61,95.26 275.77,94.04 275.77,87.26 275.61,86.04 276.54,85.26 276.56,85.26 276.58,85.23 282.88,85.23 282.88,83.72 273.69,83.72 273.67,83.7 273.66,83.7 272.45,82.63 272.88,81.08 272.88,80.43 272.84,80.43 272.28,79.75 272.84,79.08 272.88,79.07 272.88,78.43 272.84,78.43 272.28,77.75 272.84,77.08 272.88,77.07 272.88,74.43 272.84,74.43 272.28,73.75 272.84,73.08 272.88,73.07 272.88,72.43 272.84,72.43 272.28,71.75 272.84,71.08 272.88,71.07 272.88,70.43 272.45,68.87 273.66,67.8 273.67,67.8 273.69,67.78 281.48,67.78 281.48,66.78
GND on VCC: 80.82,57.38 80.82,61.42 79.68,62.56 79.68,66.04 83.87,70.23 83.87,77.47 88.04,81.64 92.66,81.64 93.4,80.89 93.4,62.97 92.02,62.97 91.62,62.56 91.62,61.46 92.02,61.06 93.4,61.06 93.4,57.38
GND on GND3: outline of 218 points within 0.26,0.26 283.85,112.75 ; 6 cut-outs
GNDA on GND1: 278.54,33.73 278.31,33.96 277.67,33.96 277.67,33.99 277.52,34.14 276.66,34.14 276.66,37.06 270.05,37.06 270.05,36.04 269.52,36.04 268.91,36.66 268.91,40.97 266.88,43.01 266.88,50.67 267.77,51.56 267.77,66.16 269.27,67.67 282.25,67.67 282.25,64.22 271.68,64.22 271.14,63.79 271.42,63.17 271.42,57.22 271.14,56.6 271.68,56.18 283.65,56.18 283.65,52.46 282.4,52.46 281.09,51.15 282.4,49.84 283.65,49.84 283.65,36.65 283.57,36.48 283.4,36.41 283.1,36.41 282.57,36.18 282.35,35.65 282.35,34.14 280.87,34.14 280.59,33.86 280.03,33.86 279.9,33.73
GNDA on GND3: 278.77,33.6 278.41,33.96 277.4,33.96 277.29,34.06 277.29,36.6 277.09,36.8 271.5,36.8 271.2,37.11 271.2,37.29 270.18,38.31 270.18,65.65 270.54,66.01 282.22,66.01 282.25,66.04 282.25,64.22 271.68,64.22 271.14,63.79 271.42,63.17 271.42,57.22 271.14,56.6 271.68,56.18 283.65,56.18 283.65,52.46 282.4,52.46 281.09,51.15 282.4,49.84 283.65,49.84 283.65,36.65 283.57,36.48 283.4,36.41 283.1,36.41 282.57,36.18 282.35,35.65 282.35,33.76 282.27,33.76 282.24,33.73 279.17,33.73 279.04,33.6
GNDA_CHG on TOP (solid shape): 56.4,8.31 56.43,8.29 56.45,8.25 56.45,7.76 56.89,7.76 56.89,8.25 56.9,8.29 56.94,8.31 57.33,8.31 57.4,8.23 57.4,7.06 57.28,6.93 56.79,6.93 56.65,7.07 56.65,7.39 56.5,7.54 56.16,7.54 56.16,8.29 56.17,8.3 56.19,8.31
GNDA_CHG on BOTTOM (solid shape): outline of 172 points within 50.91,3.07 54.36,9.05
GNDA_CHG on IN3 (solid shape): outline of 141 points within 51.87,6.4 57.25,9.66
VDD_1.35V on IN4 (solid shape): outline of 91 points within 115.42,12.37 118.63,15.21
+AUX_LDO on TOP (solid shape): 254.88,25.92 254.88,24.61 255.91,23.58 255.91,22.55 255.83,22.48 255.4,22.48 253,24.88 253,25.83 253.14,25.97 254.83,25.97
+BATT_SUM on TOP (solid shape): 174.78,15.34 174.93,15.32 175.08,15.34 175.09,15.34 175.4,15.34 175.41,15.34 175.57,15.32 175.72,15.34 175.73,15.34 176.58,15.34 176.78,15.14 176.78,13.87 177.84,12.81 177.84,12.2 177.77,12.12 175.95,12.12 175.47,11.64 170.73,11.64 170.61,11.76 170.61,15.21 170.74,15.34 174.77,15.34
+BATT_SUM on BOTTOM (solid shape): 176.89,15.09 176.89,12.45 176.58,12.14 175.92,12.14 174.47,10.69 173.13,10.69 172.97,10.85 172.97,11.43 172.64,11.76 171.09,11.76 170.56,12.29 170.56,14.99 170.82,15.24 176.73,15.24
+BATT_SUM on BOTTOM (solid shape): 88.62,10.1 88.62,4.98 88.32,4.67 85.65,4.67 85.27,5.05 85.27,7.59 84.71,8.15 83.69,8.15 83.05,8.8 81.63,8.8 81.63,8.8 80.96,8.99 80.28,9.07 80.18,9.07 79.77,9.04 79.36,8.98 79.27,9 79.24,9.08 79.24,10.13 79.43,10.32 88.39,10.32
+BATT_SUM on IN2 (solid shape): outline of 2693 points within 84.06,3.02 176.78,15.37
+BL_PWR_SRC on BOTTOM (solid shape): 64.73,75.86 64.75,75.85 64.77,75.83 65.2,74.65 65.2,74.4 65.87,73.73 65.87,73.41 66.6,72.68 66.6,70.9 66.85,70.65 66.85,66.01 66.6,65.76 64.82,65.76 64.66,65.92 64.66,72.84 63.36,74.14 62.98,75.21 62.98,75.23 63.04,75.35 64.5,75.92
+DC1_PWR_SRC on TOP (solid shape): 187.19,56.74 190.42,56.74 191.38,55.79 199.26,55.79 199.36,55.78 199.47,55.79 199.98,55.79 200.08,55.78 200.18,55.79 200.65,55.79 200.84,55.98 200.84,56.04 200.9,56.11 202.67,56.11 202.92,55.85 202.92,53.77 202.72,53.57 201.31,53.57 200.2,53.57 199.67,54.1 198.98,54.1 198.47,53.58 198.47,52.79 198.39,52.71 197.82,52.71 197.54,52.44 197.54,51.48 197.36,51.29 197.36,50.4 197.32,50.36 197.17,50.36 197.12,50.41 197.12,53.73 196.75,54.1 185.18,54.1 185.03,54.25 185.03,57.38 185.22,57.57 186.36,57.57
+DC1_PWR_SRC on BOTTOM (solid shape): 186.36,60.87 186.36,58.65 188.67,56.34 188.67,55.08 187.99,54.39 183.57,54.39 182.93,55.03 182.93,56.11 184.19,56.11 184.19,56.06 184.2,56 184.21,55.95 184.24,55.9 184.27,55.86 184.3,55.82 184.34,55.79 184.39,55.76 184.44,55.74 184.49,55.73 184.54,55.73 184.6,55.73 184.65,55.74 184.7,55.76 184.74,55.79 184.79,55.82 184.82,55.86 184.85,55.9 184.88,55.95 184.89,56 184.9,56.06 184.9,56.11 184.89,56.16 184.88,56.21 184.85,56.26 184.82,56.31 184.79,56.34 184.74,56.38 184.7,56.4 184.65,56.42 184.6,56.44 184.54,56.44 184.49,56.44 184.44,56.42 184.39,56.4 184.34,56.38 184.3,56.34 184.27,56.31 184.24,56.26 184.21,56.21 184.2,56.16 184.19,56.11 182.93,56.11 182.93,57.58 182.94,57.58 182.94,58.21 182.94,58.23 182.96,58.25 182.98,58.26 183.48,58.26 183.48,58.96 182.98,58.96 182.96,58.97 182.94,58.98 182.94,59.01 182.94,59.41 182.94,59.43 182.96,59.45 182.98,59.46 183.48,59.46 183.48,60.16 182.98,60.16 182.96,60.17 182.94,60.18 182.94,60.21 182.94,60.83 182.93,60.83 182.93,60.93 183.12,61.12 186.11,61.12
+DC_IN on TOP (solid shape): 51.52,40.58 51.52,40.02 51.23,39.73 51.23,38.18 51.44,37.97 52.38,37.97 53.57,36.78 53.57,35.53 53.44,35.41 52.91,35.41 52.58,35.74 52.58,36.32 52.35,36.55 48.97,36.55 47.98,37.54 47.98,38.4 49.64,40.07 49.64,40.68 49.77,40.8 51.3,40.8
+DC_IN on BOTTOM (solid shape): 83.3,78.27 83.3,74.9 83.11,74.71 81.78,74.71 81.39,75.09 81.39,78.27 81.59,78.46 83.11,78.46
+DC_IN on BOTTOM (solid shape): 52.35,37.69 52.35,36.85 52.25,36.75 48.62,36.75 48.22,37.14 48.22,37.47 49.41,38.66 51.38,38.66
+DC_IN on VCC: 48.16,34.26 47.8,34.62 47.8,37.97 49.96,40.13 49.96,41.14 60.63,51.81 60.63,60.19 77.75,77.32 83.36,77.32 83.36,70.44 79.17,66.25 79.17,62.71 75,62.71 72.95,60.66 72.95,55.83 64.59,47.47 63.19,47.47 49.98,34.26
+DC_IN_SS on TOP (solid shape): 54.9,35.19 54.9,33.76 54.76,33.62 54.76,32.49 54.76,32.42 54.76,32.1 54.76,32.1 54.76,29.92 54.74,29.9 52.48,29.9 52.06,30.33 52.06,34.52 52.76,35.22 54.88,35.22
+DC_IN_SS on TOP (solid shape): 206.27,15.39 206.27,14.63 206.18,14.54 205.53,14.54 205.19,14.2 205.18,14.2 205.09,14.13 205.03,14.05 205.03,14.04 204.58,13.59 203.38,13.59 203.13,13.84 203.13,15.29 203.44,15.6 206.07,15.6
+DC_IN_SS on BOTTOM (solid shape): outline of 100 points within 50.15,30.96 55.99,36.3
+DCIN on TOP (solid shape): 51.54,14.17 51.54,10.74 51.46,10.67 50.83,10.67 50.72,10.77 50.72,12.1 50.29,12.53 50.29,14.25 50.42,14.38 51.33,14.38
+DCIN_JACK on BOTTOM (solid shape): outline of 221 points within 81.43,79.86 93.78,91.35
+DCPRRTC on TOP (solid shape): outline of 157 points within 147.24,67.78 150.15,69.64
+DOCK_PWR_BAR on BOTTOM (solid shape): outline of 224 points within 193.07,11.07 205.73,16.49
+DOCK_PWR_BAR on BOTTOM (solid shape): outline of 366 points within 105.41,92.56 113.13,106.76
+DOCK_PWR_BAR on IN1 (solid shape): outline of 5940 points within 50.9,2.96 199.31,17.12
+DOCK_PWR_BAR on IN3 (solid shape): outline of 738 points within 103.18,2.96 124.36,8.71
+DOCK_PWR_BAR on IN4 (solid shape): outline of 404 points within 148.59,98.96 159.56,109.6
+DOCK_PWR_BAR on VCC: outline of 95 points within 36.37,14.05 159.94,107.16 ; 1 cut-out
+LCDVDD on TOP (solid shape): 53.01,69.56 53.01,68.63 52.12,67.74 51.64,67.74 50.71,68.67 50.71,69.14 50.86,69.29 51.78,69.29 52.17,69.68 52.88,69.68
+LCDVDD on BOTTOM (solid shape): 51.97,69.06 51.97,67.4 51.61,67.04 50.2,67.04 50.01,67.23 50.01,69.05 50.29,69.33 51.7,69.33
+LCDVDD on BOTTOM (solid shape): outline of 172 points within 55.11,62.01 63.81,73.3
+LOM_VCT on TOP (solid shape): 144.64,109.89 144.64,108.81 144.51,108.69 143.75,108.69 143.56,108.88 143.56,109.89 143.69,110.02 144.51,110.02
+LOM_VCT on BOTTOM (solid shape): 144.64,109.89 144.64,109.58 144.58,109.51 144.58,107.67 144.57,107.67 143.82,107.67 143.82,109.92 143.92,110.02 144.51,110.02
+PBATT on TOP (solid shape): 166.62,15.28 166.62,13.68 167.39,12.92 167.95,12.36 167.95,6.32 167.06,5.44 165.32,5.44 164.96,5.79 164.96,9.79 160.12,14.63 160.12,15.14 160.59,15.61 166.29,15.61
+PBATT on BOTTOM (solid shape): 162.56,15.54 162.56,11.63 161.49,10.57 158.42,10.57 158.12,10.87 158.12,13.97 158.27,14.12 159.69,14.12 160.12,14.55 160.12,15.29 160.45,15.62 162.48,15.62
+PBATT_IN_SS on TOP (solid shape): 170.41,15.13 170.41,11.81 170.19,11.59 168.38,11.59 168.14,11.84 168.14,12.5 166.88,13.75 166.88,14.31 166.95,14.39 167.55,14.39 167.68,14.51 167.68,15.12 167.84,15.28 170.26,15.28
+PBATT_IN_SS on BOTTOM (solid shape): 167.33,15.26 167.49,15.23 167.65,15.26 169.01,15.26 169.29,14.99 169.29,12.72 167.26,10.69 163.47,10.69 163.09,11.07 163.09,15.04 163.32,15.26
+PBATT_IN_SS on IN1 (solid shape): 167.22,15.35 167.49,15.23 167.76,15.35 168.73,15.35 168.94,15.14 168.94,12.1 157.16,12.1 156.85,12.42 156.85,13.28 157.25,13.69 162.43,13.69 162.45,13.7 163.64,13.7 165.28,15.35
+PCH_ASATA3PLL on TOP (solid shape): 146.25,91.88 146.25,90.91 145.3,89.95 144.84,89.95 144.83,89.96 144.71,89.98 144.59,89.96 144.58,89.95 144.46,89.95 143.93,89.42 143.43,89.42 143.33,89.52 143.33,90.34 144.15,91.15 144.15,91.95 144.2,92 146.14,92
+PCH_DCPSUS on IN2 (solid shape): outline of 345 points within 143.94,76.49 146.55,82.33
+PCH_DCPSUS1 on TOP (solid shape): 144.81,71.09 144.81,70.88 144.8,70.8 144.81,70.69 144.83,70.66 144.89,70.57 144.99,70.5 145,70.5 145.09,70.41 145.29,70.41 145.38,70.32 145.38,69.96 145.26,69.85 144.93,69.85 144.75,70.03 144.75,70.28 144.68,70.36 144.63,70.36 144.6,70.33 144.6,69.62 144.55,69.57 144.07,69.57 144.02,69.62 144.02,71.12 144.07,71.17 144.73,71.17
+PCH_DCPSUS4 on IN4 (solid shape): outline of 928 points within 143.59,70.94 150.7,79.31
+PCH_RTC_VCCSUS3_3 on IN3 (solid shape): 144.84,67.31 144.92,67.26 144.93,67.16 144.89,66.94 145,66.75 145.04,66.67 145,66.59 144.98,66.1 145.47,66.12 145.58,66.15 145.64,66.05 145.64,65.35 145.52,65.23 145.07,65.23 144.99,65.26 144.97,65.34 144.65,65.71 144.31,65.36 144.29,65.32 144.24,65.31 144.21,65.32 144.12,65.4 144.12,66 144.16,66.08 144.26,66.09 144.72,66.4 144.26,66.7 144.16,66.71 144.12,66.79 144.12,67.21 144.22,67.31
+PCH_VCC1P05 on TOP (solid shape): outline of 157 points within 140.96,76.68 142.16,81.51
+PCH_VCCDSW3_3 on TOP (solid shape): 166.57,68.25 166.57,68.01 166.26,67.69 165.87,67.69 165.51,67.32 165.51,66.84 165.43,66.76 165.21,66.76 164.91,67.07 164.36,67.07 164.25,67.18 164.25,68.13 164.43,68.31 166.51,68.31
+PCH_VCCDSW3_3 on IN3 (solid shape): outline of 375 points within 145.74,66.6 151.44,68.38
+PWR_SRC on TOP (solid shape): 75.93,9.12 75.93,7.15 75.43,6.64 71.23,6.64 70.92,6.96 70.92,9.25 71.23,9.56 75.49,9.56
+PWR_SRC on TOP (solid shape): 224.02,73.3 224.02,70.46 223.76,70.21 221.52,70.21 221.25,70.48 221.25,73.07 221.54,73.35 223.96,73.35
+PWR_SRC on TOP (solid shape): 107.69,6.35 108.06,6.35 108.1,6.33 108.11,6.3 108.11,5.81 108.62,5.81 108.62,6.3 108.63,6.33 108.67,6.35 108.86,6.35 108.9,6.33 108.91,6.3 108.91,5.81 109.42,5.81 109.42,6.3 109.43,6.33 109.47,6.35 110.26,6.35 110.45,6.35 110.67,6.13 110.67,4.99 110.53,4.85 106.12,4.85 106.02,4.95 106.02,5.64 106.74,6.36 107.68,6.36
+PWR_SRC on BOTTOM (solid shape): 72.12,68.05 72.12,65.51 71.93,65.32 67.36,65.32 67.04,65.63 67.04,66.65 67.3,66.9 68.63,66.9 69.98,68.25 71.92,68.25
+PWR_SRC on BOTTOM (solid shape): 75.8,61.97 75.8,60.35 75.03,59.58 75.03,59.36 75.01,59.33 75.01,56.11 74.75,55.85 72.44,55.85 72.25,56.04 72.25,59.41 72.82,59.98 72.82,60.81 74.09,62.08 75.69,62.08
+PWR_SRC on BOTTOM (solid shape): 182.8,60.74 182.8,54.98 182.8,54.46 183.31,53.95 189.66,53.95 190.23,53.38 190.23,50.14 189.6,49.5 179.44,49.5 177.91,51.03 177.91,57.07 179.15,57.07 179.15,57.01 179.15,56.96 179.17,56.91 179.19,56.86 179.22,56.82 179.26,56.78 179.3,56.74 179.35,56.72 179.4,56.7 179.45,56.69 179.5,56.68 179.56,56.69 179.61,56.7 179.66,56.72 179.7,56.74 179.74,56.78 179.78,56.82 179.81,56.86 179.83,56.91 179.85,56.96 179.86,57.01 179.86,57.07 179.85,57.12 179.83,57.17 179.81,57.22 179.78,57.26 179.74,57.3 179.7,57.33 179.66,57.36 179.61,57.38 179.56,57.39 179.5,57.4 179.45,57.39 179.4,57.38 179.35,57.36 179.3,57.33 179.26,57.3 179.22,57.26 179.19,57.22 179.17,57.17 179.15,57.12 179.15,57.07 177.91,57.07 177.91,60.43 178.36,60.87 182.68,60.87
+PWR_SRC on BOTTOM (solid shape): 75.39,13.28 76.02,13.28 76.96,12.34 77.34,12.34 77.38,12.31 77.38,10.92 77.74,10.57 78.09,10.92 78.09,12.24 78.11,12.28 78.14,12.29 78.66,12.29 78.73,12.23 78.73,8.79 77.4,7.93 76.5,6.63 76.2,6.32 70.92,6.32 70.69,6.55 70.69,9.14 71.3,9.75 71.3,14.48 71.5,14.68 73.99,14.68
+PWR_SRC on IN3 (solid shape): 207.82,58.42 207.82,57.56 207.53,57.27 206.4,57.27 206.15,57.52 206.15,58.39 206.32,58.57 207.67,58.57
+PWR_SRC on IN3 (solid shape): 75.9,12.85 75.9,7.92 74.6,6.63 71.12,6.63 70.87,6.88 70.87,10.52 71.3,10.95 71.3,14.53 71.43,14.66 74.09,14.66
+PWR_SRC on IN3 (solid shape): outline of 397 points within 207.38,66.81 222.4,73.41
+PWR_SRC on IN3 (solid shape): outline of 635 points within 53.19,11.07 66.52,21.36
+PWR_SRC on VCC: 50.58,19.02 50.34,19.26 50.34,33.9 63.4,46.96 64.8,46.96 73.46,55.62 73.46,60.45 75.21,62.2 79.32,62.2 80.32,61.21 80.32,57.23 71.74,48.65 71.74,48.02 69.03,45.31 68.4,45.31 55.93,32.85 55.93,19.38 55.57,19.02
+PWR_SRC on VCC: outline of 468 points within 71.55,1.02 219.1,59.03
+PWR_SRC_AC on BOTTOM (solid shape): outline of 257 points within 198.34,5.93 206.17,13.37
+PWR_SRC_AC on BOTTOM (solid shape): outline of 724 points within 51.33,9.94 58.57,25.69
+PWR_SRC_AC on IN4 (solid shape): 59.55,13.23 59.65,13.22 59.75,13.23 67.92,13.23 68.91,12.24 68.91,9.22 68.63,8.94 64.72,8.94 63.6,10.06 54.41,10.06 54.15,10.31 54.15,11.7 54.65,12.2 55.26,11.89 54.94,12.49 55.68,13.23
+PWR_SRC_AC on IN4 (solid shape): outline of 3304 points within 100.97,1.29 202.62,12.04
+RTC_CELL on TOP (solid shape): 143.18,68.68 143.18,68.3 143.28,68.2 143.28,68.19 143.29,68.19 143.31,68.17 143.94,68.17 144.01,68.11 144.01,66.2 143.8,66 143.23,66 143.23,66.7 143.23,66.95 143.12,67.06 143.12,67.4 143.06,67.47 143.07,67.5 142.96,67.92 142.53,67.87 142.42,67.85 142.35,67.94 142.35,68.55 142.55,68.74 143.12,68.74
+RTC_CELL on IN1 (solid shape): outline of 117 points within 143.28,65.95 145.64,68.16
+SD_IO_LDO on TOP (solid shape): 255.89,17.26 255.89,16.47 255.7,16.28 255.11,16.28 254.93,16.1 254.22,16.1 253.91,15.8 253.91,15.39 253.8,15.28 253.34,15.28 252.98,14.92 252.98,14.43 252.92,14.36 252.11,14.36 252.02,14.45 252.02,15.1 252.26,15.34 252.26,15.76 252.59,16.09 253.44,16.09 254,16.65 254.75,16.65 255.41,17.31 255.84,17.31
+SDC_IN on TOP (solid shape): 46.47,5.88 46.98,5.88 47.17,5.69 47.17,4.95 47.3,4.82 47.97,4.82 47.99,4.8 47.99,4.35 47.85,4.21 47.06,4.21 46.98,4.29 46.66,4.29 46.47,4.1 46.47,3.21 46.28,3.02 45.33,3.02 45.14,3.21 45.14,4.23 45.39,4.48 45.64,4.48 45.9,4.74 45.9,5.5 45.52,5.88 44.76,5.88 44.69,5.94 44.69,6.26 44.76,6.32 46.03,6.32
+SDC_IN on BOTTOM (solid shape): 54.06,30.23 54.06,29.25 54.34,28.96 54.34,26.71 54.28,26.64 53.37,26.64 53.33,26.66 53.32,26.69 53.32,28.08 52.96,28.44 52.6,28.08 52.6,26.66 52.59,26.64 52.06,26.64 51.61,27.09 51.61,30.33 51.8,30.52 53.77,30.52
+SM_VREF_CA on IN3 (solid shape): outline of 298 points within 120.36,55.57 122.23,63.96
+SM_VREF_CA_DIMM on TOP (solid shape): 111.13,20.01 111.13,19.12 111.15,19.09 111.15,19.08 111.73,18.86 111.63,19.47 111.6,19.52 111.63,19.56 111.66,19.58 111.69,19.6 112.56,19.6 112.65,19.54 112.65,19.44 112.99,18.88 113.17,19.51 113.15,19.56 113.2,19.6 113.27,19.6 113.43,19.44 113.43,17.2 113.35,17.12 110.67,17.12 110.36,17.42 110.36,19.99 110.46,20.09 111.05,20.09
+SM_VREF_DQ1 on IN3 (solid shape): 119.01,64.08 119.2,64.02 119.4,64.08 120.09,64.08 120.37,63.8 120.37,63.43 120.24,63.3 120.22,63.29 120.2,63.29 119.79,63 120.14,62.64 120.21,62.61 120.24,62.54 120.24,61.47 119.86,61.09 118.34,61.09 118.09,61.33 118.09,61.35 118.01,61.52 117.84,61.62 117.83,61.63 117.81,61.66 117.81,63.63 117.86,63.68 117.89,63.69 117.93,63.68 117.94,63.64 117.97,63.49 118.06,63.37 118.09,63.3 118.06,63.22 118.27,62.64 118.49,63.22 118.46,63.3 118.6,63.62 118.46,63.95 118.49,64.02 118.53,64.06 118.55,64.08 118.57,64.08
+USB_PWR on TOP (solid shape): outline of 404 points within 216.46,90.33 228.12,98.72
+USB_PWR on BOTTOM (solid shape): 227.95,91.6 227.95,89.95 226.37,88.37 226.37,88.3 226.35,88.26 226.33,88.21 226.32,88.16 226.31,88.11 226.32,88.05 226.33,88 226.35,87.95 226.37,87.93 226.37,86.91 226.3,86.84 225.39,86.84 225.3,86.93 225.3,87.58 224.77,88.1 224.77,88.74 225.28,89.24 225.28,90.11 226.94,90.11 226.94,90.05 226.94,90 226.96,89.95 226.98,89.9 227.01,89.86 227.05,89.82 227.09,89.79 227.14,89.76 227.19,89.74 227.24,89.73 227.29,89.72 227.35,89.73 227.4,89.74 227.45,89.76 227.49,89.79 227.53,89.82 227.57,89.86 227.6,89.9 227.62,89.95 227.64,90 227.65,90.05 227.65,90.11 227.64,90.16 227.62,90.21 227.6,90.26 227.57,90.3 227.53,90.34 227.49,90.38 227.45,90.4 227.4,90.42 227.35,90.43 227.29,90.44 227.24,90.43 227.19,90.42 227.14,90.4 227.09,90.38 227.05,90.34 227.01,90.3 226.98,90.26 226.96,90.21 226.94,90.16 226.94,90.11 225.28,90.11 225.28,92.08 225.37,92.18 227.38,92.18
+USB_SIDE_PWR on TOP (solid shape): 272.01,72.49 272.01,70.94 271.75,70.69 268.05,70.69 268,70.74 268,72.31 268.1,72.41 270.74,72.41 271.15,72.82 271.68,72.82
+USB_SIDE_PWR on TOP (solid shape): 237.36,84.84 237.36,83.51 236.8,82.96 236.8,82.93 236.28,82.4 232.58,82.4 232.45,82.54 232.45,84.29 232.56,84.4 234.15,84.4 234.7,84.95 237.25,84.95
+USB_SIDE_PWR on BOTTOM (solid shape): 270.56,81.95 272.31,81.95 272.49,81.77 272.49,80.49 272.17,80.17 267.96,80.17 266.59,81.55 266.59,84.18 266.69,84.28 268.24,84.28
+USB_SIDE_PWR on IN2 (solid shape): 272.34,81.64 272.34,80.47 271.93,80.06 268.53,80.06 268.4,80.19 268.4,81.56 268.61,81.76 272.21,81.76
+USB_SIDE_PWR on IN2 (solid shape): outline of 1093 points within 235.36,79.54 264.21,86.46
+USB_SIDE_PWR on IN4 (solid shape): outline of 104 points within 268.22,71.12 272.29,81.89
+VCHGR on TOP (solid shape): 83.83,15 83.83,11.11 83.49,10.77 81.52,10.77 81.33,10.96 81.33,15.34 81.52,15.53 83.31,15.53
+VCHGR on BOTTOM (solid shape): 87.3,15.34 87.3,13.31 86.92,12.93 86.92,11.28 86.41,10.77 79.24,10.77 79.17,10.83 79.17,13.06 78.92,13.31 78.09,13.31 78.09,14.68 77.74,15.04 77.38,14.68 77.38,13.34 77.35,13.31 76.57,13.31 76.38,13.5 76.38,15.47 76.51,15.6 87.05,15.6
+VDISPLAY_VCC on TOP (solid shape): 269.33,87.01 269.33,85.8 268.87,85.34 267.23,85.34 267.11,85.47 267.11,87.21 267.36,87.46 268.87,87.46
+VDISPLAY_VCC on TOP (solid shape): 272.89,87.84 272.89,86.94 272.71,86.77 271.86,86.77 271.73,86.89 271.73,86.93 271.76,87.02 271.77,87.1 271.77,87.29 271.59,87.46 271.42,87.46 271.4,87.49 271.4,88.02 271.48,88.1 272.63,88.1
+VDISPLAY_VCC on BOTTOM (solid shape): 273.43,87.86 273.43,86.99 273.16,86.73 271.92,86.73 271.75,86.89 271.75,87.02 271.74,87.03 271.63,87.36 271.3,87.44 271.22,87.46 271.18,87.54 271.18,88.07 271.23,88.12 271.83,88.12 271.97,88.15 272.09,88.21 273.08,88.21
+VDISPLAY_VCC on IN3 (solid shape): outline of 135 points within 267.68,85.98 272.93,89.14
+VHDMI_VCC on BOTTOM (solid shape): 199.89,100.79 199.89,99.76 199.67,99.54 198.96,99.54 198.7,99.8 198.7,100.84 198.81,100.94 199.73,100.94
+VHDMI_VCC on BOTTOM (solid shape): 186.51,103.15 186.51,99.97 186.77,99.72 187.77,99.72 187.87,99.62 187.87,98.65 187.8,98.57 185.62,98.57 185.15,99.03 185.15,99.99 185.52,100.35 185.52,103.16 185.64,103.28 186.39,103.28
+VHDMI_VCC on IN4 (solid shape): outline of 206 points within 185.5,99.5 200.15,103.38
+VLDOIN_1.35V on TOP (solid shape): 114.72,10.11 114.72,9.94 114.69,9.91 113.89,9.91 113.86,9.88 113.21,9.88 112.4,9.07 111.13,9.07 111.05,9.14 111.05,9.75 111.15,9.85 112.3,9.85 112.55,10.11 113.8,10.11 113.85,10.16 114.66,10.16
+VREFOUT on TOP (solid shape): 277.37,41.15 277.37,40.5 277.93,39.94 277.93,39.72 277.83,39.62 277.57,39.62 277.19,40 276.79,40 276.62,39.82 276.12,39.82 276.09,39.85 276.09,40.34 276.12,40.37 276.45,40.37 276.65,40.56 276.65,41.14 276.74,41.23 277.3,41.23
-DCIN_JACK on BOTTOM (solid shape): 92.57,87.2 92.57,84.11 92.32,83.86 91.24,83.86 91.05,83.67 91.05,82.78 91.3,82.52 92.06,82.52 92.19,82.4 92.19,81.38 92.17,81.36 86.44,81.36 86.33,81.47 86.33,82.09 87.67,83.43 88.03,83.52 88.12,83.88 88.25,84.01 88.25,85.63 89.97,87.35 92.43,87.35
ACAV_IN# on TOP (solid shape): 138.48,5.94 138.49,5.87 138.52,5.81 138.52,5.46 138.54,5.43 138.54,5.18 138.67,5.05 140.13,5.05 140.26,4.93 140.26,4.55 140.2,4.48 138.82,4.48 138.81,4.47 138.28,4.47 137.85,4.04 136.77,4.04 136.39,4.42 136.39,5.75 136.64,6.01 138.42,6.01
AUD_HP_OUT_R1 on TOP (solid shape): 276.89,52.68 276.89,52.35 276.12,51.59 275.71,51.59 274.76,51.59 274.16,52.2 273.09,52.2 272.61,51.71 272.09,51.71 272.01,51.79 272.01,52.79 272.29,53.07 276.49,53.07
BOOT_1.35V on TOP (solid shape): 112.34,10.49 113.57,10.49 113.63,10.55 114.67,10.55 114.72,10.5 114.72,10.38 114.66,10.32 113.77,10.32 113.74,10.29 112.55,10.29 112.24,9.98 110.95,9.98 110.87,10.06 110.87,10.79 110.92,10.85 111.99,10.85
BST_3V on TOP (solid shape): 201.02,50.67 201.02,49.76 200.94,49.68 199.21,49.68 199.07,49.54 197.98,49.54 197.93,49.59 197.93,49.71 197.98,49.76 198.88,49.76 199.87,50.75 200.94,50.75
BST_5V on TOP (solid shape): 194.6,49.77 195.72,49.77 195.75,49.74 195.75,49.54 195.68,49.48 194.59,49.48 194.34,49.73 194.34,49.73 194.21,49.86 192.61,49.86 192.53,49.94 192.53,50.85 192.58,50.9 193.47,50.9
BST_+V1.05SP on TOP (solid shape): 236.12,73.13 236.12,73.05 235.69,72.62 235.69,72.34 236.4,71.63 236.4,70.54 236.32,70.46 235.38,70.46 235.2,70.64 235.2,73.1 235.33,73.23 236.02,73.23
CHAGER_SRC on TOP (solid shape): 56.8,15.21 62.69,15.21 62.76,15.21 62.84,15.21 64.77,15.21 64.87,15.11 64.87,11.2 64.26,10.59 60.17,10.59 59.97,10.79 59.97,11.81 59.58,12.2 56.53,12.2 56.36,12.37 56.36,14.57 55.78,15.15 55.78,15.67 55.85,15.75 56.27,15.75
CHAGER_SRC on BOTTOM (solid shape): 59.33,15.09 60.66,15.09 60.66,15.09 62.03,15.09 62.22,14.9 62.22,13.06 61.39,12.23 61.39,10.13 61.14,9.88 58.28,9.88 58.15,10.01 58.15,10.28 58.16,10.28 58.16,10.91 58.17,10.95 58.21,10.96 58.71,10.96 58.71,11.66 58.21,11.66 58.17,11.68 58.16,11.71 58.16,12.11 58.17,12.15 58.21,12.16 58.71,12.16 58.71,12.86 58.21,12.86 58.17,12.88 58.16,12.91 58.16,13.53 58.12,13.58 57.63,13.58 57.49,13.72 57.49,14.46 58.12,15.09 59.33,15.09
CHG_LGATE on TOP (solid shape): 55.36,9.63 55.36,9.18 54.97,8.79 53.82,8.79 53.77,8.84 53.77,8.99 54.1,9.32 54.1,9.63 54.23,9.75 55.23,9.75
CHG_LGATE on TOP (solid shape): 62.73,5.75 62.73,4.67 62.54,4.48 61.46,4.48 61.42,4.51 60.29,4.51 60.06,4.75 60.06,5.21 60.33,5.47 61.11,5.47 61.52,5.88 62.6,5.88
CHG_LGATE on IN2 (solid shape): 61.3,5.71 61.3,4.85 61.18,4.72 59.84,4.72 59.5,5.07 59.5,5.7 59.97,6.17 60.85,6.17
CHG_LGATE on IN2 (solid shape): 57.21,9.31 57.21,8.8 56.81,8.39 56.53,8.39 56.08,8.84 54.29,8.84 54.1,9.03 54.1,9.59 54.27,9.75 56.77,9.75
CHG_UGATE on TOP (solid shape): 53.04,11.51 53.04,10.59 52.71,10.26 52.71,9.17 52.63,9.09 52.53,9.09 52.43,9.19 52.43,11.45 52.6,11.63 52.91,11.63
CHG_UGATE on TOP (solid shape): 69.8,14.2 69.8,13.54 69.57,13.31 68.91,13.31 67.89,14.33 65.39,14.33 65.27,14.45 65.27,14.96 65.52,15.21 68.78,15.21
CHG_UGATE on IN2 (solid shape): 69.77,13.82 69.77,12.12 69.62,11.96 68.91,11.96 68.63,12.24 68.63,13.82 68.78,13.97 69.62,13.97
CHG_UGATE on IN2 (solid shape): 54.41,12.92 54.41,12.25 53.82,11.66 53.82,10.59 53.59,10.36 52.78,10.36 52.5,10.64 52.5,12.17 53.55,13.21 54.12,13.21
DH_1.35V on TOP (solid shape): 107.56,8.67 107.56,7.85 107.37,7.66 106.54,7.66 106.41,7.78 106.41,8.67 106.6,8.86 107.37,8.86
DH_1.35V on TOP (solid shape): 113.7,10.97 114.68,10.97 114.73,10.92 114.73,10.74 114.68,10.69 113.56,10.69 113.49,10.62 112.42,10.62 112.34,10.69 112.34,11.05 112.47,11.18 113.49,11.18
DH_1.35V on IN4 (solid shape): 108.81,8.48 108.81,7.67 108.66,7.52 106.6,7.52 106.32,7.8 106.32,8.43 106.55,8.66 108.64,8.66
DH_1.35V on IN4 (solid shape): 113.64,11 113.64,9.85 113.23,9.45 112.75,9.45 112.4,9.8 112.4,11 112.55,11.15 113.49,11.15
DL_1.35V on TOP (solid shape): 103.81,14.01 103.81,13.18 103.62,12.99 102.86,12.99 102.73,13.12 102.73,14.13 102.79,14.2 103.62,14.2
DL_1.35V on TOP (solid shape): 115.11,12.72 115.11,11.6 115.05,11.53 114.97,11.53 114.91,11.59 114.91,12.01 114.63,12.29 113.74,12.29 113.61,12.42 113.61,12.9 113.74,13.03 114.81,13.03
DL_1.35V on IN4 (solid shape): 104.67,14.07 104.67,13.66 104.01,13 102.67,13 102.59,13.08 102.59,14.07 102.72,14.2 104.55,14.2
DL_1.35V on IN4 (solid shape): 114.53,14.33 114.56,14.31 114.58,14.27 114.91,13.94 114.91,13.58 114.88,13.44 114.91,13.3 114.91,12.5 114.73,12.32 113.87,12.32 113.59,12.6 113.59,14.22 113.69,14.33
INT_SPK_L+ on TOP (solid shape): 281.01,22.64 281.01,20.32 280.86,20.17 279.72,20.17 279.58,20.31 279.58,20.92 279.99,21.33 279.99,22.12 279.5,22.61 279.5,22.88 279.64,23.02 280.63,23.02
INT_SPK_L+ on TOP (solid shape): 269.27,35.24 270.15,35.24 270.22,35.18 270.22,34.99 270.15,34.92 269.32,34.92 269.25,34.99 268.81,34.99 268.64,35.15 268.29,35.15 268.19,35.25 268.19,35.6 268.3,35.71 268.8,35.71
INT_SPK_L+ on IN1 (solid shape): 270.42,35.98 270.42,35.09 270.3,34.97 269.76,34.97 269.72,35.01 268.87,35.01 268.63,35.25 268.28,35.25 268.19,35.34 268.19,35.57 268.68,36.07 270.33,36.07
INT_SPK_L+ on IN1 (solid shape): 280.26,23.63 280.26,23.23 280.57,22.92 280.78,22.92 281.04,22.67 281.04,22.26 280.84,22.06 279.92,22.06 279.25,22.73 279.25,23.56 279.44,23.75 280.15,23.75
INT_SPK_L- on TOP (solid shape): 268.62,34.77 269.11,34.77 269.18,34.71 270.15,34.71 270.23,34.63 270.23,34.51 270.14,34.42 269.38,34.42 269.32,34.36 268.9,34.36 268.82,34.44 268.68,34.44 268.62,34.5 268.18,34.5 268.14,34.54 268.14,34.77 268.24,34.87 268.52,34.87
INT_SPK_L- on TOP (solid shape): 278.05,22.73 278.05,21.32 278.97,20.41 278.97,20.18 278.81,20.02 276.91,20.02 276.81,20.12 276.81,21.21 276.99,21.4 276.99,22.69 277.18,22.88 277.9,22.88
INT_SPK_L- on IN1 (solid shape): 278.38,23.75 278.38,22.71 277.76,22.08 277.19,22.08 277.06,22.21 277.06,23.52 277.51,23.96 278.17,23.96
INT_SPK_L- on IN1 (solid shape): 268.74,34.78 269.49,34.78 269.56,34.72 270.48,34.72 270.76,34.44 270.76,34.18 270.26,33.67 269.99,33.67 269.44,34.21 268.92,34.21 268.68,34.45 268.24,34.45 268.14,34.56 268.14,34.78 268.25,34.9 268.63,34.9
INT_SPK_R+ on TOP (solid shape): 268.74,33.22 270.17,33.22 270.24,33.15 270.24,33.01 270.15,32.92 268.25,32.92 267.34,33.83 267.34,34 267.49,34.15 267.82,34.15
INT_SPK_R+ on TOP (solid shape): 276.73,22.53 276.73,21.57 276.51,21.34 276.51,20.44 276.21,20.14 274.87,20.14 274.74,20.27 274.74,20.89 275.41,21.56 275.41,21.93 275.65,22.17 275.93,22.17 276.38,22.62 276.64,22.62
INT_SPK_R+ on IN1 (solid shape): 276.78,22.47 276.78,21.44 276.39,21.04 275.54,21.04 275.41,21.17 275.41,21.98 275.54,22.11 275.84,22.11 276.36,22.63 276.62,22.63
INT_SPK_R+ on IN1 (solid shape): 268.22,33.69 268.22,33.57 268.69,33.1 268.69,32.83 269.04,32.49 269.04,32.36 268.43,31.75 268.33,31.75 267.28,32.79 267.28,34.01 267.45,34.18 267.74,34.18
