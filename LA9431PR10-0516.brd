# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP7-: length 89
  IN1 w0.084: v2(144.13,63.16) 143.91,63.38 143.61,63.38 143.23,63.77 143.23,65.53 142.79,65.96 142.45,65.96 141.16,67.26 140.73,67.26 140.51,67.03 140.11,67.03 139.61,67.54 137.33,67.54 137,67.21 136.49,67.21 136.22,67.47 131.09,67.47 130.05,68.52 119.61,68.52 118.44,67.35 115.95,67.35 115.21,68.08 112.76,68.08 112.34,68.5 111.35,68.5 111.24,68.39 109.93,68.39 109.93,68.39 109.91,68.39
  IN1 w0.091: 109.91,68.39 108.09,68.39 106.6,69.87 93.41,69.87 93.07,69.53 87.76,69.53 87.05,70.24 80.49,70.24 79.99,70.74 79.99,71.68 v2(79.81,71.85)
  BOTTOM w0.076: UC1.AR13 143.85,63.44 v2(144.13,63.16)
  BOTTOM w0.102: v2(79.81,71.85) 80.1,72.14 80.1,72.4 79.76,72.75 78.19,72.75 76.92,74.02 76.63,74.02 76.53,73.92 D8.2 75.73,73.16 75.63,73.27 75.63,74.09 75.5,74.22 75.18,74.22 74.96,74.45 74.96,75.3 74.03,76.22 74,76.22 73.47,76.75 73.47,76.78 71.4,78.85 70.31,78.85 69.92,78.46 69.92,78.27 69.95,78.18 70.13,78.09 JEDP1.39
USBRBIAS: length 5.7
  TOP w0.102: v1(144.79,67.33) 145.13,67 v2(145.22,67) 144.81,66.59 144.81,66.19 144.45,65.84 142.57,65.84 142.48,65.75 RC159.1
  BOTTOM w0.254: UC1.AJ11 144.9,66.69 v2(145.22,67) 145.53,66.69 UC1.AJ10
USH_DET#: length 114.9
  TOP w0.102: v2(185.57,22.3) 184.27,22.3 183.91,22.67 183.56,22.67 182.99,23.23 182.99,25.11 184.21,26.33 184.21,43.01 178.47,48.75 178.47,53.28 177.91,53.84 177.91,57.36 178.47,57.92 178.47,64.25 175,67.73 173.02,67.73 172.22,68.53 172.22,71.75 172.96,72.49 172.96,75.2 171.1,77.06 169.66,77.06 169.28,77.44 169.28,79.46 v5(169.06,79.68) 168.64,80.1 162.9,80.1 162.22,79.41 162.22,79.08 161.98,78.84 161.25,78.84 160.52,79.57 155.44,79.57 155.21,79.35 154.67,79.35 153.99,80.03 150.6,80.03 v2(150.29,79.73) ; v2(193.35,20.61) 194.11,19.85 194.11,19.21 194.36,18.96 194.36,15.63 194.01,15.27 194.01,8.32 192.76,7.07 JUSH1.20
  IN2 w0.122: v2(185.57,22.3) 186,21.87 192.71,21.87 193.35,21.23 v2(193.35,20.61)
  BOTTOM w0.076: UC1.E3 149.97,80.05 v2(150.29,79.73)
USH_PWR_ON: length 210.1
  TOP w0.102: R439.1 196.08,30.78 195.06,29.77 195.06,26.39 v1(194.13,25.46) 193.28,24.61 v2(189.73,24.61) ; v2(26.53,31.79) 26.53,31.53 26.26,31.27 U37.A18
  IN3 w0.122: v2(131.32,20.92) 131.62,20.61 133.79,20.61 134.71,19.7 135.99,19.7 136.46,20.17 136.46,22.53 136.96,23.02 138.25,23.02 138.93,23.71 148.55,23.71 150.53,25.69 188.65,25.69 v2(189.73,24.61)
  BOTTOM w0.102: v2(26.53,31.79) 26.53,32.49 26.81,32.77 26.81,33.39 28.71,35.29 28.71,37.39 29.85,38.53 31.41,38.53 40.62,47.74 42.34,47.74 43.39,48.79 45.91,48.79 46.5,48.2 47.04,48.2 48.61,46.63 49.61,46.63 52.1,44.14 55.03,44.14 56.17,43 63.4,43 65.15,41.25 125.49,41.25 129.51,37.22 129.51,33.15 129.85,32.81 129.85,30.68 130.71,29.82 130.71,27.1 131.04,26.77 131.04,24.15 131.55,23.65 131.55,21.14 v2(131.32,20.92)
USH_PWR_STATE#: length 246.3
  TOP w0.102: U37.A34 23.43,40.86 v2(23.56,40.99)
  IN2 w0.122: v2(133.12,18.87) 133.28,18.72 180.16,18.72 181.87,17.01 181.87,7.07 184.65,4.29 189.37,4.29 189.7,3.96 192.89,3.96 193.11,4.18 204.65,4.18 206.03,5.56 206.03,5.62 v2(206.46,6.04)
  IN3 w0.122: v2(206.46,6.04) 205.8,5.38 204.71,5.38 203.68,4.35 202.14,4.35 201.96,4.53 198.21,4.53 197.83,4.91 197.83,5.55 197.28,6.1 196.57,6.1 196.25,6.42 191.17,6.42 190.74,6.84 v2(190.74,6.96)
  BOTTOM w0.102: v2(133.12,18.87) 132.24,19.75 132.24,24.61 132.81,25.18 132.81,30.36 132.06,31.11 132.06,38.19 124.93,45.31 67.65,45.31 66.95,46.01 58.85,46.01 57.75,47.1 53.6,47.1 52.62,48.08 52.62,49.35 51.81,50.16 49.96,50.16 48.85,51.27 47.65,51.27 46.5,52.42 39.24,52.42 32.99,46.16 31.31,46.16 29.17,44.03 24.97,44.03 23.76,42.82 23.76,41.19 v2(23.56,40.99)
  vias: v1(190.88,7.63)
USH_SMBCLK: length 231.9
  TOP w0.102: JUSH1.5 185.26,6.48 184.76,6.97 v2(184.06,6.97) 184.06,7.39 v1(183.67,7.78) 183.47,7.99 R190.2 ; v2(18.28,18.38) 18.82,17.83 U38.A50
  IN2 w0.122: v2(184.06,6.97) 184.07,6.97 184.81,6.24 184.81,6.1 185.66,5.24 187.69,5.24 188.58,6.13 201.54,6.13 202.03,6.62 202.03,8.56 202.68,9.22 202.68,19.26 201.58,20.36 200.58,20.36 199.95,20.99 199.95,21.59 197.61,23.94 197.61,24.86 197.12,25.35 192.82,25.35 191.19,23.72 184.69,23.72 184.31,24.1 183.61,24.1 181.24,26.46 129.6,26.46 128.38,25.24 123.71,25.24 122.9,26.05 84.29,26.05 84.08,25.84 57.05,25.84 56.71,25.5 47.59,25.5 45.88,23.79 45.13,23.79 43.81,22.47 34.66,22.47 33.31,21.12 29.42,21.12 29.14,21.4 28.16,21.4 27.09,20.33 22.88,20.33 21.4,18.86 21.4,18.24 21.23,18.06 18.59,18.06 v2(18.28,18.38)
USH_SMBDAT: length 229
  TOP w0.102: U38.B53 20.56,18.08 20.59,18.05 20.99,18.05 v2(21.39,17.65) ; R191.2 184.1,8.88 v1(184.96,8.01) 185.22,7.76 185.22,7.28 v2(185.31,7.19) 185.31,6.97 185.76,6.52 JUSH1.6
  IN2 w0.122: v2(185.31,7.19) 185.09,6.98 185.09,6.17 185.76,5.49 187.59,5.49 188.48,6.38 201.43,6.38 201.78,6.73 201.78,8.67 202.43,9.32 202.43,19.16 201.48,20.11 200.48,20.11 199.71,20.88 199.71,21.49 197.36,23.83 197.36,24.76 197.02,25.1 192.92,25.1 191.3,23.47 184.58,23.47 184.21,23.85 183.5,23.85 181.14,26.21 129.7,26.21 128.48,24.99 123.6,24.99 122.8,25.8 84.4,25.8 84.19,25.59 57.15,25.59 56.81,25.25 47.69,25.25 45.98,23.54 45.23,23.54 43.91,22.22 34.77,22.22 33.42,20.87 29.32,20.87 29.04,21.15 28.26,21.15 27.19,20.09 22.98,20.09 21.65,18.76 21.65,18.14 21.39,17.87 v2(21.39,17.65)
V_SYS: length 42.2
  TOP w0.102: v2(17.03,11.98) 16.42,12.59 R381.2
  TOP w0.254: PU700.7 52.07,5.59 v2(52.3,5.36) 52.31,5.35 PC719.2
  IN3 w0.122: v2(52.3,5.36) 51,5.36 50.42,5.94 49.2,5.94 48.46,5.21 44.98,5.21 44.7,4.93 43.28,4.93 42.09,6.12 38.23,6.12 37.57,5.46 31.6,5.46 31.24,5.82 28.17,5.82 27.51,6.48 25.96,6.48 25.2,7.24 23.11,7.24 22.6,7.74 22.6,8.23 20.22,10.62 18.39,10.62 v2(17.03,11.98)
VCI_IN2#: length 9.4
  TOP w0.102: v2(17.13,9.28) 16.86,9.28 R347.2 ; U38.B63 20.43,13.08 20.51,13 21.07,13 21.16,13.09 21.49,13.09 21.73,12.85 21.73,12.19 v2(21.7,12.16)
  BOTTOM w0.102: v2(17.13,9.28) 17.2,9.35 18.62,9.35 19.49,10.22 19.49,10.67 20.56,11.73 21.28,11.73 v2(21.7,12.16)
VCP: length 153.8
  TOP w0.102: U38.A12 26.44,8.27 v2(26.51,8.2) ; v2(97.33,84.94) 97.38,84.94 v1(97.84,84.48)
  TOP w0.254: v2(43.79,5.36) 43.79,4.98 44.06,4.71 44.06,4.26 PR710.1 ; v2(97.33,84.94) 97.47,85.08 PR732.1
  IN1 w0.254: v2(42.71,10.43) 41.82,10.43 41.42,10.83 41.42,13.42 42.57,14.58 42.57,15.61 45.09,18.13 45.09,20.55 45.41,20.87 46.79,20.87 47.07,21.15 47.07,24.88 50.58,28.4 54.68,28.4 56.52,30.24 58.35,30.24 59.53,31.42 59.53,35.58 60.73,36.79 60.73,37.59 58.32,40 58.32,47.26 60.5,49.44 60.5,55.65 61.57,56.72 61.57,63.96 63.54,65.93 63.54,73.14 62.15,74.52 61.27,74.52 60.81,74.98 60.81,76.07 61.07,76.34 62.87,76.34 67.95,81.42 67.95,82.07 69.97,84.09 71.02,84.09 71.82,84.89 71.82,85.17 73.36,86.71 93.3,86.71 94.93,85.08 97.19,85.08 v2(97.33,84.94)
  IN2 w0.122: v2(42.71,10.43) 42.71,9.27 42.53,9.09 42.53,6.62 v2(43.79,5.36)
  IN3 w0.122: v2(42.71,10.43) 41.55,10.43 40.81,9.68 35.61,9.68 33.36,7.42 32.21,7.42 31.44,8.2 28.83,8.2 28.64,8.39 26.7,8.39 v2(26.51,8.2)
VCT_LAN_R1: length 3.7
  TOP w0.102: U21.6 256.18,77.37 256.47,77.66 257.23,77.66 v1(257.31,77.57) 257.61,77.28 257.61,76.92 R175.2
VFB: length 1.7
  TOP w0.203: PU500.24 92.87,74.84 PR531.1
VGA_ID: length 12.8
  TOP w0.102: v2(9.44,34.51) 9.44,34.72 9.68,34.96 R317.1 R320.2 10.06,33.39 9.92,33.25 v1(9.92,33.1) ; v2(17.01,35.47) 16.55,35.02 U37.B59
  IN2 w0.122: v2(17.01,35.47) 16.62,35.09 15.67,35.09 15.28,35.48 10.41,35.48 v2(9.44,34.51)
VIDALERT_N: length 26.3
  TOP w0.102: PU500.32 88.45,75.91 88.24,76.12 87.66,76.12 87.57,76.21 87.57,76.31 87.43,76.45 v2(87.43,77.1) 87.43,77.51 PR528.2
  IN4 w0.084: v2(107.91,75.87) 106.41,77.37 94.49,77.37 94.29,77.57 87.9,77.57 v2(87.43,77.1)
  BOTTOM w0.102: v2(107.91,75.87) 108.05,75.87 108.31,76.13 RC248.2 107.44,76.49 RC244.2
VIDSCLK: length 34.5
  TOP w0.102: PU500.31 88.85,75.99 88.44,76.4 88.44,76.77 v2(88.09,77.13) 88.09,77.74 PR527.2
  IN4 w0.084: v2(108.51,75.54) 108.38,75.41 107.81,75.41 106.19,77.03 94.29,77.03 94.19,77.13 v2(88.09,77.13)
  BOTTOM w0.076: UC1.N63 112.03,75.63 111.51,76.16 110.73,76.16 110.49,75.92 110.49,75.68 110.54,75.63 110.88,75.63 111.01,75.5 111.01,75.3 110.95,75.23 110.24,75.23 110.06,75.41 109.91,75.41
  BOTTOM w0.102: 109.91,75.41 109.2,75.41 108.79,74.99 108.79,74.41 108.72,74.34 108.49,74.34 108.38,74.44 108.38,74.82 108.29,74.9 107.95,74.9 107.86,74.82 107.86,74.66 107.79,74.59 107.34,74.59 107.25,74.68 107.25,75.01 107.55,75.31 v1(107.71,75.31) 108.37,75.31 108.51,75.45 v2(108.51,75.54)
VIDSOUT: length 38
  TOP w0.102: PR529.2 86.3,77.39 86.36,77.33 86.72,77.33 86.8,77.24 86.8,77.09 86.63,76.92 86.53,76.92 86.46,76.84 86.46,76.62 86.76,76.32 86.76,76.16 v2(86.84,76.07) 86.84,75.04 87.04,74.84 PU500.1
  IN4 w0.084: v2(109.91,76.94) 109.14,77.71 94.66,77.71 94.41,77.95 91.11,77.95 91.02,78.04 91.02,78.59 90.92,78.69 90.78,78.69 90.69,78.59 90.69,78.04 90.6,77.95 90.43,77.95 90.35,78.04 90.35,78.76 90.27,78.84 90.1,78.84 90.02,78.76 90.02,78.04 89.93,77.95 89.76,77.95 89.68,78.04 89.68,78.76 89.6,78.84 89.43,78.84 89.35,78.76 89.35,78.04 89.26,77.95 87.62,77.95 86.47,76.81 86.47,76.44 v2(86.84,76.07)
  BOTTOM w0.076: UC1.L63 112.06,76.38 111.74,76.71 111.13,76.71 110.88,76.96 109.93,76.96 v2(109.91,76.94)
  BOTTOM w0.102: v2(109.91,76.94) 109.66,76.94 RC249.2
VMM2310_AUXN: length 3.7
  TOP w0.089: U6.M5 194.06,77.53 194.17,77.42 194.17,77.3 194.06,77.19 194.06,76.94 193.84,76.73 193.84,76.27 193.59,76.02 v3(193.59,75.62) 193.59,74.75 R85.1
VMM2310_AUXP: length 5.1
  TOP w0.089: T40.1 193.28,74.12 193.28,76.16 193.52,76.4 193.52,76.86 193.74,77.08 193.74,77.98 U6.L5
VMM2310_HDP: length 6.2
  TOP w0.089: U6.M3 192.6,77.65 192.27,77.32 192.27,77.05 191.51,76.3 191.51,74.71 191.01,74.21 R74.2 v1(191.01,72.25)
VMM2310_SCL: length 38.9
  TOP w0.089: R77.1 213.62,80.27 213.51,80.27 212.93,79.69 212.93,78.29 211.73,77.1 211.73,75.74 209.83,73.84 209.83,72.66 209.39,72.21 209.39,71.46 208.11,70.18 205.89,70.18 204.83,69.12 v3(203.25,69.12) 194.17,69.12 193.43,69.86 192.29,69.86 191.63,70.52 191.63,74.05 191.98,74.4 191.98,76.07 192.61,76.69 192.61,77.03 193.09,77.51 193.09,77.99 U6.L4
VMM2310_SDA: length 37.5
  TOP w0.089: U6.M4 193.41,77.65 193.41,77.38 192.93,76.9 192.93,76.56 192.3,75.94 192.3,74.27 191.95,73.91 191.95,70.65 192.42,70.18 193.56,70.18 194.3,69.44 v3(196.39,69.44) 204.69,69.44 205.75,70.5 207.98,70.5 209.07,71.59 209.07,72.34 209.51,72.79 209.51,73.97 211.42,75.87 211.42,77.23 212.61,78.43 212.61,79.82 213.38,80.59 213.62,80.59 R81.1
VMM2310_TX2N0: length 16.8
  TOP w0.089: R84.1 207.42,78.22 207.42,76.39 206.14,75.12 206.14,74.84 204.47,73.16 v3(202.43,73.16) 200.32,73.16 198.39,75.09 198.39,76.19 197.87,76.71
  TOP w0.102: U6.M9 196.66,77.55 197.5,76.71 197.87,76.71
VMM2310_TX2N1: length 20.3
  TOP w0.089: R76.1 209.07,78.1 209.07,77.02 207.59,75.54 207.59,74.16 205.99,72.57 v1(204.77,72.57) 200,72.57 197.75,74.82 197.75,75.51 197.01,76.25 196.42,76.25 196.01,76.66 U6.M8
VMM2310_TX2N2: length 27.2
  TOP w0.089: R75.1 210.52,81.58 210.52,78.64 209.78,77.91 209.78,76.9 208.15,75.27 208.15,73.95 206.11,71.91 v1(199.36,71.91) 199.01,71.91 197.61,73.3 196.01,73.3 195.36,73.96 U6.M7
VMM2310_TX2N3: length 31.3
  TOP w0.089: U6.M6 194.71,75.91 194.88,75.73 194.88,72.61 196.02,71.48 v1(196.65,71.48) 197.19,71.48 198.44,70.22 203.02,70.22 204.04,71.25 206.83,71.25 208.72,73.14 208.72,74.32 210.62,76.22 210.62,77.61 211.3,78.3 211.3,79.9 212.1,80.7 R73.1
VMM2310_TX2P0: length 16
  TOP w0.089: 198.67,76.86 198.68,76.85 198.68,76.84 198.76,76.76 199.02,76.5 199.02,75.31 200.57,73.76 204.22,73.76 205.55,75.08 205.55,75.37 206.79,76.62 v3(206.79,77.28) 206.79,78.23 R88.1
  TOP w0.102: U6.L9 196.75,78.21 196.98,78.21 197.19,77.99 197.42,77.99 197.64,77.77 197.64,77.48 197.77,77.35 198.17,77.35 198.67,76.86
VMM_DPB_CTRLCLK: length 19.2
  TOP w0.089: R70.1 203.21,76.89 203.02,76.89 201.71,78.2 201.53,78.2 v2(201.36,78.37) 201.25,78.26 200.55,78.26 200.2,78.62 199.59,78.62 U6.K13
  IN1 w0.084: v2(207.57,84.49) 207.25,84.49 207.12,84.62 207.12,84.87 207.25,85 207.89,85 208.01,84.87 208.01,83.53 202.59,78.1 201.89,78.1 201.8,78.19 201.54,78.19 v2(201.36,78.37)
  BOTTOM w0.089: U11.12 208.2,84.17 208.08,84.05 207.89,84.05 207.57,84.37 v2(207.57,84.49)
VMM_DPB_CTRLDAT: length 19
  TOP w0.089: R72.1 203.21,76.57 202.88,76.57 v3(202.51,76.95) 201.61,77.85 201.43,77.85 v2(201.36,77.78) 201.26,77.78 200.99,78.05 200.11,78.05 200.01,77.95 199.76,77.95 199.67,78.04 199.67,78.21 199.76,78.3 U6.L14
  IN1 w0.084: v2(201.36,77.78) 201.44,77.86 201.59,77.86 201.73,77.72 202.74,77.72 208.39,83.37 208.39,85.03 208.04,85.38 207.63,85.38 v2(207.57,85.45)
  BOTTOM w0.089: U11.9 208.25,86.12 v2(207.57,85.45)
VMM_DPC_CTRLCLK: length 30.8
  TOP w0.089: R49.1 201.54,87.92 201.22,87.6 v2(200.77,87.6) 200.64,87.6 200.29,87.25 200.29,86.8 199.72,86.23 199.72,85.62 199.23,85.13 199.06,85.13 198.92,84.99 198.92,84.47 U6.B12
  IN2 w0.102: v2(200.77,87.6) 200.51,87.86 198.66,87.86 198.41,88.11 197.43,88.11 196.8,88.74 192,88.74 188.64,85.38 185.99,85.38 185.73,85.11 185.73,83.31 185.12,82.7 185.12,82.12 184.7,81.7 183.84,81.7 183.63,81.91 183.63,82.21 v2(183.44,82.4)
  BOTTOM w0.089: U13.12 182.85,81.87 183.38,82.4 v2(183.44,82.4)
VMM_DPC_CTRLDAT: length 30.5
  TOP w0.089: U6.A12 198.54,84.87 198.54,85.05 198.93,85.45 199.09,85.45 199.4,85.75 199.4,86.36 199.97,86.93 199.97,87.38 v2(200.77,88.18) 201.03,87.92 201.09,87.92 201.22,88.05 201.22,88.54 R46.1
  IN2 w0.102: v2(200.77,88.18) 200.7,88.11 198.77,88.11 198.51,88.37 197.54,88.37 196.91,89 191.89,89 188.53,85.64 185.89,85.64 185.47,85.22 185.47,83.41 184.86,82.8 184.86,82.22 184.59,81.95 183.95,81.95 183.88,82.02 183.88,82.27 184.07,82.46 184.38,82.46 184.42,82.42 v2(184.42,82.41)
  BOTTOM w0.089: v2(184.42,82.41) 184.45,82.38 184.69,82.38 184.8,82.27 U13.9
VMM_GPIO6: length 7.4
  TOP w0.102: R52.1 188.02,87.73 v1(189.85,87.73) 190.42,87.73 190.61,87.54 190.61,83.98 191.1,83.5 U6.C1
VMM_GPIO7: length 6.6
  TOP w0.089: 199.05,77.39 199.1,77.39 199.33,77.16
  TOP w0.102: U6.M12 198.79,77.65 199.05,77.39 ; R53.1 202.92,75.48 202.62,75.78 200.33,75.78 v1(200.01,76.1) 200.01,76.72 199.57,77.16 199.33,77.16
VMM_GPIO8: length 5.2
  TOP w0.089: 200.09,77.02 200.43,76.68
  TOP w0.102: 200.43,76.68 200.86,76.25 v1(201.42,76.25) 201.53,76.14 202.69,76.14 R54.1 ; U6.M13 199.46,77.65 200.09,77.02
VMM_GPIO9: length 9
  TOP w0.089: U6.L3 192.41,77.95 191.12,77.95 190.49,77.32 ; R63.1 188.58,73.88 188.58,74.59 189.03,75.03 189.03,75.78
  TOP w0.102: R63.1 v1(187.83,73.3) ; 190.49,77.32 189.32,76.15 189.32,76.07 189.03,75.78
VMM_MESCL: length 5.7
  TOP w0.102: U6.B5 194.06,84.16 193.73,84.49 193.73,84.89 193.35,85.27 193.35,86 192.7,86.65 v1(192.7,87.17) 192.7,87.4 193.97,88.67 R40.1
VMM_MESDA: length 7.1
  TOP w0.089: U6.B6 194.71,84.2 195,84.49 195,84.94 194.17,85.76 194.17,85.83
  TOP w0.102: 194.17,85.83 194.17,86.57 194.04,86.7 194.04,87.11 195.05,88.11 195.39,88.11 R42.1 196.71,88.67 v1(196.94,88.9)
VMM_SPI_CLK: length 7.5
  TOP w0.102: v4(192.43,83.82) 192.76,84.15 U6.B3
  BOTTOM w0.102: 189.54,81.27 189.54,80.37 189.71,80.19 191.21,80.19 191.34,80.31 191.34,83.12 192.04,83.82 v4(192.43,83.82)
VMM_SPI_CS#: length 12.2
  TOP w0.102: v2(192.71,85.95) 193.14,85.53 193.14,85.07 U6.A4
  BOTTOM w0.102: R64.2 193.6,86.61 192.94,85.95 v2(192.71,85.95) 192.71,85.88 192.27,85.43 v1(192.27,84.98) 192.27,84.68 191.44,83.86 187.21,83.86 187,84.07 U7.1
VMM_SPI_DIN: length 9.3
  TOP w0.102: U6.B4 193.41,84.15 v4(193.73,83.82)
  IN3 w0.122: v2(189.13,85.11) 189.4,85.38 191.22,85.38 192.11,84.49 193.06,84.49 v4(193.73,83.82)
  BOTTOM w0.102: v1(187.81,87.93) 188.27,87.48 U7.2 188.27,85.75 188.9,85.11 v2(189.13,85.11)
VMM_SPI_DO: length 6.4
  TOP w0.102: U6.A3 v2(192.76,85.32)
  BOTTOM w0.089: v2(192.76,85.32) 193.23,85.32 v1(193.61,85.7)
  BOTTOM w0.102: U7.5 190.81,82.91 192.76,84.86 v2(192.76,85.32)
VMM_SPI_HOLD: length 6.6
  BOTTOM w0.102: R65.2 192.79,78.83 v1(192.28,79.34) 191.71,79.91 188.72,79.91 188.27,80.37 U7.7
VMM_SPI_WP#: length 3.3
  TOP w0.102: v2(191,84.3) 191.15,84.15 U6.B1
  BOTTOM w0.102: v2(191,84.3) 190.87,84.3 189.54,85.64 189.54,86.44
VOL_DOWN: length 126.8
  TOP w0.102: v2(65.56,86.03) 64.5,84.97 64.5,82.49 64.35,82.34 JMEDIA.4 ; v5(9.42,18.97) 9.42,19.48 10.01,20.07 v2(10.04,20.07) 10.81,19.3 R349.2 11.54,19.3 12,19.76 12.69,19.76 13.03,19.42 13.64,19.42 14.48,18.58 R360.2
  IN2 w0.122: v2(65.56,86.03) 65.22,86.03 64.54,85.35 58.73,85.35 53.9,80.52 53.9,78.5 53.11,77.7 53.11,69.97 52.73,69.59 52.73,67.23 51.89,66.4 51.89,62.23 53.32,60.8 53.79,60.34 53.79,56.36 48.53,51.11 47.05,51.11 46.56,51.6 38.55,51.6 33.56,46.61 31.95,46.61 27.41,42.08 26.47,42.08 26.47,42.07 25.2,42.07 24.38,42.89 23.01,42.89 21.83,41.71 15.2,41.71 14.96,41.95 14.16,41.95 13.64,41.43 11.34,41.43 9.42,39.51 8.99,39.51 8.49,39.01 8.23,39.01 6.77,37.55 6.77,33.12 7.51,32.38 7.51,31.49 9.71,29.29 9.71,22.46 10.21,21.96 10.21,20.25 v2(10.04,20.07)
VOL_DOWN_R: length 13.8
  TOP w0.102: R349.1 11,20.69 C456.2 11.79,20.69 11.79,20.4 v1(12.08,20.1) 12.19,19.99 12.8,19.99 13.06,19.72 v2(14.21,19.72) ; U38.B57 20.73,16.08 v2(20.81,15.99)
  BOTTOM w0.102: v2(14.21,19.72) 15.04,18.9 18.44,18.9 19.94,17.4 19.94,16.87 v2(20.81,15.99)
VOL_MUTE: length 147.2
  TOP w0.102: JMEDIA.3 64.85,82.38 64.73,82.51 64.73,84.58 66.38,86.23 v2(66.57,86.23) ; v1(17.77,4.74) 17.42,4.39 v2(17.42,4.13) 17.42,3.96 16.92,3.45 R358.2 R352.2
  IN2 w0.122: v2(66.57,86.23) 66.04,86.23 65.58,86.69 65.18,86.69 64.08,85.6 58.63,85.6 52.86,79.82 52.86,70.08 52.48,69.7 52.48,67.33 51.65,66.5 51.65,62.13 53.54,60.23 53.54,56.5 48.4,51.36 47.15,51.36 46.66,51.85 38.44,51.85 33.45,46.86 31.84,46.86 27.31,42.33 25.3,42.33 24.48,43.14 22.9,43.14 21.72,41.96 15.34,41.96 14.84,42.46 10.06,42.46 9.55,41.95 9.55,39.99 9.35,39.79 8.89,39.79 8.36,39.26 8.12,39.26 6.52,37.66 6.52,33.02 7.26,32.28 7.26,31.39 9.27,29.38 9.27,22.55 9.89,21.93 9.89,20.55 9.62,20.28 9.62,19.85 10.13,19.34 10.37,19.34 11.69,18.02 11.69,9.33 12.31,8.7 12.31,7.11 13.15,6.26 16.11,6.26 17.42,4.96 v2(17.42,4.13)
VOL_MUTE_R: length 13.9
  TOP w0.102: v2(21.53,11.3) 21.13,10.9 21.13,10.38 21.19,10.32 U38.B2 ; v2(14.95,5.07) 14.95,5.6 C457.2 15.38,5.34 15.38,5.05 15.8,4.63 R352.1
  BOTTOM w0.102: v2(14.95,5.07) 15.13,5.25 15.13,6.1 16.37,7.34 17.79,7.34 19.48,9.03 20.07,9.03 21.13,10.1 21.13,10.9 v2(21.53,11.3)
VOL_UP: length 143.8
  TOP w0.102: v2(30.84,6.39) 31.19,6.03 R362.2 R338.2 ; v1(67.63,86.69) v2(66.19,86.69) 65.46,86.69 64.27,85.5 64.27,82.58 63.85,82.16 JMEDIA.5
  IN1 w0.084: v2(15.67,29.51) 15.67,29.34 15.33,28.99 15.33,26.45 14.15,25.27 14.15,22.8 14.43,22.52 14.43,20.46 14.81,20.07 v2(14.81,19.72)
  IN2 w0.122: v2(14.81,19.72) 14.81,19.49 13.93,18.6 13.93,14.56 14.86,13.63 14.86,12.62 16.36,11.12 16.36,8.99 17.02,8.33 18.18,8.33 19.58,6.94 22.12,6.94 22.5,6.55 23.34,6.55 23.53,6.36 30.8,6.36 v2(30.84,6.39)
  IN4 w0.084: v2(15.67,29.51) 15.49,29.7 15.49,38.31 16.46,39.27 24.7,39.27 25.68,40.26 27.4,40.26 29.83,42.69 31.58,42.69 31.98,43.08 34.27,43.08 34.79,43.6 38.46,43.6 40.63,45.76 47.1,45.76 50.89,49.55 52.53,49.55 54.49,51.51 54.49,55.65 55.25,56.42 55.25,64.76 53.86,66.15 53.86,69.02 53.62,69.26 53.62,70.64 55.88,72.9 55.88,75.63 56.17,75.92 56.17,77.43 59.37,80.63 59.37,81.6 64.46,86.69 v2(66.19,86.69)
VOL_UP_R: length 14.3
  TOP w0.102: R338.1 32.5,6.92 C455.2 v2(33.15,7.86) ; U38.B8 24.19,10.25 23.96,10.48 23.96,11.12 v2(23.84,11.24)
  IN3 w0.122: v2(23.84,11.24) 24,11.08 24,10.03 25.33,8.71 28.77,8.71 29.02,8.46 32.55,8.46 v2(33.15,7.86)
VR_EN: length 11.5
  TOP w0.102: v2(107.71,84.56) v1(107.71,85.23) 107.71,86.12 107.29,86.54 RC246.2
  IN1 w0.084: v2(107.71,84.56) 109.5,84.56 v2(114.3,79.75)
  BOTTOM w0.076: UC1.F60 114.6,79.46 v2(114.3,79.75)
VR_HOT#: length 2.4
  TOP w0.203: PR534.1 88.89,77.66 v1(88.89,76.73) 88.89,76.47 89.25,76.1 PU500.30
VR_READY: length 7.5
  BOTTOM w0.076: 113.28,85.57 113.32,85.53 113.32,84.74 115.04,83.02 115.04,82.44 115.08,82.41 115.08,81.81 UC1.C59
  BOTTOM w0.102: RC247.2 113.28,87.64 v1(113.28,87.1) 113.28,85.57
VREF: length 25.4
  TOP w0.203: PU500.27 90.45,76.51 v2(90.63,76.68) 90.45,76.86 90.45,77.53 PR521.2
  TOP w0.254: PR504.2 PR503.2 PR502.2 88.77,68.17 v2(88.8,68.15) 89.28,67.67 v1(90.14,67.67) 91.05,67.67 91.57,68.19 PR500.2
  IN3 w0.508: v2(88.8,68.15) 88.8,68.85 89.31,69.36 90.28,69.36 90.86,69.93 90.86,71.28 91.62,72.05 91.62,76.24 91.17,76.68 v2(90.63,76.68)
  BOTTOM w0.254: v2(88.8,68.15) 88.06,68.15 86.22,69.99 85.17,69.99 PH500.1
  BOTTOM w0.508: PC507.2 91.31,76 v2(90.63,76.68)
VSET_5075: length 4.5
  TOP w0.102: C367.1 31.51,9.69 31.06,10.13 30.84,10.13 30.59,10.38 30.59,10.73 30.5,10.83 U38.A17 ; C367.1 R394.1 ; C367.1 31.98,10.25 v1(31.61,10.62)
VSYNC_DOCK: length 120.9
  TOP w0.102: R88.2 206.79,79.4 206.79,80.34 v2(206.5,80.63)
  IN2 w0.122: v2(216.93,94.02) 216.93,96.02 216.17,96.78 209.63,96.78 208.79,95.93 204.91,95.93 203.41,97.43 187.63,97.43 185.55,95.35 v2(185.55,94.55)
  IN4 w0.084: v2(216.93,94.02) 215.66,92.75 214.78,92.75 208.87,86.83 208.87,83.46 207.86,82.45 207.28,82.45 206.5,81.68 v2(206.5,80.63)
  BOTTOM w0.102: JDOCK1.67 130.95,99.76 130.81,99.62 130.81,98.63 130.45,98.27 130.45,95.79 131.08,95.17 134.4,95.17 136.23,97 144.36,97 145.03,96.33 146.24,96.33 147.08,95.49 152.26,95.49 155.07,98.3 165.08,98.3 168.91,94.47 v1(171.48,94.47) 183.9,94.47 184.04,94.61 185.48,94.61 v2(185.55,94.55)
WIGIG60GHZ_DIS#: length 238.7
  TOP w0.102: R289.2 16.43,27.17 v2(16.43,27.88) U37.A1 ; v2(206.68,21.13) 206.68,21.64 v1(207.72,22.68) 208.74,23.7 R224.1 210.65,23.7 D13.1
  IN3 w0.122: v2(206.68,21.13) 206.68,18.97 203.05,15.34 200.23,15.34 199.77,14.88 195.05,14.88 194.2,14.04 192.19,14.04 188.46,17.77 178.57,17.77 178.19,17.39 139.85,17.39 139.65,17.19 135.29,17.19 134.61,16.51 133.93,16.51 133.22,17.22 132.32,17.22 132.15,17.4 131.02,17.4 v2(130.42,18.01)
  BOTTOM w0.102: v2(130.42,18.01) 130.18,18.01 129.5,18.69 129.5,19.21 130.67,20.39 130.67,23.13 129.63,24.17 129.63,25.03 129.15,25.51 129.15,28.87 128.32,29.7 128.32,29.88 127.71,30.49 127.71,32.39 128.05,32.73 128.05,36.74 126.41,38.39 120.62,38.39 120.37,38.14 61.99,38.14 61.43,38.7 59.17,38.7 58.85,39.01 55.16,39.01 54.2,39.97 52.7,39.97 52.26,40.41 48.65,40.41 46.26,38.02 43.65,38.02 41.84,36.21 35.04,36.21 34.49,35.66 32.58,35.66 31.76,34.85 30.86,34.85 29.45,33.44 29.45,27.49 29.98,26.96 29.98,25.85 29.33,25.21 29.08,25.21 28.42,24.55 25.37,24.55 23.86,26.06 20.52,26.06 20.46,26.01 18.18,26.01 17.41,26.77 17.41,26.91 16.45,27.88 v2(16.43,27.88)
WIGIG60GHZ_DIS#_R: length 4.6
  TOP w0.102: v1(208.85,24.04) 209.42,24.61 R224.2 209.92,24.7 D13.2 211.35,24.4 JMINI1.32
WIMAX_LED#: length 21.6
  TOP w0.102: v1(207.49,13.83) v2(208.14,13.83) 208.34,13.63 R222.1 ; v2(207.05,23.78) 208.08,23.78 208.96,24.66 208.96,25.1 209.79,25.93 Q22.4 211.01,25.93 R228.1 211.87,26.8 211.87,28.01 212.26,28.4 JMINI1.42
  IN1 w0.084: v2(208.14,13.83) 208.69,14.38 208.69,22.14 v2(207.05,23.78)
WIRELESS_LED#: length 346.5
  TOP w0.102: Q30.3 207.14,41.13 206.83,41.44 205.85,41.44 ; 205.85,41.44 205.84,41.45 Q30.6 ; 205.85,41.44 204.78,41.44 v2(204.54,41.2) ; U37.A47 16.93,40.31 16.82,40.42 16.65,40.42 16.52,40.55 15.67,40.55 15.61,40.61 v2(15.34,40.61) ; 198.04,94.82 197.97,94.74 R432.2 ; 198.04,94.82 v1(198.04,94.82) ; 198.04,94.82 198.93,95.7 200.56,95.7 200.79,95.47 200.79,94.78 201.07,94.51 201.07,93.88 v2(201.08,93.87) ; v2(207.85,24.74) 207.85,25.34 207.63,25.55 207.63,25.78 207.78,25.93 Q22.3 ; Q22.6 v2(209.27,27.23)
  IN1 w0.084: v2(204.54,41.2) 204.01,40.67 204.01,32.4 207.48,28.94 207.48,27.68 207.92,27.23 v2(209.27,27.23) ; v2(201.08,93.87) 201.08,93.89 203.84,91.13 203.84,89.05 205.88,87.01 205.88,84.56 v2(205.41,84.09) ; v2(15.34,40.61) 15.18,40.77 15.18,40.94 15.02,41.11 14.4,41.11 13.72,40.42 12.63,40.42 11.11,38.9 11.11,35.19 10.66,34.74 10.66,31.93 10.05,31.32 10.05,23.35 10.92,22.48 11.69,22.48 12.08,22.09 12.08,20.81 12.48,20.4 v2(12.48,20.41)
  IN2 w0.122: v2(204.54,41.2) 204.97,41.62 204.97,42.95 204.57,43.34 204.57,51.27 204.68,51.38 204.68,61.85 203.82,62.71 203.82,64.82 204.02,65.02 204.02,68.87 203.56,69.33 203.56,72.14 206.17,74.75 v2(206.17,76.61)
  IN3 w0.122: v2(207.85,24.74) 207.85,25.81 v2(209.27,27.23) ; v2(204.54,41.2) 202.97,41.2 200.24,38.47 198.63,38.47 198.23,38.07 198.23,37.59 195.95,35.31 195.17,35.31 194.11,34.24 189.79,34.24 188.15,32.6 187.5,32.6 186.46,33.63 186.14,33.63 185.98,33.8 185.97,33.8 185.02,34.75 139.43,34.75 132.85,28.17 132.85,27.65 132.13,26.92 131.67,26.92 129.8,25.05 128.37,25.05 v2(127.37,24.05)
  BOTTOM w0.102: v2(12.48,20.41) 12.48,20.4 12.57,20.31 14.9,20.31 15.38,19.84 19.46,19.84 19.71,19.58 24.68,19.58 25.57,20.47 25.57,21.51 25.93,21.87 29.69,21.87 31.21,23.39 32.61,23.39 33.22,24.01 33.22,25.57 33.22,25.57 33.22,26.07 33.33,26.17 33.62,26.46 33.62,29.56 36.97,32.92 42.45,32.92 44.48,34.95 44.84,34.95 46,36.11 46.52,36.11 49.29,38.87 51.64,38.87 52.07,38.44 53.4,38.44 53.67,38.17 54.48,37.36 57.82,37.36 58.86,36.33 60.18,36.33 60.31,36.2 119.92,36.2 121.29,34.83 121.29,31.85 123.09,30.05 124.23,30.05 125.05,30.86 125.88,30.86 126.04,30.71 126.04,29.62 125.97,29.55 125.97,28.35 126.28,28.04 126.28,25.15 v2(127.37,24.05) ; v2(205.41,84.09) 206.02,83.48 206.02,82.07 204.93,80.97 204.93,79.13 205.08,78.98 205.08,77.75 206.17,76.66 v2(206.17,76.61) ; Q25.1 200.22,92.86 200.33,92.75 200.65,92.75 201.08,93.18 v2(201.08,93.87)
WIRELESS_ON#/OFF: length 53.9
  TOP w0.102: v2(21.32,31.41) 21.27,31.41 21.21,31.34 21.78,30.77 21.78,30.64 22.18,30.24 U37.B13 ; v2(26.14,28.64) 26.14,27.95 26.99,27.1 27.97,27.1 28.21,27.34 R293.2 ; JSF1.3 8.89,14.46 v1(9.2,14.77) 9.51,15.09 v2(9.64,15.09)
  IN1 w0.084: v2(21.32,31.41) 21.21,31.29 21.21,31.24 20.98,31.01 20.98,29.51 20.18,28.7 20.18,27.06 21.02,26.22 21.02,24.7 20.68,24.36 20.68,22.67 19.76,21.75 19.76,14.18 19.91,14.03 19.91,10.04 v2(19.99,9.96)
  IN4 w0.084: v2(19.99,9.96) 18.54,9.96 17.42,8.83 16.57,8.83 15.42,7.68 14.59,7.68 13.31,8.96 12.47,8.96 10.91,10.53 10.91,14.21 10.03,15.09 v2(9.64,15.09)
  BOTTOM w0.102: v2(21.32,31.41) 21.79,30.94 21.79,30.53 23.05,29.28 23.65,29.28 24.01,28.92 25.86,28.92 v2(26.14,28.64)
WLAN_LAN_DISB#: length 344.1
  TOP w0.102: U37.A64 14.46,30.77 14.25,30.56 v2(14.25,29.59) ; v2(239.83,79.7) 239.26,80.27 239.26,84.7 239.65,85.09 240.46,85.09 241.26,84.29 v1(241.82,84.29) U24.4
  IN3 w0.122: v2(239.83,79.7) 239.31,79.7 238.62,80.4 224.82,80.4 223.59,79.16 214.69,79.16 209.48,73.95 209.48,73.24 208.56,72.32 208,72.32 207.15,71.47 204.83,71.47 203.99,70.64 203.99,70.04 204.82,69.21 204.82,68.5 205.21,68.11 205.21,64.6 204.37,63.76 204.37,56.69 205.12,55.94 205.12,51.9 206.05,50.97 206.05,46.9 206.66,46.29 206.66,41.67 205.07,40.09 205.07,39.21 204.54,38.68 202.93,38.68 202.47,38.22 202.47,36.61 201.52,35.65 201.52,30.58 205.54,26.57 205.54,22.31 204.02,20.79 204.02,17.01 202.85,15.84 200.44,15.84 199.52,16.76 198.74,16.76 197.35,15.38 194.84,15.38 194,14.54 192.4,14.54 188.67,18.27 178.36,18.27 177.98,17.89 139.65,17.89 139.44,17.68 133.56,17.68 133.36,17.89 132.78,17.89 132.23,18.44 129.91,18.44 v2(129.54,18.07)
  BOTTOM w0.102: v2(14.25,29.59) 13.87,29.59 13.21,28.93 13.21,26.82 13.7,26.32 17.16,26.32 17.94,25.55 20.84,25.55 21.34,25.05 21.74,25.05 22.15,24.64 23.48,24.64 23.8,24.32 24.77,24.32 25.07,24.02 25.07,23.62 25.2,23.49 28.71,23.49 28.93,23.71 28.93,24.09 30.53,25.69 30.53,27.17 29.91,27.79 29.91,32.3 32.03,34.42 40.03,34.42 41.36,35.75 42.36,35.75 44.17,37.55 46.46,37.55 48.85,39.94 52.08,39.94 52.51,39.51 53.9,39.51 54.93,38.48 58.29,38.48 58.56,38.21 60.4,38.21 60.97,37.64 120.84,37.64 120.97,37.77 126.38,37.77 127.6,36.55 127.6,32.92 127.25,32.58 127.25,30.3 127.86,29.69 127.86,29.33 128.3,28.9 128.3,27.71 128,27.42 128,25.93 129.15,24.79 129.15,23.59 129.26,23.47 129.26,20.31 128.94,19.99 128.94,18.67 v2(129.54,18.07)
WLAN_LED: length 5.2
  TOP w0.102: R435.2 202.82,98.7 v1(202.82,99.96) 203.02,100.16 204.11,100.16 LED5.2
WLAN_LED#: length 7.8
  TOP w0.102: v1(207.09,28.47) 207.14,28.42 R227.1 207.47,27.23 Q22.1 208.68,27.23 209.13,27.69 210.95,27.69 212.46,29.2 JMINI1.44
WLAN_RADIO_DIS#: length 262.5
  TOP w0.102: U37.A48 16.43,40.17 16.28,40.32 15.83,40.32 15.61,40.11 14.91,40.11 14.61,40.4 14.61,40.49 14.77,40.64 v2(14.75,40.64) ; v2(207.24,17.3) 207.68,16.85 208.78,16.85 v1(208.86,16.94) 209.26,17.33 R215.1 210.39,18.12 D12.1
  IN1 w0.084: v2(14.75,40.64) 14.24,40.64 13.81,40.21 12.72,40.21 11.32,38.81 11.32,35.1 10.87,34.65 10.87,31.84 10.26,31.23 10.26,23.44 11.01,22.69 11.89,22.69 12.56,22.02 12.56,21.08 v2(12.48,21.01)
  IN3 w0.122: v2(207.24,17.3) 206.82,16.88 204.94,16.88 202.69,14.63 195.15,14.63 194.31,13.79 192.09,13.79 188.36,17.52 178.67,17.52 178.27,17.12 139.94,17.12 139.75,16.94 135.39,16.94 134.72,16.26 133.83,16.26 133.11,16.97 132.22,16.97 132.04,17.15 130.89,17.15 130.62,17.42 127.38,17.42 v2(127.11,17.69)
  BOTTOM w0.102: v2(127.11,17.69) 126.8,18.01 126.8,19.74 127.05,19.99 127.05,22.17 128.16,23.28 128.16,24.38 127.01,25.52 127.01,27.86 127.27,28.12 127.27,28.52 126.87,28.92 126.87,29.28 126.26,29.89 126.26,30.8 125.88,31.19 125.88,36.22 125.55,36.56 121.6,36.56 121.47,36.42 60.4,36.42 60.27,36.56 58.95,36.56 57.92,37.59 54.61,37.59 53.83,38.37 53.53,38.67 52.16,38.67 51.73,39.1 49.2,39.1 46.43,36.33 45.9,36.33 44.75,35.18 44.39,35.18 42.41,33.2 36.93,33.2 33.39,29.66 33.39,26.56 33.1,26.27 32.99,26.16 32.99,25.67 32.99,24.1 32.7,23.81 31.31,23.81 29.59,22.1 25.84,22.1 25.35,21.61 25.35,20.57 24.59,19.81 19.81,19.81 19.55,20.07 15.48,20.07 14.97,20.57 12.92,20.57 v2(12.48,21.01)
WLAN_RADIO_DIS#_R: length 5.1
  TOP w0.102: JMINI1.20 210.75,19.6 D12.2 209.6,19.38 R215.2 208.41,19.04 v1(208.27,18.9)
WWAN_RADIO_DIS#: length 296.2
  TOP w0.102: U37.A53 14.4,36.27 14.17,36.04 13.64,36.04 v2(13.41,36.27) 13.22,36.46 13.22,36.48 12.74,36.96 RP11.6
  IN3 w0.122: v2(131.74,16.73) 132.97,16.73 133.68,16.01 134.85,16.01 135.52,16.69 139.85,16.69 140.04,16.88 178.46,16.88 179.76,15.58 179.76,9.59 183.27,6.08 195.59,6.08 197.38,4.28 201.85,4.28 202.04,4.1 208.25,4.1 209.1,4.95 209.1,22.08 209.91,22.88 209.91,25.68 210.48,26.25 210.48,28.45 209.86,29.07 208.92,29.07 205.03,32.97 205.03,36.1 207.9,38.98 207.9,46.88 208.15,47.12 208.15,49.94 207.55,50.54 207.55,51 207.9,51.35 JMINI2.20
  BOTTOM w0.102: v2(13.41,36.27) 13.66,36.02 14.73,36.02 15.29,36.58 16.68,36.58 16.73,36.52 17.57,36.52 18.17,37.12 18.72,37.12 19.8,36.04 22.67,36.04 23.02,36.39 23.35,36.39 23.77,36.8 25.34,36.8 26.25,37.71 26.44,37.71 26.85,38.12 26.85,38.3 27.61,39.06 29.42,39.06 30.06,39.71 31.57,39.71 35.66,43.8 35.66,46.56 38.07,48.97 v1(38.7,48.97) 39.18,48.97 39.51,49.3 41.88,49.3 43.38,50.8 45.85,50.8 46.98,49.67 47.61,49.67 49.32,47.97 50.16,47.97 52.62,45.5 57.05,45.5 58.15,44.41 65.46,44.41 66.16,43.71 124.24,43.71 130.01,37.95 130.01,33.38 130.31,33.08 130.31,31.22 131.63,29.9 131.63,28.69 131.04,28.09 131.04,27.14 131.27,26.91 131.27,24.33 131.78,23.82 131.78,18.77 130.96,17.95 130.96,17.5 v2(131.74,16.73)
WWAN_SMBCLK: length 9.9
  TOP w0.102: R216.2 R218.1 206.6,49.11 207.39,49.11 v2(207.66,48.84)
  IN1 w0.084: v2(207.66,48.84) 207.88,49.06 208.01,49.06 208.41,49.47 208.41,49.76 208.29,49.89 207.94,50.24 207.94,54.99 208.3,55.35 JMINI2.30
WWAN_SMBDAT: length 10.6
  TOP w0.102: v2(207.66,49.45) 207.54,49.34 207.25,49.34 R219.1 R217.2
  IN1 w0.084: v2(207.66,49.45) 207.83,49.28 207.92,49.28 208.2,49.55 208.2,49.68 207.7,50.18 207.7,55.45 208.4,56.15 JMINI2.32
XDP_DBRESET#: length 190.3
  TOP w0.102: CC68.1 58.62,61.95 v2(59.42,61.95) 59.42,61.7 59.99,61.13 JXDP1.48 ; v2(166.8,69.39) 166.61,69.58 166.61,69.7 166.19,70.12 166.19,72.02 v1(166.63,72.47) 167.03,72.86 RC72.1 RC116.2 169.27,72.3 169.66,72.3 169.77,72.41 UC2.1
  IN1 w0.084: v2(59.42,61.95) 58.96,61.49 58.96,59.2 57.44,57.68 57.44,54.91 57.6,54.75 57.6,49.17 53.9,45.47 53.9,42.52 55.89,40.53 55.89,32.43 v2(57.15,31.17)
  IN2 w0.122: v2(166.8,69.39) 167.2,68.99 167.2,63.44 168.09,62.56 168.09,61.08 168.63,60.54 168.63,53.82 169.81,52.65 169.81,48.7 152.78,31.68 137.21,31.68 135.82,30.29 131.32,30.29 130.18,29.15 129.1,29.15 128.79,28.84 126.76,28.84 126.59,28.68 124.96,28.68 124.79,28.84 121.73,28.84 119.04,31.53 97.74,31.53 97.52,31.75 65.84,31.75 64.76,30.68 57.65,30.68 v2(57.15,31.17)
XDP_OBS0_R: length 80.2
  TOP w0.102: v2(65.34,54.65) 65.36,54.63 JXDP1.21
  IN1 w0.084: v2(68.59,79.46) 70.46,81.33 71.44,81.33 72.82,82.7 74.46,82.7 75.31,83.55 78.66,83.55 79.49,84.38 82.62,84.38 83.44,83.57 84.8,83.57 85.52,82.84 88.28,82.84 89.32,83.89 92.02,83.89 93.16,82.75 93.16,81.95 93.91,81.2 100.52,81.2 101.49,80.23 107.95,80.23 109.46,78.73 110.14,78.73 110.85,78.02 v2(110.86,78.02)
  IN4 w0.084: v2(68.59,79.46) 68.15,79.02 68.15,77.18 66.12,75.15 66.12,55.42 v2(65.34,54.65)
  BOTTOM w0.076: v2(110.86,78.02) 110.86,77.95 111.39,77.42 112.84,77.42 113,77.59 113.79,77.59 113.83,77.55 114.3,77.55 UC1.J60
XDP_OBS1_R: length 83.2
  TOP w0.102: v2(64.72,54.66) 65.19,55.13 JXDP1.23
  IN1 w0.084: v2(68,79.43) 70.24,81.67 71.3,81.67 72.68,83.04 74.27,83.04 75.12,83.89 78.52,83.89 79.59,84.95 81.49,84.95 81.99,85.46 83.38,85.46 85.66,83.18 88.14,83.18 89.18,84.23 92.16,84.23 93.5,82.89 93.5,82.09 94.05,81.54 100.66,81.54 101.63,80.57 108.01,80.57 v2(108.06,80.62) 109.24,79.45 109.66,79.45 110.72,78.39 112.33,78.39 112.89,77.83 113.87,77.83 v2(114.3,78.26)
  IN4 w0.084: v2(68,79.43) 67.74,79.17 67.74,77.25 65.78,75.29 65.78,55.56 65.28,55.07 65.13,55.07 v2(64.72,54.66)
  BOTTOM w0.076: UC1.H60 114.6,78.56 v2(114.3,78.26)
  BOTTOM w0.102: v1(107.77,81.09) 108.06,80.8 v2(108.06,80.62)
XDP_OBS2_R: length 6.7
  BOTTOM w0.076: 109.91,79.29 109.97,79.29 110.69,78.56 112.3,78.56 112.38,78.48 112.52,78.34 112.77,78.34 112.94,78.51 112.94,78.69 113.18,78.92 113.69,78.92 UC1.H61
  BOTTOM w0.102: T122.1 108.32,79.29 109.91,79.29
XDP_OBS3_R: length 4.2
  BOTTOM w0.076: 109.91,78.84 109.95,78.84 110.39,78.4 112.23,78.4 112.31,78.32 112.46,78.17 112.84,78.17 112.85,78.18 112.85,78.18 UC1.H62
  BOTTOM w0.102: T126.1 109.91,78.84
XDP_OBS4_R: length 18.1
  IN2 w0.102: v2(115.66,77.52) 115.66,77.73 116.19,78.27 116.19,81.76 118.54,84.11 118.54,85.57
  IN2 w0.122: 118.54,85.57 118.54,88.17 119.15,88.78 120.75,88.78 121.95,89.97 121.95,90.39 v2(121.88,90.45)
  BOTTOM w0.076: v2(115.66,77.52) 115.3,77.17 UC1.K59
  BOTTOM w0.102: v2(121.88,90.45) 122.53,90.45 T129.1
XDP_OBS5_R: length 4.1
  BOTTOM w0.076: UC1.H63 112.47,78.63 112.37,78.73 111.04,78.73 109.97,79.79 109.91,79.79
  BOTTOM w0.102: T130.1 109.53,79.79 109.91,79.79
XDP_OBS6_R: length 20
  IN2 w0.089: 115.58,85.57 115.58,83.82 114.48,82.72 114.48,82.27 112.95,80.75 112.95,78.33 114.29,77 v2(114.29,76.74)
  IN2 w0.122: v2(119.55,90.5) 119.51,90.53 118.42,90.53 115.58,87.69 115.58,85.57
  BOTTOM w0.076: v2(114.29,76.74) 114.6,77.05 UC1.K60
  BOTTOM w0.102: v2(119.55,90.5) 118.67,89.62 T131.1
XDP_OBS7_R: length 17.4
  IN2 w0.089: 116.08,85.57 116.08,84.06
  IN2 w0.102: 116.08,84.06 114.67,82.65 114.67,81.76 113.21,80.3 113.21,79.35 113.65,78.91 v2(113.65,78.26)
  IN2 w0.122: 116.08,85.57 116.08,87.48 118.63,90.03 119.83,90.03 120.13,90.33 v2(120.13,90.45)
  BOTTOM w0.076: v2(113.65,78.26) 113.95,77.96 UC1.J61
  BOTTOM w0.102: T132.1 120.13,90.97 v2(120.13,90.45)
XDP_RST#_R: length 2.7
  TOP w0.102: JXDP1.46 59.98,60.63 59.55,61.06 RC109.2
XFR_ID_BIT#: length 8.9
  TOP w0.102: v2(18.72,37.81) 19.18,38.27 U37.B45 ; RP11.7 12.95,37.46 13.04,37.36 13.04,36.98 13.34,36.69 13.79,36.69 v2(14.01,36.48)
  BOTTOM w0.102: v2(18.72,37.81) 18.53,37.81 17.48,36.75 16.82,36.75 16.77,36.8 15.2,36.8 15.07,36.68 14.21,36.68 v2(14.01,36.48)
XTAL24_IN: length 5.7
  BOTTOM w0.076: 136.9,85.57 136.88,85.55 136.88,85.46 136.56,85.14 UC1.A25
  BOTTOM w0.203: RC44.2 137.92,87.9 RC40.1 137.92,86.6 v1(137.44,86.11) 136.9,85.57
XTAL24_IN_R: length 4.1
  BOTTOM w0.203: RC40.2 137.01,87.9 CC7.2 137.34,88.23 137.34,90.08 YC2.3
XTAL24_OUT: length 12.1
  BOTTOM w0.076: v1(136.98,84.37) 136.85,84.24 136.85,82.69 136.56,82.4 UC1.B25
  BOTTOM w0.203: v1(136.98,84.37) 136.98,85.09 138.46,86.57 138.46,87.57 RC44.1 CC6.2 138.81,89.71 138.86,89.76 138.86,91.99 139.71,92.84 YC2.1
XTALI: length 5.8
  TOP w0.102: 257.35,79.54 257.33,79.54 256.91,79.12 256.22,79.12 256.07,78.97 U21.10
  TOP w0.203: 257.35,79.54 257.62,79.81 R206.2 C190.2 259.77,79.81 259.95,79.62 Y3.1
XTALO: length 3.8
  TOP w0.102: U21.9 256,78.57 256.32,78.89 v1(257.15,78.89) 257.21,78.89
  TOP w0.203: 257.21,78.89 R206.1 R183.2
XTALO_R: length 5.6
  TOP w0.203: R183.1 C189.2 259.83,77.75 259.83,78.08 260.21,78.46 261.65,78.46 Y3.3
Z2805: length 3.3
  TOP w0.102: v2(257.29,95.39) v1(257.29,96.11)
  TOP w0.508: v2(257.29,95.39) 257.3,95.38 R280.1
  BOTTOM w0.508: T94.22 v2(257.29,95.39)
Z2806: length 3.4
  TOP w0.102: v1(250.65,94.21) 250.47,94.39 R278.1
  TOP w0.508: R278.1 249.64,95.26 v2(249.68,95.3)
  BOTTOM w0.508: T94.16 249.67,95.29 v2(249.68,95.3)
Z2807: length 3.6
  TOP w0.102: v1(255.16,95.78) 255.58,95.36 v2(256.02,95.36)
  TOP w0.508: v2(256.02,95.36) 256.03,95.35 R279.1
  BOTTOM w0.508: T94.21 v2(256.02,95.36)
Z2808: length 3.6
  TOP w0.102: v1(247.17,94.39) R277.1
  TOP w0.508: v2(248.4,95.3) 248.37,95.27 R277.1
  BOTTOM w0.508: T94.15 v2(248.4,95.3)
Z4012: length 2.6
  TOP w0.102: v1(267.69,55.99) PR1.2
  TOP w0.254: PD3.2 265.77,56.72 PR1.2
Z4304: length 12.8
  TOP w0.254: 160.4,10.68 160.16,10.93 PRP2.8
  TOP w0.508: PBATT1.3 164.81,3.7 163.26,3.7 162.81,4.14 PD1.2 162.08,6.33 162.08,9.36 v1(161.91,9.53) 160.76,10.68 160.4,10.68
Z4305: length 14.4
  TOP w0.102: PRP2.7 159.66,11.94 159.78,12.06 v1(161.44,12.06)
  TOP w0.254: v2(163.81,6.31) PD1.3 v2(163.81,4.79) ; v2(159.58,9.88) 159.66,9.96 PRP2.7
  BOTTOM w0.254: v2(163.81,6.31) 163.81,7.28 161.21,9.88 v2(159.58,9.88) ; PBATT1.4 163.81,2.69 v2(163.81,4.79)
Z4306: length 11.2
  TOP w0.254: PRP2.6 159.16,10.67 159.02,10.53 159.02,9.47 v1(159.18,9.31) 159.56,8.93 160.54,8.93 160.95,8.52 PD2.2 v2(160.95,6.27)
  IN3 w0.254: PBATT1.5 160.95,3.55 v2(160.95,6.27)
N18526: length 3
  TOP w0.102: v2(144.64,65.38) 143.97,65.38 143.38,64.79 T3.1
  BOTTOM w0.076: v2(144.64,65.38) 144.97,65.71 UC1.AL11
N19012: length 7.3
  TOP w0.102: v2(148.82,70.29) 148.9,70.21 150.29,70.21 151.8,71.71 152.47,71.71 153.12,71.06 154.52,71.06 T4.1
  BOTTOM w0.076: UC1.AC4 148.84,70.31 v2(148.82,70.29)
N19898: length 4.6
  TOP w0.102: T5.1 150.49,62.5 v2(148.95,62.5)
  BOTTOM w0.076: v2(148.95,62.5) 148.99,62.46 149.42,62.46 149.59,62.29 149.59,61.95 149.72,61.82 150.06,61.82 150.38,61.51 UC1.AV2
N33176: length 2.8
  TOP w0.102: T2.1 144.59,75.48 v2(144.26,75.48)
  BOTTOM w0.076: v2(144.26,75.48) 144.7,75.92 144.7,76.17 144.83,76.3 145.02,76.3 145.34,76.62 UC1.K10
N77714: length 2.7
  TOP w0.102: T6.1 140.41,76.94 140.41,77.28 140.58,77.44 v2(140.58,77.67)
  BOTTOM w0.076: v2(140.58,77.67) 140.58,77.63 140.06,77.11 UC1.K21
N77941: length 2.2
  TOP w0.102: v2(139.05,76.2) 138.96,76.11 T7.1
  BOTTOM w0.076: UC1.M21 v2(139.05,76.2)
N434133: length 8.8
  TOP w0.102: T16.1 140.69,86.31 140.16,85.78 140.16,84.61 142.15,82.61 142.15,80.24 v2(142.53,79.86)
  BOTTOM w0.076: UC1.E15 142.96,80.19 142.62,79.86 v2(142.53,79.86)
N434770: length 10.1
  TOP w0.102: T17.1 141.64,87.3 142.25,87.3 143.23,86.32 143.23,84.67 143.85,84.05 143.85,80.85 v2(143.5,80.49)
  BOTTOM w0.076: UC1.E13 143.79,80.2 v2(143.5,80.49)
N453960: length 1.4
  TOP w0.102: T14.1 145.67,65.23 v2(146.07,65.23)
  BOTTOM w0.076: v2(146.07,65.23) 145.62,64.77 UC1.AN10
N453980: length 1.4
  TOP w0.102: T15.1 145.83,66.28 v2(146.12,65.99)
  BOTTOM w0.076: UC1.AM10 145.62,65.48 v2(146.12,65.99)
N517848: length 6.6
  TOP w0.102: v2(150.27,69.22) 150.98,69.22 151.7,69.95 155.44,69.95 T13.1
  BOTTOM w0.076: UC1.AD4 149.46,69.64 149.88,69.22 v2(150.27,69.22)
N592736: length 1.8
  TOP w0.102: T18.1 139.83,68.31 v2(140.58,69.06)
  BOTTOM w0.076: UC1.AF20 140.34,68.83 140.57,69.06 v2(140.58,69.06)
N595754: length 1.2
  TOP w0.102: T19.1 139.21,70.12 v2(139.21,70.11)
  BOTTOM w0.076: v2(139.21,70.11) 139.59,70.48 UC1.AB21
N659696: length 6.4
  BOTTOM w0.076: 109.91,58.39 111.16,58.39 111.94,59.17 111.94,60.93 112.48,61.48 UC1.AV63
  BOTTOM w0.102: T20.1 109.18,58.39 109.91,58.39
N659720: length 5.1
  BOTTOM w0.076: 109.91,59.19 110.73,59.19 111.43,59.89 111.43,61.19 112.38,62.14 UC1.AU63
  BOTTOM w0.102: T21.1 109.55,59.19 109.91,59.19
N659740: length 1.2
  TOP w0.102: T34.1 139.93,74.58 v2(140.5,74.58)
  BOTTOM w0.076: v2(140.5,74.58) UC1.P20
N659776: length 1.5
  TOP w0.102: v2(140.5,73.76) 140.39,73.76 T36.1
  BOTTOM w0.076: UC1.R20 v2(140.5,73.76)
N659780: length 3.5
  BOTTOM w0.076: UC1.A5 148.72,82.9 149.81,83.99 149.81,85.23 149.61,85.43 149.61,85.57
  BOTTOM w0.102: T33.1 149.61,85.57
N659800: length 6.7
  BOTTOM w0.076: 110.16,85.57 110.16,83.84 112.5,81.5 UC1.C63
  BOTTOM w0.102: T22.1 110.16,86.82 110.16,85.57
N659846: length 4.7
  BOTTOM w0.076: UC1.E1 151.27,80.34 150.93,80.68 150.93,81.13 151.08,81.28 151.44,81.28
  BOTTOM w0.102: T35.1 153.63,82.02 152.93,82.02 152.2,81.28 151.44,81.28
N659886: length 5.9
  BOTTOM w0.076: 110.6,85.57 110.6,83.63 112.41,81.83 112.9,81.83 UC1.C62
  BOTTOM w0.102: T23.1 110.6,85.57
N659906: length 3.4
  BOTTOM w0.076: UC1.D1 151.35,81.03 152.3,81.03 152.97,81.7
  BOTTOM w0.102: 152.97,81.7 153.53,81.7 154,81.23 T37.1
N659936: length 3.4
  BOTTOM w0.076: T24.1 125.06,84.73 125.06,82.51 UC1.B43
N659940: length 1.5
  TOP w0.102: T38.1 140.47,78.33 v2(140.58,78.33)
  BOTTOM w0.076: v2(140.58,78.33) 140.58,78.27 140.1,77.79 UC1.J20
N659960: length 3.3
  BOTTOM w0.076: UC1.A51 120.39,82.95 120.96,83.52 120.96,85.11 121.07,85.23 121.07,85.41 121.08,85.42 121.08,85.57
  BOTTOM w0.102: T25.1 121.08,85.57
N659980: length 5.8
  BOTTOM w0.076: UC1.B51 120.68,82.46 120.68,83.01 121.3,83.63 121.3,85.15 121.53,85.38 121.53,85.57
  BOTTOM w0.102: 121.53,85.57 121.53,86.38 120.96,86.96 T26.1
N660016: length 1.5
  TOP w0.102: T39.1 140.58,79.01 v2(140.58,78.98)
  BOTTOM w0.076: UC1.H18 141.05,78.43 140.64,78.84 140.64,78.92 v2(140.58,78.98)
N660346: length 5.5
  BOTTOM w0.076: UC1.L60 114.3,76.05 113.83,76.05 113.7,75.93 112.02,75.93 111.61,76.33 110.62,76.33 110.08,75.79 109.91,75.79
  BOTTOM w0.102: T27.1 109.91,75.79
N660398: length 18.3
  IN2 w0.089: v2(114.29,75.29) 114.29,75.35 115.56,76.62 115.56,76.87 116.38,77.7 116.38,81.44 119.05,84.11 119.05,85.57
  IN2 w0.122: 119.05,85.57 119.05,86.78 119.49,87.22 120.73,87.22 121.31,87.8 v2(121.31,88.34)
  BOTTOM w0.076: v2(114.29,75.29) 114.6,75.59 UC1.N60
  BOTTOM w0.102: v2(121.31,88.34) 121.31,88.61 121.08,88.84 T28.1
N660504: length 2.2
  TOP w0.102: v2(137.27,72.24) 136.46,72.24 T29.1
  BOTTOM w0.076: v2(137.27,72.24) 137.37,72.14 UC1.W23
N660524: length 2.6
  TOP w0.102: T30.1 136.69,71.65 v2(137.08,71.65)
  BOTTOM w0.076: UC1.Y22 137.16,71.73 v2(137.08,71.65)
N660552: length 6.2
  BOTTOM w0.076: T31.1 110.8,57.95 111.11,57.95 112.16,59 112.16,60.9 112.41,61.15 112.95,61.15 UC1.AV62
N660594: length 8
  BOTTOM w0.076: UC1.D58 115.94,80.73 115.55,81.12 115.55,81.25 115.68,81.38 115.68,81.64 115.56,81.76 115.56,81.93 115.88,82.25 115.88,83.23 114.68,84.43 114.68,85.57
  BOTTOM w0.102: T32.1 115.16,87.03 114.68,86.55 114.68,85.98 114.68,85.98 114.68,85.57
N758470: length 19.1
  IN2 w0.089: v2(114.95,76.77) 114.95,77.54 115.37,77.95 115.37,78.33 115.11,78.59 115.11,79.35 115.43,79.67 115.43,82.91 116.58,84.06 116.58,85.57
  IN2 w0.122: v2(120.71,90.45) 120.78,90.39 120.78,89.92 120.38,89.53 118.84,89.53 116.58,87.27 116.58,85.57
  BOTTOM w0.076: UC1.L59 115.25,76.48 v2(114.95,76.77)
  BOTTOM w0.102: T66.1 120.05,89.79 v2(120.71,90.45)
N759266: length 17.6
  IN2 w0.089: 116.83,85.57 116.83,83.74
  IN2 w0.102: v2(115.74,78.51) 115.63,78.51 115.3,78.84 115.3,79.22 115.81,79.73 115.81,82.71 116.83,83.74
  IN2 w0.122: 116.83,85.57 116.83,87.17 118.94,89.28 120.54,89.28 121.36,90.1 121.36,90.39 v2(121.3,90.45)
  BOTTOM w0.076: v2(115.74,78.51) 115.9,78.35 UC1.J58
  BOTTOM w0.102: v2(121.3,90.45) 121.3,91.19 T67.1
N770443: length 18.5
  IN2 w0.089: v2(116.42,75.39) 116.99,75.39 117.4,75.79 117.4,79.24 117.59,79.43 117.59,80.36 118.61,81.37 118.61,81.74 120.96,84.1 120.96,85.01 121.27,85.32 121.27,85.57
  IN2 w0.122: v2(122.48,88.34) 122.48,88.24 123.37,87.35 123.37,86.78 123.05,86.46 122.16,86.46 121.27,85.57
  BOTTOM w0.076: UC1.N58 v2(116.42,75.39)
  BOTTOM w0.102: v2(122.48,88.34) 122.43,88.39 T68.1
N770463: length 3
  TOP w0.102: v2(116.45,70.37) 116.45,70.9 117.15,71.6 T69.1
  BOTTOM w0.076: UC1.AC58 116.08,70.37 v2(116.45,70.37)
N778869: length 3.7
  TOP w0.102: v2(136.96,70.71) 134.99,70.71 T70.1
  BOTTOM w0.076: v2(136.96,70.71) 137.16,70.51 UC1.AB23
N784899: length 1.4
  TOP w0.102: T71.1 137.55,70.5 v2(137.55,69.95)
  BOTTOM w0.076: v2(137.55,69.95) 137.81,69.7 UC1.AD23
N785755: length 1.5
  TOP w0.102: T72.1 137.65,71.58 v2(137.65,71.22)
  BOTTOM w0.076: UC1.AA23 137.75,71.32 v2(137.65,71.22)
N786613: length 20.8
  TOP w0.102: v2(105.3,57.59) 105.3,56.61 T73.1
  IN2 w0.089: v2(115.64,68.42) 115.9,68.17 115.9,62.74 115.42,62.25 114.55,62.25 109.91,57.61
  IN2 w0.122: 109.91,57.61 109.66,57.37 105.53,57.37 v2(105.3,57.59)
  BOTTOM w0.076: UC1.AE59 115.25,68.82 v2(115.64,68.42)
N843309: length 5.8
  BOTTOM w0.076: 109.91,74.78 111.35,74.78 111.91,74.22 112.26,74.22 112.47,74.43 113.76,74.43 113.86,74.52 114.29,74.52 114.6,74.83 UC1.P60
  BOTTOM w0.102: T74.1 109.72,74.78 109.91,74.78
N846514: length 5
  BOTTOM w0.076: 109.91,75.03 111.33,75.03 111.97,74.4 112.21,74.4 112.4,74.59 113.69,74.59 UC1.P61
  BOTTOM w0.102: 109.91,75.03 109.46,75.03 T75.1
N847540: length 16.2
  IN2 w0.089: 120.8,85.57 120.8,85.35 120.64,85.2 120.64,84.03 118.39,81.78 118.39,81.47 117.37,80.45 117.37,79.52 117.18,79.33 117.18,78.18 116,77 116,76.37 v2(115.68,76.05)
  IN2 w0.122: 120.8,85.57 120.8,86.94 121.89,88.04 v2(121.89,88.34)
  BOTTOM w0.076: UC1.N59 115.31,75.67 v2(115.68,76.05)
  BOTTOM w0.102: T76.1 121.89,88.12 v2(121.89,88.34)
N848568: length 18.2
  IN2 w0.089: v2(113.61,75.26) 113.61,76.09 112.7,77 112.7,80.85 113.97,82.12 113.97,83.92 114.68,84.63 114.68,85.89 114.58,85.99
  IN2 w0.122: v2(116.64,89.57) 115.81,89.57 114.58,88.34 114.58,85.99
  BOTTOM w0.076: UC1.N61 113.95,75.6 v2(113.61,75.26)
  BOTTOM w0.102: T77.1 116.95,89.26 v2(116.64,89.57)
N849646: length 21.1
  IN2 w0.089: v2(115.66,74.58) 116.19,74.58 116.76,75.16 117.08,75.16 117.59,75.67 117.59,79.16 117.78,79.35 117.78,80.28 118.8,81.3 118.8,81.68 121.3,84.19 121.3,84.9 121.84,85.45 121.84,85.57
  IN2 w0.122: 121.84,85.57 122.16,85.89 122.92,85.89 123.69,86.65 123.69,87.67 123.06,88.29 v2(123.06,88.34)
  BOTTOM w0.076: UC1.T59 v2(115.66,74.58)
  BOTTOM w0.102: v2(123.06,88.34) 123.06,87.68 123.34,87.4 123.34,86.87 T78.1
N849666: length 4.1
  TOP w0.102: T79.1 117.02,68.92 116.28,69.66 115.34,69.66 v2(114.95,69.26)
  BOTTOM w0.076: UC1.AD60 114.6,69.62 v2(114.95,69.26)
N849686: length 20.2
  TOP w0.102: T80.1 106.86,57.71 v2(106.14,58.43)
  IN2 w0.089: v2(115.54,69.27) 114.22,67.95 114.22,64.46 112.88,63.12 112.88,61.85 109.91,58.88
  IN2 w0.122: 109.91,58.88 109.32,58.29 106.27,58.29 v2(106.14,58.43)
  BOTTOM w0.076: UC1.AD59 115.25,69.56 v2(115.54,69.27)
N849706: length 20
  TOP w0.102: v2(106.56,58.85) 107.45,57.95 T81.1
  IN2 w0.089: 109.91,59.64 112.47,62.2 112.47,63.4 113.13,64.06 113.13,69.39 114,70.26 114.4,70.26 v2(114.92,70.78)
  IN2 w0.122: v2(106.56,58.85) 106.76,58.65 108.92,58.65 109.91,59.64
  BOTTOM w0.076: v2(114.92,70.78) 115.25,71.1 UC1.AA59
N850792: length 4.6
  TOP w0.102: T82.1 117.72,70.14 116.76,70.14 116.57,69.95 114.98,69.95 v2(114.3,69.26)
  BOTTOM w0.076: UC1.AE60 114.6,68.96 114.33,69.23 v2(114.3,69.26)
N850812: length 26.3
  TOP w0.102: v2(104.89,57.18) 102.56,57.18 T83.1
  IN2 w0.089: v2(115.53,70.74) 115.53,70.27 116.07,69.73 116.07,68.71 116.26,68.53 116.26,67.89 116.81,67.33 116.81,62.84 114.71,60.73 113.89,60.73 110.06,56.9 109.91,56.9
  IN2 w0.122: 109.91,56.9 105.17,56.9 v2(104.89,57.18)
  BOTTOM w0.076: v2(115.53,70.74) 115.53,70.66 115.25,70.38 UC1.AC59
N850832: length 18
  TOP w0.102: T84.1 105.99,57.73 v2(105.71,58.01)
  IN2 w0.089: 109.91,58.01 113.9,62 113.9,63.15 114.99,64.24 114.99,66.29 114.83,66.45 114.83,67.41 v2(115.07,67.65)
  IN2 w0.122: v2(105.71,58.01) 105.86,57.86 109.75,57.86 109.91,58.01
  BOTTOM w0.076: v2(115.07,67.65) 115.23,67.81 UC1.AG58
N850852: length 20.7
  IN2 w0.089: 123.18,85.57 122.29,85.57 121.58,84.87 121.58,84.22 119.05,81.69 119.05,81.19 118.03,80.17 118.03,78.97 118.35,78.65 118.35,78.27 117.91,77.83 117.91,75.09 116.38,73.57 v2(115.68,73.57)
  IN2 w0.122: 123.18,85.57 123.96,86.36 123.96,88.02 v2(123.65,88.34)
  BOTTOM w0.076: UC1.U59 115.46,73.35 v2(115.68,73.57)
  BOTTOM w0.102: v2(123.65,88.34) 123.65,87.92 T85.1
N851898: length 3.3
  TOP w0.102: v2(115.62,72.3) 116.52,72.3 117.27,73.05 T86.1
  BOTTOM w0.076: v2(115.62,72.3) 115.25,72.67 UC1.V59
N13302954: length 46.5
  TOP w0.254: v2(192.79,8.89) 193.12,9.22 PR822.1 PR818.1 193.09,10.52 PC809.2 193.09,11.77 v1(192.11,12.75) 191.58,13.28 v2(191.11,13.28) ; PD821.1 203.44,11.25 202.39,12.29 PD816.1 199.95,11.56 199.61,11.22 198.85,11.22 198.43,10.79 197.87,10.79 v2(197.26,11.4)
  IN3 w0.254: v2(191.11,13.28) 191.11,13.61 187.76,16.97 181.94,16.97 180.95,15.98 180.95,10.67 v2(180.57,10.29)
  IN4 w0.254: v2(191.11,13.28) 191.8,13.97 196.04,13.97 196.24,13.77 196.24,11.61 196.44,11.4 v2(197.26,11.4)
  BOTTOM w0.254: v2(192.79,8.89) 192.77,8.88 PD813.1 ; PQ815.4 179.83,11.02 v2(180.57,10.29) ; PQ826.4 191.86,14.03 v2(191.11,13.28)
N13303110: length 4.3
  TOP w0.102: v1(205.14,8.65) PQ830.1
  TOP w0.254: PQ830.1 207.05,9.31 PD821.2
N13303122: length 7.3
  TOP w0.102: v1(208.7,12.18) 208.7,11.99 208.13,11.42 PR836.1
  TOP w0.254: PR836.1 207.89,10.83 207.89,9.51 209.13,8.27 PQ830.2 209.83,7.68 210.48,7.04 PR837.2
N13303138: length 2.3
  TOP w0.102: v1(212.71,7.04) PR837.1
  TOP w0.254: PQ831.1 211.42,6.69 PR837.1
N13303142: length 6.2
  TOP w0.102: v1(212.59,3.19) 211.86,3.19 210.78,4.27 PQ831.2
  TOP w0.254: PU808.4 208.3,4.8 208.48,4.98 210.57,4.98 210.77,4.78 PQ831.2
N13388109: length 6.5
  TOP w0.254: PD820.2 v2(1.88,39.79)
  BOTTOM w0.102: v1(4.25,42.86) 4.19,42.8 PR828.2
  BOTTOM w0.254: v2(1.88,39.79) 1.56,40.11 1.56,41.55 1.71,41.71 PQ832.2 2.49,41.71 3.33,42.54 PR828.2
