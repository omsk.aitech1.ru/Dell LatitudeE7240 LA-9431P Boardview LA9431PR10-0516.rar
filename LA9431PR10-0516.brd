# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_AIN: length 18.2
  TOP w0.203: C214.1 257.29,25.18 256.99,24.88 U27.9 ; C215.1 255.94,15.34 255.94,15.71 256.59,16.35 U27.27
  TOP w0.508: C214.1 257.8,25.68 v2(257.92,25.81) ; v2(255.38,15.43) C215.1
  IN2 w0.508: v2(255.38,15.43) 255.38,21.88 257.92,24.42 v2(257.92,25.81)
  vias: v1(254.71,10.74) v2(254.5,12.17) v2(254.5,11.53)
+3.3V_RUN_AUDIO: length 37.6
  TOP w0.127: 267.64,15.02 266.38,15.02 v5(266.1,14.74)
  TOP w0.254: U17.9 274.58,29.83 274.69,29.72 274.69,29.2 v2(274.75,29.13) ; C119.1 271.41,28.77 v2(271.77,29.13) 271.77,29.13 271.77,29.26 271.58,29.45 U17.3
  TOP w0.508: C120.1 275.04,28.76 274.75,29.06 v2(274.75,29.13) ; R159.1 R158.1 282.37,21.11 v2(281.86,20.6)
  IN3 w0.508: v2(274.75,29.13) 274.75,28.36 275.02,28.09 276.86,28.09 281.86,23.09 v2(281.86,20.6) 280.82,19.56 268.83,19.56 268.81,19.53
  BOTTOM w0.508: v2(274.75,29.13) 273.77,28.16 272.47,28.16 271.77,28.85 v2(271.77,29.13)
  vias: v2(264.01,31.5) v2(269.08,15.58) v2(269.06,14.99)
+3.3V_RUN_AUDIO_U18:
  vias: v1(270.12,17.37)
+3.3V_RUN_CARD:
  vias: v2(250.71,19.43) v2(250.7,18.83) v5(253.1,18.96)
+3.3V_RUN_TPM: length 6.5
  TOP w0.254: U25.24 37.92,37.36 v2(38.47,37.91)
  TOP w0.381: U25.19 41.17,37.61 40.57,38.22 40.56,38.23 C200.1
  TOP w0.508: U25.10 41.17,29.88 40.92,29.63 40.92,29.39 ; C200.1 40.7,38.46 v2(41.33,38.46) ; v2(36.18,38.38) C384.1
  vias: v1(39.8,28.61) v2(35.99,37.76) v2(37.44,29.44) v2(38.05,29.44)
+3.3V_RUN_U46:
  vias: v1(189.4,69.95)
+3.3V_RUN_VDDA: length 5.8
  TOP w0.254: U6.H12 198.6,80.25 v4(198.28,80.57) ; U6.K6 v4(195.03,79.27) 195.35,78.95 U6.K7 ; U6.H5 194.06,80.25 v4(194.38,79.92) ; v4(193.73,79.28) 193.41,79.6 U6.J4 ; U6.C10 v4(197.63,83.82)
  BOTTOM w0.102: C16.1 197.73,87.03 197.42,87.34 197.17,87.34 v1(197.03,87.48)
  BOTTOM w0.508: C14.1 197.63,84.83 v4(197.63,83.82)
+3.3V_RUN_VDDIO: length 7.7
  TOP w0.102: L5.2 v1(188.26,90.63)
  TOP w0.254: U6.C4 193.4,83.5 v4(193.08,83.82) U6.C3 ; U6.K11 v4(198.28,79.27) 198.6,78.95 U6.K12 ; U6.K4 193.4,78.95 v4(193.08,79.27) U6.K3 ; U6.C12 198.6,83.5 v4(198.28,83.82) U6.C11
  BOTTOM w0.254: C28.1 193.08,84.56 v4(193.08,83.82)
  BOTTOM w0.508: v4(198.28,83.82) 198.79,84.34 C29.1 ; C27.1 198.35,79.2 v4(198.28,79.27)
  vias: v2(189.6,88.34) v2(190.23,88.34)
+3.3V_RUN_VMM: length 84.7
  TOP w0.508: R74.1 190.09,73.09 189.5,72.49 v2(187.12,72.49) ; v2(205.6,78.52) 205.38,78.31 204.56,78.31 R44.2 204.39,77.19 R70.2 R72.2 204.41,75.36 R54.2 204.24,75.2 204.24,74.99 203.84,74.59 R53.2 ; v2(212.85,90.09) 209.23,90.09 207.72,91.6 204.1,91.6 202.53,90.03 R49.2 R46.2 v2(200.65,90.66)
  IN1 w0.508: v2(212.85,90.09) 212.85,88.75 212.19,88.09 212.19,86.74 210.6,85.15 v2(210.6,84.67) ; v4(191.1,76.85) 191.26,76.85 192.49,75.62 v2(196.2,75.62)
  IN2 w0.508: v2(187.12,72.49) 187.35,72.72 187.35,79.08 186.44,79.99 v2(186.44,80.17) ; v2(181.46,82.32) 181.46,82.8 182.65,84 182.65,85.84 183.96,87.15 184.67,87.15 185.7,88.18 186.72,88.18 v2(187,88.45)
  IN3 w0.508: v2(186.44,80.17) 186.01,80.17 184.46,81.72 182.06,81.72 v2(181.46,82.32)
  BOTTOM w0.381: C93.1 210.32,83.36 209.84,82.87 U11.14 ; R56.1 180.93,81.71 U13.14
  BOTTOM w0.508: v2(191.69,87.27) 192.33,86.64 R64.1 ; v2(181.46,82.32) 181.2,82.57 C97.1 R56.1 ; R60.1 210.6,85.23 v2(210.6,84.67) 210.55,84.62 C93.1 ; v4(191.1,76.85) 191.69,77.44 C34.1 R65.1 191.87,78.92 191.31,79.48 187.13,79.48 v2(186.44,80.17) 186.55,80.17 187,80.62 U7.8 ; L2.2 199.98,86.21 v2(200.75,86.98) ; U11.14 207.5,82.87 205.41,80.78 205.41,79.32 205.6,79.13 v2(205.6,78.52)
  vias: v1(192.09,91.31) v2(198.58,90.7)
+3.3V_RUN_VMM_U31: length 0.8
  BOTTOM w0.102: v1(193.08,73.32) 193.14,73.38 193.81,73.38
+3.3V_SUS: length 127.4
  TOP w0.203: v2(167.63,102.4) 167.72,102.49 167.72,103.07 167.46,103.33 U33.29 ; v2(165.58,106.5) 165.58,106.48 165.33,106.22 165.33,105.89 165.14,105.71 U33.3 ; v2(162.61,106.08) 162.74,105.95 U33.9 ; v2(159.98,104.99) 160.44,104.53 U33.12 ; U33.20 163.14,101.55 v2(163.56,101.13) ; v2(159.94,102.84) 160.03,102.93 U33.16
  TOP w0.508: C420.1 166.74,108.56 v2(166.73,108.55) ; v2(170.93,70.19) 170.94,70.19 171.28,69.85 171.28,68.52 172.73,67.07 174.72,67.07 177.81,63.98 177.81,58.22 177.25,57.66 177.25,47.15 181.03,43.38 181.03,31.25 182.16,30.12 182.16,24.68 180.48,23 180.48,16.81 180.21,16.55 180.21,15.98 179.74,15.51 179.74,9.93 180.2,9.47 v2(180.92,9.47) 181.52,8.88 R191.1 R190.1 ; v2(157.15,110.59) 157.42,110.86 C414.1 ; C417.1 159.98,105.28 v2(159.98,104.99) ; C418.1 167.83,99.03 C416.1 167.51,100.1 v2(167.54,100.13) 167.51,100.15 C419.1 167.51,102.29 v2(167.63,102.4) ; v2(155.64,110.62) C415.1
  IN2 w0.508: v2(170.93,70.19) 170.02,71.11 170.02,72.52 171.27,73.77 171.27,78.87 174.4,81.99 174.4,83.07 173.57,83.9 173.57,85.25 172.93,85.9 172.93,90.71 167.54,96.1 v2(167.54,100.13)
  IN3 w0.508: v2(186.08,7) 186.08,8 184.61,9.47 v2(180.92,9.47)
  vias: v2(186.72,7) v2(187.35,7) v2(195.73,13.46) v2(195.7,12.86) v2(195.7,12.28) v5(188.57,23.62)
+3.3V_SUS_U45: length 2.1
  TOP w0.102: v1(187.9,31.91) 188.01,31.8 189.23,31.8 189.74,31.29 C396.1
+3.3V_TP: length 20.3
  TOP w0.127: v5(191.44,20.92) 191.12,20.6 v2(191.12,20.04)
  TOP w0.508: v2(193.41,19.34) 193.41,19.15 192.76,18.5 R404.1 ; R405.1 190.96,18.6 190.43,19.13 190.43,19.72 190.75,20.04 v2(191.12,20.04)
  IN2 w1.016: 199.7,8.86 199.76,8.93 199.76,14.13 199.24,14.66 193.65,14.66 192.84,15.47 192.84,17.93 192.89,17.98
  vias: v2(198.62,7.7) v2(199.23,7.71)
+3.3V_TSP: length 80.4
  IN2 w1.016: 70.76,76.64 70.76,78.24 71.88,79.36 71.88,83.57 73.14,84.82 75.15,84.82 77.11,86.79 77.34,86.79 78.23,87.68 78.23,88.78 84.19,94.73 95.35,94.73 101.18,100.56 104.04,100.56 107.04,97.56 111.73,97.56 113.08,98.9 113.08,99.53 114.53,100.98 115.46,100.98 118.59,104.11 118.59,105.05 119.76,106.21 128.45,106.21 130.61,104.05
  vias: v2(71.06,75.45) v2(71.36,75.96) v2(131.41,104.08) v2(131.97,104.55) v5(138.1,102.59)
+3.3V_TSP_Q:
  vias: v1(143.52,100.8)
+3.3V_VTR: length 3.9
  TOP w0.279: U38.A22 30.57,13.33 30.65,13.25 31.92,13.25 C352.1
  TOP w0.508: R336.2 C346.1 C352.1
+3.3V_VTR_ADC: length 13.7
  TOP w0.102: R490.2 17.31,6.81 v1(17.42,6.69)
  TOP w0.279: U38.A58 18.55,13.83 17.94,14.44 C347.1
  TOP w0.508: v2(18.14,8.8) 17.31,7.97 R490.2 ; v2(17.96,13.5) 17.91,13.55 C353.1 C347.1
  IN3 w0.508: v2(18.14,8.8) 17.88,8.55 16.88,8.55 16.52,8.91 16.52,9.99 16.33,10.17 16.33,12.35 17.48,13.5 v2(17.96,13.5)
+3.3V_WLAN: length 7.4
  TOP w0.508: JMINI1.24 211.66,21.2 211.28,20.81 C261.2 209.59,20.81 C262.1 207.59,20.83 v5(207.31,20.54) 207.31,19.4 207.32,19.41 v2(207.32,19.25)
  vias: v2(206.41,26.62) v2(206.41,26) v2(206.65,38.92) v2(207.15,39.27) v2(208.03,27.86) v2(208.61,27.86) v2(210.08,8.25) v2(210.62,7.9) v2(210.66,8.48)
+3.3V_WLAN_U3: length 1.9
  TOP w0.102: PJP23.2 v1(205.64,23.24)
+5V_ALW: length 619.7
  TOP w0.203: v2(116.36,13.26) 116.21,13.11 PU11.12 ; v2(199.5,38.01) U22.4 ; v2(203.3,24.14) 203.15,24.29 U3.4 ; U18.4 v2(266.21,18.77) ; U45.4 194.14,32.87 v2(194.3,33.03)
  TOP w0.254: U39.5 72.9,84.38 72.7,84.18 72.31,84.18 72.14,84.35 72.14,84.81 C287.1
  TOP w0.279: PC305.1 235,75.04 235,74.78 235.2,74.58 PU300.7
  TOP w0.381: v2(79.6,98.74) 79.74,98.74 80.25,98.23 PU111.5
  TOP w0.508: v2(161.86,92.72) 161.25,93.33 160.01,93.33 R445.1 ; v2(210.3,72.14) 210.3,72.01 210.81,71.5 211.53,71.5 213.59,69.44 214.73,69.44 215.75,70.46 218.99,70.46 219.81,71.28 219.81,72.58 220.7,73.47 220.7,77.7 222.58,79.58 222.58,81.21 224.4,83.03 227.72,83.03 ; v2(37.57,20.24) 37.12,19.79 R411.1 ; v2(84.86,93.65) 84.94,93.73 84.94,94.86 84.3,95.49 PD5.3 ; v2(94.17,82.19) PC724.1 PC725.1 PR727.2 92.37,82.82 90.75,81.2 90.75,79.32 91.3,78.78 PR526.2 ; R434.2 225.44,96.95 225.64,96.75 226.95,96.75 229.1,94.6 v2(229.1,93.75) ; v2(82.98,89.81) 82.98,90 83.57,90.59 84.87,90.59 85.62,89.84 PR11.1 ; C287.1 R244.2 v2(72.2,86.64) ; v2(116.36,13.26) 117.41,13.26 PR202.1 118.45,13.65 PC209.2 ; v2(54.67,79.11) R243.2 ; PR843.2 v2(1.94,31.98) ; R28.1 127.75,26.83 127.94,26.64 127.94,24.98 128.71,24.21 128.71,22.04 128.83,21.92 v2(128.83,21.51) ; LED7.4 LED7.2 195.75,100.49 194.65,99.39 183.76,99.39 v2(183.25,98.88) ; v2(236.59,78.27) 236.59,77.57 234.63,75.62 PC305.1
  TOP w1.016: 231.29,82.83 231.29,81.48 231.83,80.95 235.84,80.95
  IN1 w0.508: v2(70.94,83.54) 71.49,83.54 73.29,85.35 74.44,85.35 75.16,86.07 91.5,86.07 94.17,83.4 v2(94.17,82.19) ; v2(84.86,93.65) 84.65,93.44 84.65,92.18 85.26,91.57 87.39,91.57 90.02,94.2 101.39,94.2 v2(102.41,95.22) 102.41,98.83 v2(101.55,99.69) ; v2(59.74,69.76) 60.25,69.25 60.25,65.19 60.24,65.18 60.24,57.48 58.15,55.4 58.15,48.95 55.52,46.32 55.52,41.72 56.52,40.73 56.52,39.95 58.55,37.92 58.6,37.87 58.6,34.12 57.91,33.43 v2(57.91,31.2)
  IN2 w0.508: v2(210.3,72.14) 210.05,72.14 209.45,72.73 209.45,73.39 208.61,74.23 v2(208.61,75.16) ; v2(79.6,98.74) 79.91,98.74 82.66,95.99 94.05,95.99 94.86,96.79 v2(94.86,99.1) ; 198.57,66.83 198.57,68.08 196.32,70.33 v2(196.32,70.44) ; 198.57,66.83 200.72,66.83 v2(200.74,66.81) ; 198.57,66.83 197.03,66.83 196.05,65.85 196.05,64.39 194.73,63.07 189.88,63.07 v2(188.01,64.93) ; v2(266.21,18.77) 266.21,19.68 v2(266.98,20.45) ; v2(116.36,13.26) 123.95,13.26 126.13,15.44 132.55,15.44 v2(132.64,15.53)
  IN3 w0.508: v2(161.86,92.72) 161.86,93.13 162.15,93.42 166.89,93.42 167.87,92.44 181.33,92.44 v2(181.74,92.85) ; v2(194.3,33.03) 195.9,34.63 198.68,34.63 199.92,35.88 199.92,37.59 v2(199.5,38.01) ; v2(82.98,89.81) 74.07,89.81 72.2,87.94 v2(72.2,86.64) 72.2,86.55 71.21,85.56 71.21,83.81 v2(70.94,83.54) 69.01,83.54 68.65,83.9 63.8,83.9 v2(62.65,82.75) 62.26,82.36 62.26,81.46 60.2,79.4 60.2,73.26 59.49,72.55 59.49,70.01 v2(59.74,69.76) ; v2(128.83,21.51) 128.83,20.81 129.15,20.5 130.62,20.5 130.96,20.15 133.62,20.15 134.51,19.26 137.66,19.26 138.48,20.08 138.48,22.63 139.12,23.27 148.73,23.27 150.71,25.25 185.62,25.25 187.03,23.84 191.43,23.84 191.78,24.19 193.43,24.19 193.95,23.67 197.27,23.67 197.68,23.27 202.43,23.27 v2(203.3,24.14)
  IN4 w0.508: v2(57.91,31.2) 57.91,31.5 57.56,31.85 56.77,31.85 55.84,30.92 55.84,29.8 53.34,27.3 53.34,25.99 51.83,24.47 51.83,24 50.15,22.33 v2(50.09,22.33) 50.09,21.5 47.37,18.78 47.37,18.19 46.97,17.79 41.27,17.79 38.82,20.24 v2(37.57,20.24) 36.83,19.5 36.04,19.5 34.7,18.16 33.8,18.16 33.07,17.43 31.48,17.43 30.99,16.94 28.42,16.94 27.46,15.98 26.19,15.98 25.63,15.42 25.63,14.35 25.32,14.04 20.53,14.04 19.74,14.83 19.74,16.38 18.97,17.14 17.04,17.14 16.64,16.74 16.64,16.26 16.37,15.99 16.37,15.67 16.01,15.31 15.49,15.31 14.76,14.58 12.6,14.58 11.58,15.6 11.58,17.73 11.24,18.07 11.24,21.04 9.94,22.34 9.94,29.01 8.65,30.3 3.47,30.3 1.94,31.83 v2(1.94,31.98) ; v2(203.3,24.14) 201.73,25.72 201.73,27.13 200.46,28.4 200.46,31.06 197.66,33.86 197.66,37.36 198.31,38.01 v2(199.5,38.01) 200.9,39.41 200.9,40.58 199.42,42.06 199.42,45.47 200.61,46.66 200.61,47.57 202.01,48.97 202.01,52.31 202.02,52.32 202.02,53.14 202.86,53.97 202.86,55.55 203.63,56.33 203.63,64.85 204.48,65.7 204.48,66.64 204.23,66.89 200.81,66.89 v2(200.74,66.81)
  BOTTOM w0.203: U31.4 196.52,70.65 v2(196.32,70.44) ; v2(208.61,75.16) 208.32,74.87 U43.4
  BOTTOM w0.381: v2(203.44,95.22) 203.44,94.47 203.14,94.17 Q15.3 ; v2(203.3,95.91) 202.63,96.59 Q16.3
  BOTTOM w0.508: v2(54.67,79.11) 54.67,80.19 56.76,82.27 60.15,82.27 60.67,82.79 62.61,82.79 v2(62.65,82.75) ; v2(128.83,21.51) 128.83,20.49 128.51,20.17 128.51,17.9 130.88,15.53 v2(132.64,15.53) ; v2(84.86,93.65) 84.44,93.23 84.44,91.27 v2(82.98,89.81) ; PU2.8 93.73,82.64 v2(94.17,82.19) ; PU400.6 102.04,94.67 102.21,94.5 PC400.1 102.69,94.94 v2(102.41,95.22) ; v2(94.86,99.1) 94.86,98.21 94.3,97.65 C3.1
  BOTTOM w1.016: 266.14,30.81 265.94,30.61 265.94,28.27 267.09,27.11 267.09,24.84 267.97,23.96 267.97,23.61 267.96,23.6 ; 266.93,72.49 266.93,47.1
  vias: v2(103.94,104.37) v2(103.94,103.73) v2(104.57,104.37) v2(104.57,103.73) v2(104.57,103.03) v2(122.47,99.02) v2(123.67,98.18) v2(181.04,96.8) v2(181.53,97.2) v2(181.96,97.59) v2(182.36,98.02) v2(182.78,98.42) v2(229.98,85.25) v2(230.62,85.25) v2(230.94,85.77) v2(231.25,85.25) v2(231.6,85.77) v2(231.89,85.25) v2(232.47,85.25) v2(233.5,85.32) v2(235.92,78.26) v2(242.42,73.38) v2(242.57,72.75) v2(266.98,21.06) v5(105.33,103.48) v5(180.8,93.29) v5(236.46,79.1)
+5V_ALW2: length 2.8
  TOP w0.203: v5(196.71,52.04) 196.84,51.92 PU100.13
  TOP w0.508: v5(196.71,52.04) 196.71,52.17 196.2,52.68 PC118.1
+5V_ALW_U41: length 3.7
  TOP w0.102: v1(39.23,18.16) 38.48,17.41 U41.1
  TOP w0.508: U41.1 37.96,18.57 C387.1 R411.2
+5V_ALWP: length 58.8
  TOP w0.203: 196.08,51.79 196.44,51.43 PU100.14
  TOP w0.254: v2(183.13,62.46) 182.36,62.46 180.24,60.34 180.24,49.42 186.5,43.15 194.42,43.15 194.81,43.54 PR101.1
  TOP w0.508: 183.12,61.63 182.55,61.63 181.03,60.11 181.03,53.7 181.46,53.26 v1(186.47,53.26) 192.74,53.26 193.55,52.45 195.42,52.45 196.08,51.79
  vias: v2(183.13,63.09) v2(183.76,63.09) v2(183.76,62.46) v2(184.39,62.46) v2(185.03,62.46) v2(185.66,62.46) v2(185.66,61.82) v2(186.42,62.46) v2(186.42,61.82) v2(187.06,62.46) v2(187.06,61.82)
+5V_HDMI_DDC: length 10.5
  IN2 w0.508: v2(201.02,101.6) 201.02,101.04 202.11,99.95 203.23,99.95 204.52,101.24 v2(204.52,102.29)
  BOTTOM w0.508: R471.2 v2(204.52,102.29) ; D65.1 199.95,98.55 200.32,98.92 v1(200.32,99.72) 200.32,100.29 201.02,100.99 v2(201.02,101.6)
+5V_RUN: length 451.2
  TOP w0.102: v2(49.24,45.75) v5(49.24,46.47)
  TOP w0.508: v2(37.01,24.1) 37.03,24.1 37.45,23.68 R355.1 R357.1 ; v2(49.24,45.75) 49.84,45.15 C7.1 50.92,45.08 D1.1 ; JFAN1.1 53.48,55.83 v2(53.48,54.52) ; v2(25.96,23.91) R356.1 R354.1
  IN1 w0.508: v2(37.01,24.1) 37.01,24.56 37.19,24.74 38.97,24.74 39.53,25.29 39.53,29.16 40.25,29.89 40.25,33.88 39.93,34.21 39.93,35.54 40.63,36.24 40.63,40.04 40.18,40.49 40.18,43.48 42.19,45.49 48.98,45.49 v2(49.24,45.75) 49.63,45.75 52.06,48.17 52.06,49.13 54.27,51.34 54.27,53.73 v2(53.48,54.52) ; v2(65.56,39.33) 65.56,40.33 78.03,52.81 78.03,63.09 80.12,65.19 80.12,68.2 81.24,69.32 85.89,69.32 v2(85.92,69.29)
  IN2 w0.508: 184.85,99.49 179.63,94.27 179.63,89.69 179.06,89.12 179.06,88.43 177.34,86.72 177.34,84.25 178.03,83.57 178.03,83.04 177.03,82.04 177.03,81 176.43,80.41 176.43,79.82 177.09,79.16 181.03,79.16 182.23,80.37 184.38,80.37 v2(184.84,79.91) 185.52,79.91 186.72,78.71 186.72,74.4 185.12,72.8 185.12,70.5 v2(186.04,69.57) ; 184.85,99.49 184.85,101.96 v2(185.13,102.23) ; 184.85,99.49 189.81,99.49 189.92,99.6 198.56,99.6 v2(199.03,99.14)
  IN3 w0.508: v2(85.92,69.29) 85.92,74.92 86.25,75.25 87.88,75.25 88.77,76.14 88.77,76.96 90.7,78.89 90.7,80.8 93.4,83.49 98.03,83.49 101.99,87.45 104.6,87.45 106.44,85.61 106.44,84.95 107.44,83.95 108.92,83.95 110.73,85.76 113.65,85.76 114.85,86.96 119.56,86.96 120.12,86.4 127.4,86.4 127.6,86.2 128.43,85.37 130.84,85.37 131.43,85.97 133.72,85.97 134.24,85.45 140.21,85.45 140.89,86.12 142.63,86.12 143.29,85.45 143.29,84.57 143.94,83.92 145.21,83.92 146.48,82.65 147.94,82.65 148.2,82.91 149.64,82.91 150.8,81.74 150.8,80.68 151.5,79.98 153.73,79.98 154.38,80.63 160.4,80.63 160.97,81.2 162.29,81.2 163.91,79.59 165.92,79.59 168.29,77.22 170.59,77.22 172.8,79.43 176.45,79.43 176.67,79.21 179.15,79.21 180.77,80.83 183.91,80.83 v2(184.84,79.91) ; v2(203.42,31.11) 204.27,30.26 205.84,30.26 207.39,28.71 207.39,26.09 206.35,25.04 206.35,23.61 208.16,21.8 208.16,15.41 205.28,12.53 205.28,9.25 v2(203.73,7.69) 202.56,8.86 198.81,8.86 196.34,11.33 194.42,11.33 193.69,10.59 190.04,10.59 189,9.55 v2(189,7.47)
  IN4 w0.508: v2(25.96,23.91) 25.96,24.07 26.51,24.62 29.55,24.62 30.77,23.4 32.97,23.4 33.36,23 35.98,23 37.01,24.03 v2(37.01,24.1)
  BOTTOM w0.203: PC509.2 84.94,67.28 84.7,67.52 PU501.2
  BOTTOM w0.508: v2(186.04,69.57) 185.65,69.96 183.9,69.96 182.97,69.04 182.97,68.29 180.98,66.29 177.9,66.29 177.47,65.86 177.47,63.3 175.72,61.54 175.72,44.52 182.43,37.81 190.3,37.81 192.19,35.92 194.16,35.92 194.45,35.62 195.85,35.62 196.91,36.69 196.91,37.81 198.91,39.8 202.67,39.8 204.09,38.38 204.09,37.06 203.62,36.59 203.62,31.32 v2(203.42,31.11) ; v2(49.24,45.75) 49.24,45.64 52.28,42.6 54.97,42.6 55.46,42.11 63.03,42.11 65.56,39.58 v2(65.56,39.33) ; v2(85.92,69.29) 85.92,67.63 PC509.2 ; v2(185.13,102.23) 184.98,102.08 C333.1 184.71,100.48 U48.1 ; R472.1 201.13,96.33 D65.2 199.93,96.33 198.88,97.38 198.88,98.99 v2(199.03,99.14)
+5V_RUN_AUDIO: length 2.1
  TOP w0.102: L21.2 270.7,22.89 272.01,24.21 v5(272.01,24.31)
  vias: v2(266.59,40.91) v2(267.17,40.91) v2(270.65,22.19) v2(271.08,21.75)
+5V_RUN_U46: length 1
  TOP w0.102: v1(185.89,67.08) 186.16,67.35 186.16,67.93
+5V_USB_CHG_PWR: length 18.3
  IN4 w1.27: 82.73,95.77 89.34,95.77 89.8,95.3 94.33,95.3 95.79,96.76 95.79,98.44 97.21,99.86 97.21,100.62
  vias: v2(82.32,98.11) v2(82.93,98.11) v2(84.1,97.38) v2(84.47,96.85) v2(96.83,102.27) v2(96.83,101.64) v2(97.46,102.27) v2(97.46,101.64) v5(98.16,101.19)
+DVDD_CORE: length 3.3
  TOP w0.102: C121.1 268.36,28.88 268.25,28.76 v1(268.14,28.76)
  TOP w0.254: U17.1 270.58,29.85 269.61,28.88 C121.1
+GND_CHASSIS: length 6.7
  BOTTOM w1.016: 259.96,91.63 262.02,89.57 262.02,88.06 262.86,87.21 C327.2
  vias: v1(258.89,93.15) v2(259.65,92.47) v2(260.27,92.48)
+V1.05S_APLLOPI: length 12.6
  TOP w0.508: v2(151.59,91.01) LC5.2 151.28,88.56 v1(151.28,87.29) 151.28,85.61 150.64,84.97 150.64,84.27 149.35,82.98 ; v2(140.51,72.12) CC56.1
  BOTTOM w0.254: UC1.AA21 139.59,71.35 v2(139.21,71.72) 139.59,72.1 UC1.W21 139.59,72.18 v2(139.22,72.54)
  BOTTOM w0.508: CC55.1 151.57,89.92 151.57,90.99 v2(151.59,91.01)
  vias: v2(147.35,79.86)
+V1.05SP_B+: length 2.5
  TOP w0.127: v1(223.62,75.45) 224.59,74.48 224.59,73.33
  vias: v3(229.72,71.7)
+VCC_CORE: length 58.6
  TOP w0.508: 112.62,83.32 112.62,86.51 112.29,86.84 RC250.1 ; C460.1 127.83,70.57 v2(127.47,70.93) ; C459.1 v2(134.38,76.02) ; C458.1 v2(133.07,76.03)
  BOTTOM w0.127: UC1.F48 122.44,79.46 ; UC1.F48 122.21,79.68 121.98,79.46 ; UC1.F48 122.21,79.69 ; 116.32,79.73 116.32,79.54 UC1.G57 ; UC1.G27 135.17,79.1 ; UC1.G27 135.43,79.35 135.56,79.23 135.56,78.88 ; UC1.G27 135.43,79.37 ; 130.54,79.8 130.54,79.48 130.43,79.37 130.42,79.37 ; 135.17,79.61 135.41,79.37 135.43,79.37 ; 117.19,79.18 UC1.F56 ; UC1.F56 117.19,80.13 ; UC1.F56 117.59,80.09 ; UC1.F56 116.83,80.05 ; 126.53,79.36 UC1.G41 ; 126.53,79.36 126.42,79.25 126.42,78.87 v2(126.53,78.75) ; 126.53,79.36 126.8,79.1 ; UC1.G41 126.53,79.36 126.42,79.48 126.42,79.76 126.49,79.83 ; UC1.G41 126.53,79.36 126.82,79.65 ; 116.5,79.36 UC1.G57 ; 116.5,79.36 116.76,79.1 ; 116.5,79.36 116.5,78.98 116.51,78.97 ; UC1.G57 116.52,79.36 116.76,79.6 ; UC1.H23 138.16,78.62 137.92,78.38 ; UC1.H23 138.28,78.52 138.28,77.95 UC1.J23 ; UC1.H23 138.15,78.64 137.9,78.89 ; UC1.H23 138.2,78.68 138.2,79.1 137.94,79.36 ; 129.73,79.69 129.72,79.69 129.45,79.96 ; 129.73,79.69 UC1.F36 ; 129.73,79.69 129.74,79.69 130.01,79.96 ; 127.91,79.37 127.89,79.37 127.65,79.61 ; 127.91,79.37 127.92,79.37 128.03,79.48 128.03,79.8 ; 127.91,79.37 UC1.G39 ; 121.4,79.86 121.4,79.48 121.51,79.36 UC1.G49 ; 130.42,79.37 130.4,79.37 130.16,79.61 ; 130.42,79.37 UC1.G35 ; 132.24,79.69 UC1.F32 ; 132.24,79.69 132.25,79.69 132.52,79.96 ; 132.24,79.69 132.23,79.69 131.96,79.96 ; UC1.F32 132.24,79.68 132.01,79.46 ; UC1.F32 132.47,79.46 ; 132.59,79.04 132.91,79.36 UC1.G31 ; 137.59,78.14 137.84,78.14 UC1.J23 ; UC1.G25 136.45,79.25 v2(136.45,78.65) ; UC1.G25 136.89,79.03 136.89,79.03 ; UC1.G25 136.47,79.45 136.47,79.78 ; UC1.G25 136.74,79.54 136.89,79.54 ; 118.92,79.79 118.92,79.45 UC1.G53 ; UC1.G31 133.02,79.46 133.02,79.81 ; UC1.G31 132.93,79.37 132.66,79.63 ; UC1.G31 v2(132.93,78.75) ; 129.5,79.46 129.73,79.68 UC1.F36 ; UC1.G33 131.57,79.36 131.81,79.6 ; UC1.G33 131.5,79.41 131.5,79.79 ; UC1.G33 131.55,79.36 ; 121.52,79.36 121.4,79.24 121.4,78.87 v2(121.52,78.75) ; 121.52,79.36 UC1.G49 ; 121.52,79.36 121.84,79.03 ; 118.03,78.9 118.03,79.21 UC1.G55 ; UC1.G53 v2(119.01,78.75) ; UC1.G53 119.3,79.66 119.3,79.67 ; UC1.G53 119.04,79.36 119.3,79.1 ; 137.94,79.36 UC1.G23 ; 137.94,79.36 137.94,79.34 137.69,79.1 ; v2(120.39,78.75) 120.51,78.87 120.51,79.24 UC1.G51 ; UC1.G43 125.39,79.36 125.12,79.63 ; UC1.G43 125.4,79.35 125.15,79.1 ; UC1.G43 125.41,79.36 ; 117.97,79.79 117.97,79.45 UC1.G55 ; UC1.G51 120.51,79.48 120.51,79.79 ; UC1.G51 120.38,79.36 120.14,79.6 ; UC1.G51 120.39,79.35 120.13,79.1 ; 134.52,79.46 134.74,79.68 UC1.F28 ; UC1.G35 130.16,79.1 ; UC1.G35 130.42,79.35 130.54,79.23 130.54,78.88 ; UC1.G55 117.88,79.37 117.59,79.67 ; UC1.G55 117.86,79.36 117.59,79.1 ; 137.25,79.69 137.26,79.69 137.54,79.96 ; 137.25,79.69 UC1.F24 ; 137.25,79.69 137.25,79.69 136.98,79.96 ; v2(129.04,78.75) UC1.G37 ; UC1.G37 128.96,79.45 128.96,79.79 ; UC1.G37 129.07,79.36 129.34,79.1 ; UC1.G37 129.04,79.37 129.34,79.67 ; 119.41,79.37 119.41,79.4 UC1.F52 ; 134.29,79.12 134.05,79.36 UC1.G29 ; 119.43,79.96 119.43,79.96 UC1.F52 ; UC1.F28 134.74,79.69 ; UC1.F28 134.98,79.46 ; 127.22,79.69 UC1.F40 ; 127.22,79.69 127.23,79.69 127.51,79.96 ; 127.22,79.69 127.22,79.69 126.95,79.96 ; UC1.F40 127.45,79.46 ; UC1.F40 127.22,79.68 127,79.46 ; 122.54,79.03 122.87,79.36 UC1.G47 ; UC1.G23 137.96,79.36 138.18,79.58 138.18,79.76 ; UC1.G23 137.93,79.36 137.67,79.63 ; 134.32,79.63 134.05,79.37 UC1.G29 ; 133.93,79.83 133.93,79.48 134.05,79.36 134.05,79.36 ; UC1.J23 137.9,77.57 137.78,77.57 ; UC1.J23 138.23,77.76 138.23,77.44 ; 124.71,79.69 UC1.F44 ; 124.71,79.69 124.71,79.69 124.44,79.96 ; 124.71,79.69 124.73,79.69 125,79.96 ; UC1.F44 124.95,79.46 ; UC1.F44 124.71,79.68 124.49,79.46 ; UC1.F24 137.48,79.46 ; UC1.F24 137.25,79.68 137.03,79.46 ; 134.74,79.69 134.76,79.69 135.03,79.96 ; 134.74,79.69 134.74,79.69 134.47,79.96 ; 128.03,78.88 128.03,79.23 127.91,79.35 UC1.G39 ; 135.43,79.37 135.44,79.37 135.56,79.48 135.56,79.8 ; 122.61,79.67 122.9,79.38 UC1.G47 ; v2(124.02,78.75) 123.93,78.85 123.93,79.25 124.02,79.34 UC1.G45 ; 134.05,79.36 133.93,79.25 133.93,78.87 v2(134.05,78.75) ; 134.05,79.36 UC1.G29 ; 124.26,79.15 124.04,79.36 ; 124.04,79.36 124.04,79.36 124.31,79.63 ; 124.04,79.36 UC1.G45 ; 131.55,79.36 131.81,79.1 ; 131.55,79.36 131.5,79.31 131.5,78.8 v2(131.55,78.75) ; 122.21,79.69 122.2,79.69 121.93,79.96 ; 122.21,79.69 122.22,79.69 122.49,79.96 ; UC1.G49 121.54,79.36 121.78,79.6 ; UC1.G45 124.02,79.38 123.9,79.5 123.9,79.83 ; v2(122.9,78.75) 122.99,78.84 122.99,79.27 UC1.G47 ; 125.41,79.36 125.41,79.36 125.53,79.48 125.53,79.83 ; 125.41,79.36 125.53,79.25 125.53,78.88 v2(125.4,78.75) ; UC1.F36 129.96,79.46 ; UC1.F52 119.83,79.82 v2(119.83,80.29) ; UC1.F52 119.73,79.69 119.99,79.43 ; UC1.G47 123.02,79.48 123.02,79.8 ; UC1.G39 127.65,79.1
  BOTTOM w0.229: v2(114.95,79.75) 115.25,79.46 UC1.F59
  vias: v2(95.73,79.02) v2(96.32,70.52) v2(97.56,79.04) v2(99.44,79.07) v2(102.67,79.12) v2(104.52,79.12) v2(106.35,79.12) v2(111.68,81.44) v2(116.76,78.52) v2(116.76,76.05) v2(116.83,74.65) v2(116.76,68.36) v2(117.01,77.41) v2(117.02,73.44) v2(117.02,72.17) v2(117.02,70.9) v2(117.08,69.44) v2(117.97,78.46) v2(122.34,80.29) v2(124.85,80.29) v2(127.36,80.29) v2(127.91,78.75) v2(129.86,80.29) v2(130.42,78.75) v2(132.37,80.29) v2(134.8,78.71) v2(134.88,80.29) v2(135.5,78.71) v2(137.24,80.26) v2(137.21,78.76) v3(94.32,60.19) v3(94.32,59.55) v3(94.32,58.92) v3(94.98,60.17) v3(94.98,59.54) v3(94.98,58.9) v3(95.22,65.84) v3(95.24,65.19) v3(95.24,64.55) v3(95.62,60.17) v3(95.62,59.54) v3(95.62,58.9) v3(95.86,65.86) v3(95.87,65.19) v3(95.87,64.55) v3(96.22,75.6) v3(96.22,72.28) v3(96.18,67.7) v3(96.25,60.17) v3(96.25,59.54) v3(96.25,58.9) v3(96.51,65.19) v3(96.51,64.55) v3(96.9,68.92) v3(96.89,60.17) v3(96.89,59.54) v3(97.14,65.19) v3(97.14,64.55) v3(97.52,60.17) v3(97.59,64.05) v3(97.59,63.41) v3(97.59,62.78) v3(97.59,62.14) v3(97.59,61.51) v3(97.59,60.87) v3(97.74,67.31) v3(98.02,75.6) v3(98.02,72.28) v3(98.68,68.92) v3(99.67,75.6) v3(99.67,72.28) v3(99.7,67.32) v3(100.36,68.92) v3(101.47,75.6) v3(101.47,72.28) v3(101.59,67.28) v3(102.13,68.92) v3(103.12,75.6) v3(103.12,72.28) v3(103.15,67.32) v3(103.76,68.92) v3(104.88,75.6) v3(104.88,72.28) v3(104.9,67.32) v3(105.54,68.92) v3(106.38,67.32) v3(106.53,75.6) v3(106.53,72.28) v5(96.19,61.38)
+VCC_PWR_SRC: length 20.4
  TOP w0.508: v2(91.66,67.25) 92.46,68.05 PR511.1
  IN4 w0.508: v2(79.68,60.38) 80.73,59.32 83.96,59.32 84.98,60.34 84.98,65.1 86.26,66.38 90.79,66.38 v2(91.66,67.25)
  vias: v1(79.31,63.37) v2(79.71,62.69) v2(79.71,62.08) v2(79.68,60.98)
+VCCIO_OUT: length 6.4
  BOTTOM w0.305: UC1.A59 115.37,83.1 113.67,84.81 113.67,85.61 v1(114.11,86.06) 114.11,86.49 114.48,86.85 114.48,87.16 114.67,87.35 RC242.1
+VCCIOA_OUT: length 6.4
  TOP w0.127: v1(136.35,77.14) 137.68,77.14 RC134.1
  TOP w0.508: v2(139.53,80.54) 139.15,80.54 138.42,79.81 138.42,77.88 RC134.1
  BOTTOM w0.254: v2(139.53,80.54) 139.7,80.54 140.05,80.2 UC1.E20
+VDDA_AVDD1: length 41.4
  TOP w0.127: v2(274.5,44.61) v1(274.5,45.64)
  TOP w0.254: U17.27 275.08,37.83 275.73,38.48 277.55,38.48 277.67,38.35 v2(277.67,38.38)
  TOP w0.508: v2(271.88,25.53) 270.55,24.19 L21.1 ; v2(274.5,44.61) 274.63,44.61 275.2,44.04 C117.1 275.2,43.85 275.72,43.33 C115.1
  IN2 w0.508: v2(274.5,44.61) 272.95,43.07 272.95,40.44 274.5,38.89 274.5,34.44 270.35,30.29 270.35,26.17 270.93,25.59 271.82,25.59 v2(271.88,25.53)
  IN4 w0.508: v2(277.67,38.38) 278.22,38.38 278.49,38.65 278.49,40.21 278.85,40.57 278.85,41.29 276.01,44.12 274.99,44.12 v2(274.5,44.61)
+VDDA_AVDD2: length 35.2
  TOP w0.102: v1(271.48,13.46) 271.2,13.74 v2(271.2,14.26)
  TOP w0.254: U17.38 269.39,36.07 268.76,36.7 v2(268.76,36.8)
  TOP w0.508: C116.1 267.93,39.79 C150.1 268.43,39.23 269.27,38.39 269.27,37.78 268.76,37.27 v2(268.76,36.8) ; R140.2 v2(271.2,14.26)
  IN1 w0.508: v2(271.2,14.26) 270.5,14.96 270.5,19.86 268.49,21.87 266.71,21.87 265.66,22.93 265.66,23.67 266.4,24.41 266.4,27.47 266.13,27.74 266.13,28.75 266.41,29.03 266.41,33.72 267.73,35.04 267.73,35.78 v2(268.76,36.8)
+VDDA_PVDD: length 7.7
  TOP w0.127: v1(265.14,33.88) 265.16,33.91 266.71,33.91
  TOP w0.254: U17.39 269.33,35.57 268.86,36.04 C129.1 ; U17.45 267.77,32.57 C123.1
  TOP w0.508: 266.71,33.91 267.12,33.5 267.12,33.22 C123.1
GND: length 3895
  TOP w0.127: v5(167.22,97.15) 166.92,97.46 C418.2 ; v2(60.38,72.58) 60.38,72.41 v5(59.8,71.84) ; CC50.2 133.74,88.54 v5(133.78,88.51)
  TOP w0.203: PU500.29 89.65,76.18 89.38,76.45 v2(89.38,76.68) ; PU11.1 115.01,8.44 v2(114.57,8.01) ; v2(269.73,18.77) 269.73,18.77 U18.11 ; 115.41,13.24 PU11.14 ; v2(165.91,103.35) 166.33,102.93 U33.28 ; PU11.3 115.81,7.94 v3(115.93,7.82) ; v2(203.14,38) 203.13,38.01 U22.11 ; PU500.19 92.97,72.84 v2(93.12,72.69) ; PU500.22 93.11,74.04 v2(93.17,73.99) ; v2(161.28,105.89) 161.47,105.7 161.85,105.7 161.94,105.61 U33.11 ; v2(187.96,69.67) 187.93,69.65 187.93,69.19 188.19,68.94 U46.11 ; v2(163.94,103.73) 163.54,103.33 U33.21 ; v2(203.21,27.74) 203.15,27.67 U3.11
  TOP w0.254: v4(193.73,81.22) 194.05,80.9 U6.G5 ; v4(193.73,81.22) U6.G4 ; v4(193.73,81.22) 193.41,81.55 U6.F4 193.73,81.87 ; v2(167.7,89.69) 167.7,89.46 168.14,89.03 U19.17 ; U6.L7 195.35,78.3 v4(195.03,77.97) 194.71,78.3 U6.L6 ; v2(273.88,29.14) 273.88,29.59 273.58,29.89 U17.7 ; C331.2 11.85,36.26 11.65,36.46 RP11.4 ; U6.F10 197.3,81.55 v4(196.98,81.87) U6.F9 ; U6.D11 197.95,82.85 v4(197.63,83.17) U6.D10 ; U36.6 76.77,81.9 76.57,81.7 76.21,81.7 75.9,82.01 v2(75.9,82.82) 75.92,82.84 U36.5 ; v2(229.29,85.24) 229.25,85.2 228.47,85.2 228.21,85.47 228.21,85.7 228.42,85.91 U49.7 ; U6.E11 v4(197.63,81.87) 197.95,81.55 U6.F11 ; U6.B13 199.26,84.15 v4(199.58,83.82) ; PU801.3 130.6,10.45 v2(131.24,9.82) 131.24,8.55 131.12,8.42 PC801.1 ; v2(13.35,40.82) 12.89,40.36 C337.2 ; U6.E4 193.41,82.2 193.73,81.87 ; v2(37.08,37.74) 37.27,37.55 U25.25 ; PU800.14 10.64,28.1 v2(10.74,28) ; PU700.14 55.13,8.41 v2(55.19,8.47) ; U6.J7 195.35,79.6 v4(195.03,79.92) U6.J6 ; v2(2.85,28.55) 3.29,28.1 PU800.32 ; U6.D6 v4(195.03,83.17) 195.35,82.85 U6.D7 ; v2(6.85,32.11) 6.78,32.04 PU800.23 ; v4(196.33,77.97) 196.01,78.3 U6.L8 ; UC6.7 79.67,74.07 v2(80.24,73.51) ; D15.3 211.13,94.91 211.22,94.81 v2(211.4,94.81) ; U6.F7 v4(195.68,81.87) 196,81.55 U6.F8 ; U6.D9 196.54,82.97 196.12,82.97 U6.D8 196,82.85 v4(195.68,83.17) ; U6.J12 v4(198.93,79.92) ; U6.F5 194.05,81.55 193.73,81.87 ; U6.F5 v4(194.38,81.87) 194.7,81.55 U6.F6 ; U6.F5 194.06,81.55 v4(194.38,81.22) 194.7,80.9 U6.G6 ; U6.J5 194.05,79.6 v4(193.73,79.92) 193.41,80.25 U6.H4 ; v2(176.95,89.32) 176.52,89.32 176.14,88.93 U19.1 ; U45.11 190.68,32.87 v2(190.68,32.87) ; U6.G10 v4(197.63,81.22) 197.95,80.9 U6.G11 ; v2(128.26,8.42) 128.32,8.48 128.32,9.05 128.62,9.36 PQ802.1 ; v2(267.21,4.38) 267.04,4.55 267.04,5.89 JSH1.10 ; U6.G7 v4(195.68,81.22) 196,80.9 U6.G8 ; U6.H10 197.31,80.25 v4(197.63,79.92) 197.95,79.6 U6.J11 ; v2(115.53,55.06) 115.18,55.41 RC125.2 ; v4(199.58,83.82) 199.9,83.5 U6.C14 ; v4(199.58,83.82) U6.B14 ; v4(199.58,83.82) U6.C13 v4(198.93,83.17) 199.25,82.85 U6.D13 U6.D14 ; U6.K5 v4(194.38,79.27) ; U6.D5 194.05,82.85 v4(193.73,83.17) U6.D4 ; D34.3 269.26,78.87 269.26,77.79 269.37,77.69 v2(269.37,77.7) ; CC15.1 140.8,56.85 v2(140.17,56.85) ; v2(77.46,94.14) D17.3 ; PQ819.1 141.85,4.07 v2(142.19,3.73) ; PU800.5 v2(6.78,24.17) ; U6.J9 196.65,79.6 v4(196.33,79.92) U6.J8 ; U6.C5 v4(194.38,83.82) ; U6.G9 v4(196.98,81.22)
  TOP w0.279: CC10.2 59.23,58.63 JXDP1.38 ; JXDP1.13 65.12,52.63 v2(64.63,53.12) ; JXDP1.37 65.72,58.63 65.27,59.09 v2(65.27,59.16) ; JXDP1.8 v2(59.61,51.13) ; v2(59.36,54.03) 59.47,54.13 JXDP1.20 ; JXDP1.7 68.3,51.13 v2(68.48,51.31) ; v2(59.61,50.39) 59.61,49.86 59.84,49.63 JXDP1.2 ; JXDP1.49 v2(65.2,61.63) ; JXDP1.31 65.14,57.13 64.72,56.72 v2(64.72,56.64) ; JXDP1.26 59.73,55.63 59.53,55.83 59.53,56.94 59.73,57.13 JXDP1.32 v2(62.69,57.13) ; JXDP1.25 65.21,55.63 v2(65.2,55.64) ; v2(59.61,51.82) 59.61,52.28 59.97,52.63 JXDP1.14 ; JXDP1.19 68.12,54.13 68.36,54.38 v2(68.36,55.61) ; v2(62.66,60.91) 62.66,61.18 62.2,61.63 JXDP1.50 ; v2(68.32,64.13) JXDP1.59 ; v2(68.48,49.63) JXDP1.1
  TOP w0.305: JUSH1.1 v2(183.26,4.76) ; U38.B18 29.58,10.58 29.9,10.26 v2(30.2,10.26) ; v2(20.76,14.67) 20.67,14.58 U38.B60 ; JSH1.2 263.04,6.74 v2(263.29,6.99) 263.53,6.75 JSH1.3 ; JKBTP1.1 197.45,5.58 197.29,5.42 v2(197.29,5.1) 197.58,5.1 197.95,5.47 JKBTP1.2 ; JAPS1.8 36.86,45.57 36.31,45.57 v2(36.12,45.38) 36.12,44.84 JAPS1.10 ; JUSH1.4 184.76,4.98 v2(184.91,4.83) ; JKBTP1.14 203.95,4.94 204.44,4.44 205.51,4.44 v2(205.96,4.89) ; JMEDIA.6 63.35,82.49 v2(63.86,83.01) ; v2(251.47,4.27) 251.31,4.27 250.96,4.61 JNFC1.7 ; JUSH1.19 192.26,6.64 v2(191.95,6.95) 191.76,6.75 JUSH1.18 ; v2(24.74,11.72) 24.88,11.72 25.69,10.91 U38.B11 ; v2(253.46,7.02) JNFC1.12 ; JKBTP1.8 200.95,6.99 v2(200.81,7.12) ; U38.B66 20.63,11.58 v2(20.88,11.33) ; v2(264.54,4.39) 264.53,4.4 JSH1.5 ; U38.B54 20.11,17.6 v2(20.75,17.6) ; JNFC1.1 247.96,4.12 v2(247.96,4.11) ; v2(34.98,44.81) JAPS1.12 35.8,43.4 35.8,43.1 35.2,42.77 35.01,42.77 JAPS1.14 ; JKBTP1.15 204.45,5.28 204.72,5 205.17,5 205.59,5.42 v2(205.59,5.82)
  TOP w0.318: U37.B27 24.27,35.02 v2(24.11,35.18)
  TOP w0.356: U52.1 229.55,83.98 229.76,84.18 229.76,84.52 229.29,84.99 v2(229.29,85.24)
  TOP w0.381: v2(100.64,89.74) 100.62,89.76 PQ710.4 ; PQ806.4 v2(123.86,6.56) ; v2(94.34,90.89) 94.34,91.77 94.16,91.95 93.87,91.95 93.72,91.8 PQ712.1 ; v2(138.84,5.97) 138.84,5.59 139.05,5.37 PQ819.4 ; U47.3 13.65,42.56 14.57,42.56 C328.2 ; Q17.1 148.19,98.94 147.83,98.58 v2(147.55,98.58) ; PU703.1 44.71,4.82 44.37,5.16 v2(44.37,5.35) 44.5,5.47 PU703.2 ; JMEDIA.7 66.85,84.86 v2(66.33,85.38) ; v2(179.02,9.09) 179.02,9.47 178.84,9.65 178.46,9.65 178.26,9.45 PQ812.4 ; PQ824.3 6.77,40.79 6.66,40.68 v2(6.21,40.68) ; v2(245.11,84.94) 245.59,84.94 245.82,84.71 245.82,84.45 245.66,84.29 U24.3 ; v2(96.8,91.1) 96.84,91.06 PQ710.1 ; v2(11.29,23.09) 11.29,22.43 11.04,22.17 11.04,21.81 10.48,21.25 C456.1 ; v2(251.73,27.9) 251.98,28.15 U26.3 ; PU3.3 102.14,90.27 v2(102.07,90.34) ; UC2.3 171.07,72.51 v2(170.8,72.24) ; PQ821.1 201.64,17.26 v2(201.27,17.63) ; U25.11 41.82,31.59 42.15,31.91 v2(42.15,32.23) ; U25.8 39.87,31.91 v2(39.61,32.17) ; PQ824.6 8.79,42.09 8.22,42.66 v2(8.13,42.66) ; PQ712.4 92.42,88.56 92.18,88.32 v2(92.18,87.82) ; U25.18 41.82,35.63 v2(41.33,35.14) ; PC812.1 132.26,5.12 v2(131.81,4.67) 131.74,4.59 PQ805.4 ; U5.3 126.81,22.7 126.87,22.64 ; v2(80.18,92.87) 80.25,92.95 PU111.2 ; UC4.3 107.73,95.21 107.56,95.03 107.56,94.53 108.06,94.02 v5(108.62,94.02) 109.14,94.02 v2(109.46,94.34) ; v2(125.5,10.31) 125.16,9.97 PQ806.1 ; v2(129.65,6.51) 129.65,6.28 129.27,5.89 PQ805.1 ; PQ821.4 v2(205.03,15.96)
  TOP w0.406: JKBTP1.17 196.45,2.96 196.32,2.83 195.77,2.83 v2(195.57,3.03) ; v2(246.81,71.55) 246.69,71.43 U20.3 ; UC7.3 69.31,73.43 v2(69.09,73.66) ; JSH1.14 v2(269.04,1.92) ; U30.3 192.38,40.51 192.99,41.12 195.52,41.12 ; PU807.3 v2(137.72,7.93) ; v2(192.99,2.93) 193.45,2.93 193.76,3.24 JUSH1.22 ; v2(41.9,12.51) 41.9,12.35 41.54,11.99 40.21,11.99 40.04,12.16 U42.3 ; U29.3 248.68,12.02 v2(248.82,11.89) ; JNFC1.16 246.96,3.02 v2(247.33,3.39) ; v2(173.96,56.39) 173.96,56.84 173.57,57.24 173.16,57.24 172.6,57.8 172.6,59.09 172.89,59.38 UC3.3 ; JSH1.13 261.53,1.95 v2(261.54,1.94) ; JNFC1.17 v2(255.96,1.68) ; PU806.3 139.65,11.61 v2(140.03,11.23) ; PU804.3 124.24,10.88 v2(124.59,11.23) ; JKBTP1.18 v2(205.95,1.97) ; PU805.3 v2(140.42,12.98) ; PU808.3 v2(208.3,6.82)
  TOP w0.432: C412.2 157.77,90.13 Q124.4 ; Q5.4 32.2,22.12 32.73,21.59 v2(33.13,21.59) ; Q124.1 160.04,92.2 v2(160.52,92.68) ; v2(63.86,83.01) 63.86,83.7 63.41,84.15 JMEDIA.8 ; JUSH1.21 v2(182.26,2.25) ; Q5.1 33.5,24.85 33.86,25.21 v2(33.86,25.31)
  TOP w0.457: v2(33.77,18.77) 33.33,18.77 33.06,19.04 C371.2 ; v2(148.65,52.11) 148.59,52.04 CC14.1 ; CC91.2 110.11,91.22 110.78,90.55 110.78,89.9 110.43,89.55 CC90.2 ; C229.2 250.69,17.07 v2(250.18,17.58) ; v2(250.24,18.16) 250.55,18.16 250.76,17.94 C219.1 ; C180.2 257.05,72.11 257.47,71.69 v2(257.84,71.69) ; v2(109.37,91.93) 109.37,92.33 109.78,92.73 CC22.2 ; v2(250.84,16.03) 250.8,15.99 C228.2 ; v2(55.37,16.71) 55.72,16.37 PC707.2
  TOP w0.508: v2(185.92,78.65) 185.92,78.49 185.76,78.33 Y1.4 ; C412.2 156.48,90.17 156.12,90.53 v2(156.12,90.84) ; C62.2 140.58,103.67 v2(140.01,104.24) ; C206.2 186.84,9.28 v2(187.24,9.68) ; v2(144.83,9.82) 144.37,10.27 PC808.1 ; v2(58.34,80.17) 58.27,80.1 R95.2 ; C207.2 187.76,9.31 v2(188.2,9.75) 188.65,9.31 C208.2 R195.1 ; PD2.1 v2(160.45,4.63) ; PR105.2 201.57,46.08 v2(201.75,45.9) ; C182.2 257.81,83.16 v2(257.48,82.83) ; v2(155.56,68.29) 155.6,68.33 CC36.2 ; PR15.2 54.13,18.47 53.95,18.29 v2(53.62,18.29) ; v2(150.4,87.38) 150.08,87.71 CC27.2 CC29.2 ; v2(248.51,10.4) 248.34,10.22 C1.2 ; v2(137.52,8.61) 137.31,8.81 PC810.1 ; R194.2 276.11,23.05 275.72,22.66 v2(275.72,22.59) ; v2(226.16,97.48) 227.51,97.48 C194.2 ; PC214.2 v2(122.17,5.68) ; v2(271.86,26.83) 271.41,27.28 C119.2 ; v2(74.88,20.11) 75.1,20.11 75.68,19.53 75.68,18.85 CD3.2 CD34.2 ; v2(11.63,34.52) 11.18,34.06 R320.1 ; v2(11.63,34.52) 11.85,34.73 C331.2 ; v2(11.63,34.52) 12.04,34.11 12.04,33.81 12.45,33.4 C330.2 ; JFAN1.6 44.92,53.6 v2(44.15,52.83) ; v2(211.28,84.76) 211.28,83.84 R312.2 ; RC159.2 141.72,66.87 v2(140.98,66.87) ; v2(257.02,13.61) 256.77,13.87 C232.1 ; PC100.1 197.73,43.29 v2(197.41,42.98) ; CD44.2 170.87,16.67 v2(170.55,16.36) ; v2(197.2,75.29) 197.2,74.53 197.57,74.15 C394.2 ; v2(10.39,17.03) 10.86,17.5 R384.2 ; v2(10.39,17.03) 10.87,16.55 C362.2 ; v2(10.39,17.03) 10.32,16.96 JSF1.1 ; C221.1 253.48,27.28 v2(253.62,27.42) ; PC514.1 87.99,80.28 v2(87.99,79.73) ; C355.2 15.84,17.18 v2(15.77,17.26) ; v2(189.64,74.98) 189.15,74.5 R63.2 ; v2(30.68,31.25) 30.67,31.25 29.76,31.25 R321.2 ; CC45.2 v2(141.78,73.68) 142.16,74.07 CC63.2 ; PQ817.3 144.18,12.63 v2(143.88,12.93) ; PR844.2 3.58,38.96 v2(3.06,38.44) ; C120.2 274.8,27.37 v2(274.8,26.86) ; PR742.2 96.8,83.74 PC729.2 v2(96.81,84.59) ; C349.2 19.1,6.24 19.36,5.98 v2(19.36,5.76) ; C422.2 205.35,28.61 v2(205.33,28.63) 205.24,28.71 204.93,28.71 204.1,29.54 C409.2 ; v2(280.2,7.77) 280.2,7.78 JSPK1.6 ; C128.2 266.52,37.19 v2(266.85,36.85) ; v2(137.77,28.15) 137.57,28.15 136.08,26.66 RC128.2 RC132.2 ; CD43.2 171.76,16.8 v2(172.2,16.36) ; R214.2 v2(251.13,21.03) ; v2(82.04,79.76) 81.62,80.17 PC9.2 82.84,80.48 PD6.2 ; C344.2 13.02,4.36 v2(12.88,4.22) 11.98,4.22 11.72,3.96 C342.2 ; C365.2 15.55,10.05 15.77,9.82 15.77,9.6 15.8,9.57 v2(15.8,9.56) ; CC59.2 139.17,75.48 v2(139.06,75.36) 138.87,75.17 CC31.2 ; v2(99.7,24.42) 98.98,25.14 CD5.2 ; v2(97.13,24.59) 96.95,24.76 CD21.2 ; PR308.1 240.86,76.31 v2(240.45,76.72) ; R303.1 R326.2 19.84,26.25 19.56,25.97 v2(19.56,25.12) ; Q29.3 185.75,96.44 185.47,96.72 v2(185.47,96.95) ; JTAG1.2 10.91,15.4 10.42,15.89 v2(10.4,15.89) ; PC728.1 97.82,87.78 97.37,87.34 v2(97.37,87.19) 97.37,86.63 PC727.2 ; v2(187.06,60.36) 186.58,59.88 PC116.2 ; 126.87,22.64 126.87,22.58 v2(127.46,22) ; JSF1.5 3.05,19.81 v2(4.09,20.85) 4.12,20.88 PC813.2 ; v2(237.31,91.21) 237.8,90.73 R167.2 ; C198.2 244.37,81.94 v2(244.78,82.35) ; PD1.1 163.31,6.76 v2(162.97,6.41) ; v2(50.76,41.88) 50.76,41.45 PR18.2 ; v2(166.7,23.9) 166.74,23.94 CD52.2 166.1,25.06 165.8,25.36 CD40.2 ; PR302.1 241.34,71.67 v2(241.5,71.83) ; PR114.1 192.01,48.17 192.27,48.42 v2(192.27,48.68) ; R366.1 25.07,23.41 v2(24.63,23.85) 24.18,23.41 C356.2 ; C407.2 204.14,39.92 v2(204.65,39.41) ; C403.2 190.41,71.22 190.41,72.48 v2(190.45,72.52) ; R342.1 14.59,23.35 v2(14.59,23.72) ; v2(147.66,55.88) RC50.2 ; v2(95.29,24.56) 95.24,24.61 CD7.2 ; C404.2 v2(9.23,38.77) ; v2(88.25,24.55) 87.81,24.99 CD10.2 ; R370.2 17.58,23.46 v2(17.32,23.71) ; CD27.2 123.75,26.23 v3(124.21,25.78) 124.49,25.5 CD23.2 123.7,25.06 CD26.2 ; v2(276.02,26.83) 276.02,26.1 R153.2 ; PC814.1 v2(211.43,2.09) ; v2(191.69,16.36) 191.64,16.31 C378.2 ; v3(200.93,25.68) 200.81,25.57 CD54.2 ; v2(219.09,95.54) 218.73,95.18 C281.2 ; R182.2 262.88,72.36 262.53,72.71 262.53,72.97 v2(262.46,73.05) ; v2(199.66,90.72) 199.63,90.69 R92.2 ; v2(86.16,24.42) 85.71,24.87 CD16.2 ; R37.1 252.93,9.13 v2(253.66,9.85) ; v2(18.45,21.56) C360.2 ; CC35.2 143.59,68.67 v2(143.59,69.19) ; v2(184.08,73.79) 184.16,73.87 Y1.2 ; v2(54.84,26.52) 54.94,26.62 54.94,27.19 RC221.2 ; RD11.2 197.28,25.27 v2(196.6,24.59) 197.85,23.34 CD59.2 ; CD56.2 CD57.2 200.67,18.2 v2(200.76,18.11) ; v2(121.08,14.39) 120.87,14.17 PC209.1 PC211.2 ; C328.2 14.61,41.72 14.38,41.49 v2(14.38,41.5) ; C26.2 190.07,90.46 v2(190.26,90.27) ; CD19.2 96.32,19.34 v2(96.51,19.53) ; R311.2 213,84.66 v2(213.46,85.11) ; R32.1 128.64,27.29 v2(128.49,27.14) ; v2(55,12.14) 55,12.52 PC709.2 ; C222.1 254.56,26.97 254.33,27.2 254.33,27.38 v2(254.28,27.43) ; C345.2 13.39,14.26 12.95,13.83 v2(12.95,13.83) ; v2(156.5,110.58) C414.2 ; CD32.2 133.09,24.54 v2(133.53,24.1) 133.98,24.56 CD33.2 ; C220.1 v2(251.7,13.37) ; CD53.2 156.2,30.44 v2(156.97,29.67) ; v2(161.72,16.42) 161.91,16.61 CD47.2 ; C262.2 209.58,22.3 210.08,22.81 v2(210.54,22.81) 210.76,22.59 C261.1 ; JMINI1.4 211.06,10 C259.2 210.73,10.32 v2(210.08,10.32) ; SW1.3 228.02,106.4 v2(227.79,106.17) ; v2(42.18,9.92) 42.18,9.31 41.59,8.72 C386.2 ; v2(170.8,72.24) 171.2,71.84 RC76.2 ; R47.2 204.97,79.03 v5(205.47,79.54) 205.6,79.54 206.03,79.97 v2(206.03,80.24) ; v2(270.64,73.15) v5(269.74,73.15) 268.68,73.15 C445.2 ; v2(247.52,16.93) 247.74,16.71 R493.2 C256.2 ; C426.2 200.23,40.36 v2(199.76,40.83) ; RC292.2 156.15,74.27 v2(156.58,74.7) ; v2(251.69,12.67) 252.32,12.04 C213.2 ; v2(30.23,37.22) 29.88,37.57 R307.1 29.54,37.58 R50.1 ; C419.2 166.6,100.29 v2(166.42,100.11) 166.6,99.94 C416.2 166.6,98.78 C418.2 ; C429.2 202.84,29.65 C428.2 201.9,30.63 v2(202.88,31.61) ; v2(82.03,19.6) CD8.2 ; v2(261.48,80.87) 261.54,80.87 262.68,79.73 Y3.4 ; v2(278.89,22.62) 279.48,22.03 C124.2 ; R474.2 204.39,97.23 205.51,98.35 v2(205.71,98.35) ; R373.1 R377.1 v2(38.34,24) ; v2(33.6,11.53) R369.1 32.88,11.54 C346.2 C352.2 ; v2(81.34,83.98) 81.34,83.4 80.97,83.03 C322.2 ; v2(165.15,16.36) 165.15,16.48 165.53,16.87 165.53,17.37 ; PC212.2 v2(117.78,5) ; C369.2 25.02,6.45 25.82,6.45 C351.2 25.9,6.07 25.59,5.77 v2(25.59,5.69) 25.59,5.36 25.91,5.04 C368.2 ; v2(141.47,69.13) 141.02,68.68 CC33.2 ; PC308.2 241.05,74.33 241.27,74.1 v2(241.5,74.1) ; C211.2 v2(249.99,26.07) ; v2(28.96,4.09) 28.63,4.42 C366.2 ; C144.2 266.23,42.09 v2(266.65,41.67) ; C316.2 144.75,108.1 145.02,108.37 v2(145.02,110.01) ; v2(274.97,22.61) 274.99,22.58 C126.2 ; C250.2 205.6,44.84 205.03,45.41 v2(205.03,45.72) ; R447.2 148.93,89.35 v2(148.76,89.52) ; C396.2 188.85,31.29 186.74,31.29 v2(186.61,31.42) ; PC726.2 PR735.2 v2(95.83,85.7) ; v2(50.29,62.97) 50.29,62.11 JFAN1.5 ; CC91.2 108.29,91.22 107.42,92.1 106.77,92.1 106.35,91.68 CC149.2 104.24,93 v2(104.24,93.14) ; C397.2 C398.2 188.53,33.45 188.03,33.95 v2(188.03,33.96) 187.69,33.96 187.36,34.29 187.36,34.9 187.73,35.27 C399.2 ; C152.2 C153.2 165.04,82.21 C151.2 163.38,81.64 v2(163.38,81.37) ; D18.1 73.97,94.98 73.25,95.69 v2(73.01,95.69) ; v2(274.17,22.55) 274.17,22.24 C127.2 ; v2(258.05,26.47) 257.92,26.59 C214.2 ; v2(108,87.35) 108.51,86.84 RC260.2 ; v2(38.1,16.41) 37.31,15.62 U41.2 ; C255.2 v2(262.62,21.69) ; PR102.1 200.13,44.17 v2(200.36,44.4) ; PC740.2 PC725.2 PC724.2 94.17,84.29 v2(94.36,84.48) ; v2(19,43.08) 18.58,42.66 R313.1 ; v2(198.89,10.46) 199.44,9.92 C374.2 ; JLED1.8 120.9,104.14 v2(120.8,104.24) ; v2(49.64,28.17) 50.34,27.47 RC195.2 ; v2(83.24,19.85) CD14.2 ; v2(29.67,9.49) 31.3,7.86 C455.1 ; PC106.2 PC108.2 v2(184.54,56.08) ; C225.1 248.73,23.53 v2(248.62,23.42) ; v2(192.42,87.83) 193.15,88.57 R207.2 ; v2(247.66,20.78) 248.16,20.28 C227.2 ; CC43.2 v2(141.91,72.62) ; v2(258.58,71.69) 258.43,71.84 C187.2 ; C43.2 188.46,75.21 v2(188.6,75.35) ; C129.2 266.27,35.61 C122.2 266.28,34.98 266.78,34.98 v2(266.94,35.14) ; v2(71.86,60.81) 71.86,61.34 70.86,62.33 CC48.2 ; C241.2 209.35,15.13 v2(209.82,15.6) ; v2(196.08,43.5) 195.91,43.66 195.91,43.94 PR104.1 ; CC38.2 141.86,68.63 142.23,69 v2(142.23,69.13) ; v2(85.14,77.09) 85.4,77.34 PC511.2 ; CD35.2 166.99,16.42 v2(166.93,16.36) ; SW1.1 v2(225.91,106.4) ; v2(154.31,91.77) 154.27,91.77 153.39,90.89 RC288.2 ; v2(154.36,10.01) 154.61,10.26 PC4.2 ; CD2.2 57.7,28.28 CD1.2 v2(56.95,28.27) ; C339.2 31.62,36.98 v2(31.88,37.24) ; C379.2 190.72,14.02 C380.2 190.47,13.78 v2(190.47,13.26) ; v2(119.64,28.29) 120.01,28.29 120.69,27.61 CD25.2 CD24.2 ; Q7.3 54.42,75.4 53.92,75.89 v2(53.77,75.89) ; C430.2 51.56,72.3 v2(51.02,71.75) ; R51.1 14.06,25.39 13.67,25.78 13.67,26.71 13.83,26.87 v2(13.83,27.15) 13.78,27.2 12.94,27.2 PC817.2 ; v2(271.22,17.65) C148.2 C147.2 ; C289.2 103.62,105.14 v2(104.18,105.7) ; PQ828.3 203.76,18.47 v2(204.74,18.47) ; CC61.2 142.61,89.26 v2(142.23,89.64) 142.38,89.64 142.86,90.12 CC49.2 ; RC180.2 121.49,109.29 v2(120.95,109.83) ; v2(270.87,5.69) 270.95,5.78 C50.2 ; v2(132.46,90.09) 132.5,90.13 CC50.2 ; R165.1 237.49,87.67 v2(237.49,87.07) ; v2(145.31,77.95) 144.5,77.14 CC74.2 ; v2(79.99,81.82) 79.93,81.82 79.16,81.05 RC131.1 ; v2(11.29,23.98) 11.67,24.36 PC816.2 ; C363.2 35.84,16.85 v2(35.92,16.93) ; D1.2 51.42,42.88 C7.2 50.1,42.7 v2(50.1,41.95) ; v2(159.75,16.42) 160.66,17.32 CD42.2 ; CC39.2 142.85,66.8 v2(142.74,66.91) ; v2(268.77,28.24) 268.78,28.24 269.44,27.58 C121.2 269.6,27.33 269.6,26.49 270.21,25.88 C130.2 ; v2(264.97,19.6) 264.72,19.85 C210.2 ; PQ831.3 v2(212.89,4.27) ; v2(269.8,85.19) 270.3,85.7 U50.2 ; v2(161.28,105.89) 160.58,106.59 C417.2 ; v2(83.81,93.13) 84.04,93.36 PD5.2 ; v2(111.37,99.03) 111.81,98.59 CC24.2 ; v2(255.18,27.29) 255.45,27.03 C212.2 ; v2(193.93,15.85) 193.93,16.17 C377.2 ; CC26.2 135.74,69.82 v2(136.12,70.21) ; C415.2 154.72,110.96 v2(154.61,110.85) ; v2(256.3,13.02) 255.75,13.02 255.38,13.39 C215.2 ; v2(231.45,96.4) 231.18,96.14 C192.2 ; PC815.2 v2(5.32,20.95) ; v2(59.82,84.48) R96.2 ; CC8.2 167.65,75.62 v2(167.45,75.82) 167.13,76.14 RC287.2 ; CD37.2 170.47,25.17 169.9,24.6 v2(169.9,24.26) 168.78,25.37 CD48.2 ; CC5.2 158.28,50.46 v2(158.86,51.04) ; Y3.2 v2(260.88,76.24) ; v2(262.14,26.63) 262.62,26.15 C231.1 ; v2(21.81,42.72) R309.1 ; C413.2 149.31,90.03 149.79,89.56 v2(150.04,89.56) ; R383.2 v2(33.58,15.98) C350.2 ; v2(117.72,28.29) 117.97,28.29 118.73,27.53 RD6.1 RD5.1 ; v2(207.62,81.94) 208.43,81.13 R351.2 ; CC28.2 141.85,71.22 142.1,71.48 v2(142.55,71.48) CC46.2 ; v2(85.11,96.76) 85.49,96.76 86.26,95.99 RC211.2 ; C226.1 v2(251,22.45) ; CC53.2 143.87,71.98 v2(143.42,71.54) CC54.2 ; CD13.2 CD12.2 115.82,18.64 v2(115.16,19.3) ; v2(139.24,70.92) 139.53,71.21 CC56.2 ; v2(53.25,52.98) 53.21,53.02 51.12,53.02 JFAN1.4 ; C189.1 C190.1 259.82,78.89 v2(259.83,78.9) ; CC81.2 132.64,68.68 v2(132.64,68.01) ; C200.2 40.23,39.23 v2(39.93,39.53) ; PC302.2 v3(231.32,73.38) ; v2(264.85,16.93) 265.07,17.16 C223.1 ; v2(11.29,23.09) 11.61,23.4 Q9.3 ; v2(201.41,52.93) 201.18,53.16 PC117.2 ; v2(50.22,11.48) 50.2,11.47 PC706.2 ; v2(139.37,89.58) 139.11,89.58 138.6,90.09 CC34.2 ; C185.2 251.45,70.87 v2(251.02,70.44) ; v2(54.85,66.94) 54.57,67.22 C64.2 54.13,67.73 54.57,68.17 R104.1 ; C247.2 273.77,5.8 C246.2 273.39,4.74 v2(273.39,2.65) ; C136.2 273.41,25.83 C135.2 272.54,25.82 272.54,25.44 v2(272.78,25.2) ; PC805.1 v2(127.76,11.26) ; v2(120.57,20.73) 121.16,21.31 CD31.2 ; v2(71.2,59.4) 71.2,59.4 70.93,59.66 CC11.2 ; C239.2 v2(247.52,18.06) ; C234.1 v2(261.66,14.06) ; C340.2 10.9,7.03 v2(10.9,7.03) 11.09,7.21 C343.2 ; R211.2 254.5,13.88 v2(253.87,13.26) ; C233.1 v2(258.12,13.14) ; v2(124.66,17.7) 124.66,18.11 124.21,18.57 CD30.2 ; v2(246.05,73.19) 246.32,73.46 C406.1 ; v2(140.73,76.21) 140.94,76.42 CC51.2 ; v2(176.33,24.29) 175.95,24.68 CD51.2 ; PR305.2 v2(237.03,76.75) ; PR814.1 198.63,15.07 v2(199.17,15.62) ; v2(257.02,29.76) 256.83,29.57 C341.1 ; CC32.2 144.88,69.06 v2(144.84,69.1) ; v2(124.21,15.92) 123.7,16.43 CD29.2 CD28.2 ; C411.2 234.35,91.78 v2(234.24,91.9) ; R168.1 271.44,88.61 270.76,87.93 C171.2 270.73,87.74 270.24,88.23 v2(270.03,88.23) ; PR858.2 6.08,32.8 v2(6.27,32.61) ; C68.2 68.14,77.3 68.57,77.74 68.58,77.74 v2(68.59,77.75) ; v2(73.03,67.72) Q4.3 ; v2(254.46,83.13) 254.17,83.43 C177.2 ; C348.2 15.81,7.28 v2(14.82,7.28) 14.82,6.82 C457.1 ; v2(250.5,83.13) 250.72,83.36 C183.2 ; CD36.2 169.6,17.02 v2(169.04,16.46) ; C216.1 253.42,14.54 v2(253.42,13.84) ; v2(145.64,105.16) 145.69,105.21 146.16,105.21 C61.2 ; v2(193.7,53.54) 193.9,53.34 PC118.2 ; CC9.2 169.32,57.66 v2(169.6,57.38) ; v2(123.02,56.82) 123.25,56.82 123.3,56.87 CC12.2 ; PC119.2 191.43,46 v2(190.68,45.25) ; C224.1 248.51,24.8 v2(248.41,24.9) ; v2(167.49,15.58) 167.18,15.28 PR817.2 ; C218.1 256.4,26.96 v2(256.78,27.34) ; CD15.2 89.14,19.09 v2(89.9,19.85) 90.54,19.21 CD20.2 ; v2(34.6,10.9) 34.33,11.16 C357.2 ; v2(201.94,10.1) 202.3,9.74 C375.2 C376.2 ; v2(68.62,69.8) 69.73,69.8 CC82.2 ; v2(206.33,51.87) 206.62,52.16 C252.2 ; v2(281.71,13.97) JSPK1.5 ; v2(10.29,9.27) 10.53,9.03 R399.1 ; v2(32.89,16.61) C350.2 ; C350.2 R371.1 ; v2(245.34,78.08) R184.2 ; v2(172.77,24.49) 172.01,25.25 CD49.2 ; JMINI2.53 214.09,37.45 216.04,35.5 JMINI1.54 ; PR209.1 v2(121.08,4.61) ; v2(185.38,67.45) 185.09,67.45 184.84,67.7 C400.2 ; C425.2 203.28,36.11 203.28,36.58 C427.2 204.31,37.25 v2(204.71,37.65) ; U9.2 51.65,70.32 v2(51.5,70.17) ; R271.2 C311.2 122.47,109.74 v2(122.35,109.85) ; v2(205.89,61.05) 206.03,60.91 206.67,60.91 C248.2 ; CC66.2 142.7,76.75 v2(143.24,76.2) ; v2(73.62,73.15) 73.62,73.25 74,73.63 CC41.2 ; v2(27.23,42.94) v5(27.75,43.46) 28.36,44.07 JAPS1.20 ; LED5.1 203.9,102.05 v2(203.69,102.26) ; v2(54.81,39.96) 55.14,39.63 PQ6.6 ; v2(250.75,14.16) 250.13,14.16 C388.1 ; PR12.1 86.98,87.93 v2(86.49,87.44) ; CC40.2 143.37,73.13 v2(143.12,73.38) 143.21,73.47 143.21,73.81 CC64.2 ; v2(89.71,68.17) 89.7,68.19 PR505.1 PC501.2 ; LED6.1 187.14,101.45 v2(187.24,101.55) ; v2(247.75,70.44) R25.2 248.68,71.05 C186.2 ; v2(87.33,93.87) 87.33,94.37 C67.2 ; CD6.2 v2(97.57,16.18) ; v2(146.91,75.07) 146.02,75.07 CC60.2 ; CD41.2 174.75,24.94 v2(174.3,24.49) 173.61,25.17 CD38.2 ; C287.2 71.03,84.54 v2(70.58,84.99) ; C354.2 29.58,23.74 29.41,23.91 v2(29.39,23.91) ; v2(271.12,69.06) 270.62,68.57 v5(270.62,68.55) 270.36,68.29 C141.2 270.35,67.3 C142.2 ; RC69.2 110.69,20.78 111.34,21.42 v2(111.5,21.42) ; R372.1 v2(33.58,14.2) R368.1 ; v2(139.19,69.25) 138.82,69.62 CC37.2 ; CD50.2 168.33,16.61 v2(168.07,16.36) ; v2(48.36,36.47) 49.09,35.75 PC11.2 50.2,35.85 PR16.2 ; CC52.2 129.29,68.57 v2(128.74,68.01) ; PR874.2 13.13,28.87 13.39,28.61 v2(13.64,28.61) ; R205.1 260.88,26.15 v2(261.15,26.42) ; PC215.2 v2(121.09,9.07) ; v2(30.71,29.97) 29.57,29.97 C332.2 R305.1 ; v2(260.59,80.75) R185.2 ; v2(93.4,19.52) 93.46,19.45 CD11.2 ; v2(114.91,109.81) 114.91,109.14 R120.1 ; C230.1 v2(265.61,26.01) ; v2(90.35,24.55) 90.03,24.87 CD17.2 ; CC65.2 139.37,53.5 138.89,53.03 v2(138.57,53.03) ; v2(193.27,43.69) 193.74,44.16 PR106.2 ; CD58.2 v2(201.3,19.34) ; R26.2 C338.2 195.69,41.76 v2(196.2,42.27) ; RC215.2 155.58,76.39 155.65,76.31 155.65,76.03 v2(155.66,76.02) 155.66,75.31 RC154.2 ; v2(268.06,20.43) 267.92,20.57 C188.2 ; CC68.2 57.47,61.94 57.2,62.2 56.57,62.2 56.31,61.95 56.31,61.12 56.6,60.83 v2(57.01,60.83) 57.01,60.59 57.43,60.17 CC10.2 ; C291.2 77.03,96.95 77.09,97.01 v2(77.09,98.09) ; C217.1 v2(265.15,18.96) ; CD18.2 92.25,24.68 v2(92.32,24.61) ; v2(242.24,95.61) 242.56,95.92 C321.2 C320.2 ; v2(89.33,87.88) 89.47,88.03 PQ3.3 ; v2(264.93,72.86) 264.93,72.85 v5(265.8,71.98) 265.91,71.87 265.91,68.82 PC1.2 ; PC733.2 47.28,6.77 v2(47.6,7.09) ; v3(200.91,26.31) 200.65,26.58 CD55.2 CD61.2 CD60.2 ; CD4.2 84.06,25.12 v2(84.7,24.49) ; v2(85.46,19.79) 85.08,19.41 CD9.2 ; v2(36.13,39.29) C384.2 ; RC83.2 v2(111.29,15.73) ; v2(120.77,99.26) 120.77,98.02 121.24,97.54 122.15,97.54 JLED1.7 ; R85.2 193.95,73.05 v2(193.37,72.47) ; RC210.2 168.57,61.45 v2(168.63,61.52) ; PQ825.3 135.99,4.06 v2(136.26,3.78) ; v2(33.24,10.31) 32.89,9.96 C367.2 R394.2 ; CD46.2 163.07,17.56 CD39.2 162.99,16.74 v2(162.61,16.36) ; v2(41.83,50.12) 41.53,50.42 JAPS1.19 ; C383.2 v2(270.97,82.35) ; R175.1 259.6,76.24 259.89,76.53 v2(259.89,77) ; v2(142.47,8.15) 142.46,8.15 142.04,8.57 PQ818.3 ; PC2.2 173.79,6.37 PC3.2 v2(173.29,4.77) ; C42.2 v2(189.41,78.03) ; v2(140.58,70.52) 140.06,70.52 CC44.2 ; v2(278.85,21.08) 278.57,21.36 C125.2 ; C240.2 v2(247.54,19.14) ; v2(271.5,16.42) C139.2 ; R27.2 v2(250.43,30.77) ; C387.2 36.6,18.64 v2(36.47,18.77) ; C180.2 255.92,72.11 C184.2 ; C420.2 v2(167.63,109.26)
  GND1 w0.203: 212.15,31.84 JMINI1.50 ; JMINI1.50 212.15,31.36 ; JMINI1.50 212.15,31.6 ; JUSB1.12 80.43,107.61 ; JUSB1.12 80.43,108.99 ; JUSB1.12 79.55,108.99 ; JUSB1.12 79.55,106.24 ; JUSB1.12 80.43,106.24 ; 153.46,3.04 PBATT1.9 ; PBATT1.9 154.94,3.04 ; PBATT1.9 154.2,3.28 ; PBATT1.9 153.22,2.3 ; PBATT1.9 153.46,1.56 ; PBATT1.9 154.2,1.32 ; PBATT1.9 155.18,2.3 ; PBATT1.9 154.94,1.56 ; 242.97,105.45 JLOM1.15 ; JLOM1.15 243.42,108.95 ; JLOM1.15 243.42,105.45 ; JDOCK1.152 127.25,100.62 ; JDOCK1.152 126.2,101.6 ; JDOCK1.152 127.25,101.6 ; JDOCK1.152 126.2,99.65 ; JDOCK1.152 127.25,99.65 ; JDOCK1.152 125.15,101.6 ; JDOCK1.152 125.15,99.65 ; JDOCK1.152 125.15,100.62 ; JMDP1.1 274.79,93.93 ; JMDP1.1 275.37,93.35 ; JMDP1.1 274.33,93.81 ; JMDP1.1 275.25,93.81 ; JMDP1.1 274.33,92.89 ; JMDP1.1 274.21,93.35 ; JMDP1.1 275.25,92.89 ; 154.64,99.68 JDOCK1.154 ; JDOCK1.154 158.76,99.68 ; JDOCK1.154 154.64,100.62 ; JDOCK1.154 158.76,101.57 ; JDOCK1.154 156.7,99.68 ; JDOCK1.154 156.7,101.57 ; JDOCK1.154 158.76,100.62 ; JUSB2.12 223.33,107.61 ; JUSB2.12 222.45,106.24 ; JUSB2.12 222.45,108.99 ; JUSB2.12 223.33,108.99 ; JUSB2.12 223.33,106.24 ; 62.97,107.61 JUSB1.13 ; JUSB1.13 63.85,108.99 ; JUSB1.13 63.85,106.24 ; JUSB1.13 62.97,106.24 ; JUSB1.13 62.97,108.99 ; 214.04,75.35 H13.1 ; H13.1 217.21,76.69 ; H13.1 215.87,73.52 ; H13.1 217.7,75.35 ; H13.1 215.87,77.18 ; H13.1 214.53,74.01 ; H13.1 214.53,76.69 ; H13.1 217.21,74.01 ; 207.95,32.22 H18.1 ; H18.1 207.95,35.88 ; H18.1 206.61,35.39 ; H18.1 209.78,34.05 ; H18.1 206.12,34.05 ; H18.1 209.29,32.71 ; H18.1 209.29,35.39 ; H18.1 206.61,32.71 ; JHDMI1.2 191.61,103.43 ; JHDMI1.2 190.69,102.51 ; JHDMI1.2 190.69,103.43 ; JHDMI1.2 190.57,102.97 ; JHDMI1.2 191.15,102.39 ; JHDMI1.2 191.61,102.51 ; JHDMI1.2 191.15,103.56 ; 211.79,67.25 JMINI2.54 ; JMINI2.54 213.45,68.06 ; JMINI2.54 215.11,68.06 ; JMINI2.54 211.79,68.06 ; JMINI2.54 215.11,67.25 ; 215.99,5.7 JMINI1.53 ; JMINI1.53 219.31,5.7 ; JMINI1.53 217.65,4.89 ; JMINI1.53 219.31,4.89 ; JMINI1.53 215.99,4.89 ; 273.13,92.11 JMDP1.7 ; JMDP1.7 274.17,91.65 ; JMDP1.7 273.59,91.07 ; JMDP1.7 273.13,91.19 ; JMDP1.7 274.05,92.11 ; JMDP1.7 273.01,91.65 ; JMDP1.7 274.05,91.19 ; 183.26,12.58 H2.1 ; H2.1 186.43,13.92 ; H2.1 184.6,12.09 ; H2.1 185.94,15.26 ; H2.1 185.94,12.58 ; H2.1 182.77,13.92 ; H2.1 184.6,15.75 ; H2.1 183.26,15.26 ; JDOCK1.159 107.7,109.42 ; JDOCK1.159 105.64,109.42 ; JDOCK1.159 105.64,107.53 ; JDOCK1.159 109.76,109.42 ; JDOCK1.159 107.7,107.53 ; JDOCK1.159 109.76,108.48 ; JDOCK1.159 105.64,108.48 ; JHDMI1.11 196.11,103.71 ; JHDMI1.11 195.65,103.59 ; JHDMI1.11 195.65,104.75 ; JHDMI1.11 196.11,104.63 ; JHDMI1.11 195.19,103.71 ; JHDMI1.11 195.19,104.63 ; 101.44,85.43 H10.1 ; H10.1 104.56,85.43 ; H10.1 104.56,82.31 ; H10.1 101.44,82.31 ; H10.1 100.86,83.87 ; H10.1 103,81.74 ; H10.1 103,86 ; H10.1 105.13,83.87 ; 125.15,109.45 JDOCK1.160 ; JDOCK1.160 126.2,107.5 ; JDOCK1.160 125.15,107.5 ; JDOCK1.160 127.25,107.5 ; JDOCK1.160 127.25,108.48 ; JDOCK1.160 126.2,109.45 ; JDOCK1.160 127.25,109.45 ; JDOCK1.160 125.15,108.48 ; 156.7,107.53 JDOCK1.162 ; JDOCK1.162 158.76,108.48 ; JDOCK1.162 156.7,109.42 ; JDOCK1.162 154.64,109.42 ; JDOCK1.162 158.76,109.42 ; JDOCK1.162 154.64,108.48 ; JDOCK1.162 158.76,107.53 ; 150.1,4.43 PBATT1.10 ; PBATT1.10 151.08,0.67 ; PBATT1.10 152.05,2.55 ; PBATT1.10 150.1,0.67 ; PBATT1.10 151.08,4.43 ; PBATT1.10 152.05,4.43 ; PBATT1.10 150.1,2.55 ; PBATT1.10 152.05,0.67 ; 71.16,99.11 JUSB1.7 ; JUSB1.7 72.39,99.64 ; JUSB1.7 71.7,98.96 ; JUSB1.7 72.24,99.11 ; JUSB1.7 71.01,99.64 ; 274.33,88.41 JMDP1.19 ; JMDP1.19 275.25,87.49 ; JMDP1.19 274.21,87.95 ; JMDP1.19 275.37,87.95 ; JMDP1.19 275.25,88.41 ; JMDP1.19 274.33,87.49 ; JMDP1.19 274.79,87.37 ; JDOCK1.148 158.29,106.4 ; JDOCK1.148 157.37,102.7 ; JDOCK1.148 158.29,104.55 ; JDOCK1.148 157.37,106.4 ; JDOCK1.148 158.29,102.7 ; JDOCK1.153 139.25,100.62 ; JDOCK1.153 138.2,101.6 ; JDOCK1.153 137.15,100.62 ; JDOCK1.153 139.25,99.65 ; JDOCK1.153 137.15,101.6 ; JDOCK1.153 137.15,99.65 ; JDOCK1.153 139.25,101.6 ; JDOCK1.153 138.2,99.65 ; JLOM1.14 263.39,105.45 ; JLOM1.14 263.39,108.95 ; JLOM1.14 262.47,105.45 ; JLOM1.14 262.47,108.95 ; JLOM1.14 263.39,107.2 ; 43.36,43.87 H15.1 ; H15.1 46.53,42.53 ; H15.1 42.87,42.53 ; H15.1 46.04,43.87 ; H15.1 44.7,44.36 ; H15.1 46.04,41.19 ; H15.1 43.36,41.19 ; H15.1 44.7,40.7 ; H4.1 81.54,3.71 ; H4.1 81.54,6.39 ; H4.1 80.2,3.22 ; H4.1 78.37,5.05 ; H4.1 80.2,6.88 ; H4.1 78.86,6.39 ; H4.1 78.86,3.71 ; H4.1 82.03,5.05 ; JMDP1.13 274.17,89.65 ; JMDP1.13 273.59,90.23 ; JMDP1.13 273.01,89.65 ; JMDP1.13 273.13,89.19 ; JMDP1.13 274.05,90.11 ; JMDP1.13 274.05,89.19 ; 212.15,22.24 JMINI1.26 ; JMINI1.26 212.15,22 ; JMINI1.26 212.15,21.76 ; 272.4,76.32 JUSB3.7 ; JUSB3.7 272.97,75.01 ; JUSB3.7 272.4,75.18 ; JUSB3.7 272.97,76.49 ; JUSB3.7 273.54,75.18 ; JUSB3.7 273.54,76.32 ; JUSB3.7 272.23,75.75 ; JHDMI1.17 199.11,104.63 ; JHDMI1.17 199.11,103.71 ; JHDMI1.17 198.65,104.75 ; JHDMI1.17 198.19,103.71 ; JHDMI1.17 198.65,103.59 ; JHDMI1.17 198.19,104.63 ; 206.97,100.39 JUSB2.11 ; JUSB2.11 207.85,96.84 ; JUSB2.11 208.73,98.61 ; JUSB2.11 206.97,98.61 ; JUSB2.11 208.73,96.84 ; JUSB2.11 206.97,96.84 ; 225.61,110.55 H5.1 ; H5.1 226.03,109.38 ; H5.1 228.37,109.38 ; H5.1 228.79,110.55 ; H5.1 227.2,112.14 ; H5.1 228.37,111.72 ; H5.1 227.2,108.96 ; H5.1 226.03,111.72 ; JUSB3.11 275.68,84.48 ; JUSB3.11 273.9,84.48 ; JUSB3.11 272.12,83.6 ; JUSB3.11 275.68,83.6 ; JUSB3.11 272.12,82.72 ; 212.15,25.2 JMINI1.34 ; JMINI1.34 212.15,25.44 ; JMINI1.34 212.15,24.96 ; 276.44,95.37 JMDP1.23 ; JMDP1.23 276.44,96.15 ; JMDP1.23 276.44,96.93 ; JMDP1.23 279.06,96.93 ; JMDP1.23 279.06,96.15 ; JMDP1.23 277.75,96.93 ; 271.44,85.93 JMDP1.22 ; JMDP1.22 272.75,85.93 ; JMDP1.22 271.44,84.37 ; JMDP1.22 274.06,85.15 ; JMDP1.22 271.44,85.15 ; 279.36,83.6 JUSB3.12 ; JUSB3.12 280.7,84.48 ; JUSB3.12 279.36,84.48 ; JUSB3.12 282.03,84.48 ; JUSB3.12 282.03,83.6 ; 192.19,103.71 JHDMI1.5 ; JHDMI1.5 192.65,104.75 ; JHDMI1.5 193.11,104.63 ; JHDMI1.5 192.19,104.63 ; JHDMI1.5 193.11,103.71 ; JHDMI1.5 192.65,103.59 ; JUSB2.4 211.79,98.14 ; JUSB2.4 211.64,98.68 ; JUSB2.4 211.64,97.61 ; JUSB2.4 210.56,98.68 ; JUSB2.4 210.56,97.61 ; JUSB2.4 210.41,98.14 ; JUSB2.4 211.1,98.83 ; JUSB2.4 211.1,97.46 ; 144.82,4.94 H16.1 ; H16.1 145.31,3.6 ; H16.1 147.99,3.6 ; H16.1 146.65,6.77 ; H16.1 147.99,6.28 ; H16.1 148.48,4.94 ; H16.1 145.31,6.28 ; H16.1 146.65,3.11 ; 207.95,41.51 JMINI2.4 ; JMINI2.4 207.95,41.75 ; JMINI2.4 207.95,41.99 ; H8.1 158.32,86 ; H8.1 156.76,85.43 ; H8.1 159.88,82.31 ; H8.1 159.88,85.43 ; H8.1 156.76,82.31 ; H8.1 156.19,83.87 ; H8.1 158.32,81.74 ; H8.1 160.46,83.87 ; 156.19,61.73 H11.1 ; H11.1 159.88,63.29 ; H11.1 156.76,63.29 ; H11.1 159.88,60.17 ; H11.1 160.46,61.73 ; H11.1 158.32,59.6 ; H11.1 156.76,60.17 ; H11.1 158.32,63.86 ; 137.15,108.48 JDOCK1.161 ; JDOCK1.161 139.25,108.48 ; JDOCK1.161 139.25,109.45 ; JDOCK1.161 138.2,109.45 ; JDOCK1.161 138.2,107.5 ; JDOCK1.161 137.15,109.45 ; JDOCK1.161 139.25,107.5 ; JDOCK1.161 137.15,107.5 ; JUSB3.4 272.04,79.82 ; JUSB3.4 272.2,79.25 ; JUSB3.4 270.9,79.82 ; JUSB3.4 270.9,78.68 ; JUSB3.4 271.47,78.51 ; JUSB3.4 270.73,79.25 ; JUSB3.4 271.47,79.99 ; JUSB3.4 272.04,78.68 ; 265.37,92.15 H17.1 ; H17.1 269.03,92.15 ; H17.1 265.86,93.49 ; H17.1 268.54,90.81 ; H17.1 265.86,90.81 ; H17.1 267.2,93.98 ; H17.1 267.2,90.32 ; H17.1 268.54,93.49 ; 204.4,108.78 JHDMI1.23 ; JHDMI1.23 204.4,111.72 ; JHDMI1.23 205.28,111.72 ; JHDMI1.23 203.52,110.25 ; JHDMI1.23 205.28,108.78 ; JHDMI1.23 205.28,110.25 ; JHDMI1.23 203.52,108.78 ; JHDMI1.23 203.52,111.72 ; JUSB1.4 68.2,98.83 ; JUSB1.4 68.2,97.46 ; JUSB1.4 67.66,98.68 ; JUSB1.4 68.74,98.68 ; JUSB1.4 68.89,98.14 ; JUSB1.4 68.74,97.61 ; JUSB1.4 67.66,97.61 ; JUSB1.4 67.51,98.14 ; 138.2,103.5 JDOCK1.157 ; JDOCK1.157 137.15,104.55 ; JDOCK1.157 139,105.35 ; JDOCK1.157 137.4,103.75 ; JDOCK1.157 139.25,104.55 ; JDOCK1.157 139,103.75 ; JDOCK1.157 138.2,105.6 ; JDOCK1.157 137.4,105.35 ; H1.1 52.31,85.15 ; H1.1 48.65,85.15 ; H1.1 51.82,83.81 ; H1.1 49.14,83.81 ; H1.1 49.14,86.49 ; H1.1 50.48,83.32 ; H1.1 51.82,86.49 ; H1.1 50.48,86.98 ; 193.69,103.43 JHDMI1.8 ; JHDMI1.8 194.61,103.43 ; JHDMI1.8 193.69,102.51 ; JHDMI1.8 194.61,102.51 ; JHDMI1.8 194.15,102.39 ; JHDMI1.8 194.15,103.56 ; 185.02,110.25 JHDMI1.22 ; JHDMI1.22 185.9,111.72 ; JHDMI1.22 186.78,108.78 ; JHDMI1.22 185.02,111.72 ; JHDMI1.22 186.78,111.72 ; JHDMI1.22 185.9,108.78 ; JHDMI1.22 185.02,108.78 ; JHDMI1.22 186.78,110.25 ; 207.95,56.95 JMINI2.34 ; JMINI2.34 207.95,57.19 ; JMINI2.34 207.95,56.71 ; 205.87,108.99 JUSB2.13 ; JUSB2.13 206.75,106.24 ; JUSB2.13 206.75,108.99 ; JUSB2.13 205.87,107.61 ; JUSB2.13 205.87,106.24 ; ST2.1 173.34,62.31 ; ST2.1 170.66,64.99 ; ST2.1 173.34,64.99 ; ST2.1 170.17,63.65 ; ST2.1 172,65.48 ; ST2.1 172,61.82 ; ST2.1 170.66,62.31 ; ST2.1 173.83,63.65 ; PBATT1.11 174.3,2.55 ; PBATT1.11 172.35,2.55 ; PBATT1.11 174.3,0.67 ; PBATT1.11 173.33,4.43 ; PBATT1.11 172.35,0.67 ; PBATT1.11 174.3,4.43 ; PBATT1.11 173.33,0.67 ; PBATT1.11 172.35,4.43 ; JHDMI1.21 203.28,101.83 ; JHDMI1.21 201.52,104.98 ; JHDMI1.21 203.28,103.4 ; JHDMI1.21 203.28,104.98 ; JHDMI1.21 202.4,104.98 ; JHDMI1.21 201.52,101.83 ; JHDMI1.21 201.52,103.4 ; JHDMI1.21 202.4,101.83 ; JDOCK1.151 109.76,100.62 ; JDOCK1.151 109.76,99.68 ; JDOCK1.151 105.64,99.68 ; JDOCK1.151 107.7,101.57 ; JDOCK1.151 105.64,100.62 ; JDOCK1.151 105.64,101.57 ; JDOCK1.151 107.7,99.68 ; JDOCK1.156 127,103.75 ; JDOCK1.156 125.15,104.55 ; JDOCK1.156 127.25,104.55 ; JDOCK1.156 125.4,103.75 ; JDOCK1.156 126.2,105.6 ; JDOCK1.156 126.2,103.5 ; JDOCK1.156 125.4,105.35 ; JDOCK1.156 127,105.35 ; 207.95,63.59 JMINI2.50 ; JMINI2.50 207.95,63.11 ; JMINI2.50 207.95,63.35 ; 278.86,0.81 H3.1 ; H3.1 281.54,0.81 ; H3.1 278.37,2.15 ; H3.1 282.03,2.15 ; H3.1 278.86,3.49 ; H3.1 280.2,3.98 ; H3.1 281.54,3.49 ; 64.07,96.84 JUSB1.11 ; JUSB1.11 64.95,96.84 ; JUSB1.11 65.83,98.61 ; JUSB1.11 64.07,98.61 ; JUSB1.11 64.07,100.39 ; JUSB1.11 65.83,96.84 ; 156.2,1.32 PBATT1.8 ; PBATT1.8 155.22,2.3 ; PBATT1.8 155.46,3.04 ; PBATT1.8 155.46,1.56 ; PBATT1.8 156.94,3.04 ; PBATT1.8 156.2,3.28 ; PBATT1.8 156.94,1.56 ; JUSB1.10 79.33,96.84 ; JUSB1.10 77.57,96.84 ; JUSB1.10 78.45,96.84 ; JUSB1.10 77.57,98.61 ; JUSB1.10 79.33,100.39 ; 213.1,18.32 JMINI1.18 ; JMINI1.18 212.15,18.32 ; JMINI1.18 212.15,18.8 ; 207.95,50.55 JMINI2.18 ; JMINI2.18 207.95,50.07 ; JMINI2.18 208.9,50.07 ; 276.44,84.37 JMDP1.21 ; JMDP1.21 277.75,84.37 ; JMDP1.21 279.06,84.37 ; JMDP1.21 279.06,85.15 ; JMDP1.21 276.44,85.15 ; JMDP1.21 276.44,85.93 ; 49.2,79.51 H14.1 ; H14.1 50.3,82.1 ; H14.1 50.69,81 ; H14.1 47.71,81 ; H14.1 48.1,82.1 ; H14.1 49.2,82.49 ; H14.1 50.3,79.9 ; H14.1 48.1,79.9 ; JHDMI1.20 188.78,101.83 ; JHDMI1.20 187.9,101.83 ; JHDMI1.20 188.78,104.98 ; JHDMI1.20 187.02,101.83 ; JHDMI1.20 187.9,104.98 ; JHDMI1.20 187.02,104.98 ; JHDMI1.20 187.02,103.4 ; JHDMI1.20 188.78,103.4 ; 103,59.6 H9.1 ; H9.1 104.56,60.17 ; H9.1 103,63.86 ; H9.1 101.44,63.29 ; H9.1 105.13,61.73 ; H9.1 101.44,60.17 ; H9.1 104.56,63.29 ; H9.1 100.86,61.73 ; 220.47,96.84 JUSB2.10 ; JUSB2.10 222.23,98.61 ; JUSB2.10 221.35,96.84 ; JUSB2.10 220.47,98.61 ; JUSB2.10 222.23,96.84 ; JUSB2.10 222.23,100.39 ; 107.02,102.7 JDOCK1.145 ; JDOCK1.145 107.02,106.4 ; JDOCK1.145 106.11,106.4 ; JDOCK1.145 106.11,104.55 ; 213.91,99.64 JUSB2.7 ; JUSB2.7 214.6,98.96 ; JUSB2.7 215.14,99.11 ; JUSB2.7 214.06,99.11 ; JUSB2.7 215.29,99.64 ; 207.95,53.99 JMINI2.26 ; JMINI2.26 207.95,53.51 ; JMINI2.26 207.95,53.75 ; JDOCK1.158 151,103.75 ; JDOCK1.158 151,105.35 ; JDOCK1.158 149.4,105.35 ; JDOCK1.158 150.2,105.6 ; JDOCK1.158 151.25,104.55 ; JDOCK1.158 149.15,104.55 ; JDOCK1.158 149.4,103.75 ; JDOCK1.158 150.2,103.5 ; 113.4,103.75 JDOCK1.155 ; JDOCK1.155 113.15,104.55 ; JDOCK1.155 114.2,103.5 ; JDOCK1.155 115,105.35 ; JDOCK1.155 115,103.75 ; JDOCK1.155 115.25,104.55 ; JDOCK1.155 114.2,105.6 ; JDOCK1.155 113.4,105.35 ; 211.79,37.45 JMINI2.53 ; JMINI2.53 213.45,36.64 ; JMINI2.53 211.79,36.64 ; JMINI2.53 215.11,36.64 ; JMINI2.53 215.11,37.45 ; 271.44,96.93 JMDP1.24 ; JMDP1.24 274.06,96.15 ; JMDP1.24 271.44,96.15 ; JMDP1.24 274.06,96.93 ; JMDP1.24 272.75,95.37 ; JMDP1.24 271.44,95.37 ; JMDP1.24 272.75,96.93 ; JUSB3.10 275.68,68.34 ; JUSB3.10 272.12,68.34 ; JUSB3.10 272.12,68.78 ; 212.15,10 JMINI1.4 ; JMINI1.4 212.15,10.24 ; JMINI1.4 212.15,9.76 ; 159.46,1.56 PBATT1.6 ; PBATT1.6 159.46,3.04 ; PBATT1.6 160.94,3.04 ; PBATT1.6 160.2,3.28 ; PBATT1.6 160.94,1.56 ; PBATT1.6 160.2,1.32
  GND2 w0.203: H3.1 280.2,3.98 ; H3.1 281.54,3.49 ; H3.1 278.37,2.15 ; H3.1 278.86,3.49 ; H3.1 278.86,0.81 ; H3.1 282.03,2.15 ; H3.1 281.54,0.81 ; H5.1 228.79,110.55 ; H5.1 228.37,109.38 ; H5.1 227.2,108.96 ; H5.1 225.61,110.55 ; H5.1 226.03,111.72 ; H5.1 228.37,111.72 ; H5.1 227.2,112.14 ; H5.1 226.03,109.38 ; JMDP1.23 277.75,96.93 ; JMDP1.23 276.44,96.15 ; JMDP1.23 279.06,96.15 ; JMDP1.23 276.44,96.93 ; JMDP1.23 279.06,96.93 ; JMDP1.23 276.44,95.37 ; 101.44,63.29 H9.1 ; H9.1 101.44,60.17 ; H9.1 104.56,60.17 ; H9.1 103,63.86 ; H9.1 105.13,61.73 ; H9.1 104.56,63.29 ; H9.1 103,59.6 ; H9.1 100.86,61.73 ; 203.52,108.78 JHDMI1.23 ; JHDMI1.23 205.28,111.72 ; JHDMI1.23 205.28,110.25 ; JHDMI1.23 204.4,111.72 ; JHDMI1.23 203.52,110.25 ; JHDMI1.23 205.28,108.78 ; JHDMI1.23 203.52,111.72 ; JHDMI1.23 204.4,108.78 ; 49.14,83.81 H1.1 ; H1.1 51.82,86.49 ; H1.1 48.65,85.15 ; H1.1 52.31,85.15 ; H1.1 51.82,83.81 ; H1.1 50.48,86.98 ; H1.1 49.14,86.49 ; H1.1 50.48,83.32 ; JMINI2.54 215.11,68.06 ; JMINI2.54 213.45,68.06 ; JMINI2.54 211.79,67.25 ; JMINI2.54 215.11,67.25 ; JMINI2.54 211.79,68.06 ; 205.87,106.24 JUSB2.13 ; JUSB2.13 205.87,107.61 ; JUSB2.13 206.75,108.99 ; JUSB2.13 206.75,106.24 ; JUSB2.13 205.87,108.99 ; 274.79,87.37 JMDP1.19 ; JMDP1.19 275.25,88.41 ; JMDP1.19 274.33,88.41 ; JMDP1.19 274.21,87.95 ; JMDP1.19 274.33,87.49 ; JMDP1.19 275.25,87.49 ; JMDP1.19 275.37,87.95 ; PBATT1.11 173.33,4.43 ; PBATT1.11 173.33,0.67 ; PBATT1.11 174.3,0.67 ; PBATT1.11 172.35,0.67 ; PBATT1.11 174.3,4.43 ; PBATT1.11 172.35,2.55 ; PBATT1.11 172.35,4.43 ; PBATT1.11 174.3,2.55 ; JHDMI1.8 194.61,102.51 ; JHDMI1.8 193.69,102.51 ; JHDMI1.8 194.15,103.56 ; JHDMI1.8 194.15,102.39 ; JHDMI1.8 194.61,103.43 ; JHDMI1.8 193.69,103.43 ; JDOCK1.158 151,105.35 ; JDOCK1.158 151,103.75 ; JDOCK1.158 149.15,104.55 ; JDOCK1.158 149.4,103.75 ; JDOCK1.158 149.4,105.35 ; JDOCK1.158 151.25,104.55 ; JDOCK1.158 150.2,103.5 ; JDOCK1.158 150.2,105.6 ; 138.2,103.5 JDOCK1.157 ; JDOCK1.157 139,105.35 ; JDOCK1.157 137.4,105.35 ; JDOCK1.157 139.25,104.55 ; JDOCK1.157 137.15,104.55 ; JDOCK1.157 139,103.75 ; JDOCK1.157 137.4,103.75 ; JDOCK1.157 138.2,105.6 ; 153.46,3.04 PBATT1.9 ; PBATT1.9 153.46,1.56 ; PBATT1.9 154.94,3.04 ; PBATT1.9 154.94,1.56 ; PBATT1.9 154.2,1.32 ; PBATT1.9 153.22,2.3 ; PBATT1.9 154.2,3.28 ; PBATT1.9 155.18,2.3 ; 155.46,1.56 PBATT1.8 ; PBATT1.8 156.94,1.56 ; PBATT1.8 156.94,3.04 ; PBATT1.8 155.22,2.3 ; PBATT1.8 156.2,1.32 ; PBATT1.8 156.2,3.28 ; PBATT1.8 155.46,3.04 ; ST2.1 173.34,64.99 ; ST2.1 170.17,63.65 ; ST2.1 173.34,62.31 ; ST2.1 172,65.48 ; ST2.1 173.83,63.65 ; ST2.1 172,61.82 ; ST2.1 170.66,64.99 ; ST2.1 170.66,62.31 ; 101.44,82.31 H10.1 ; H10.1 104.56,85.43 ; H10.1 101.44,85.43 ; H10.1 103,86 ; H10.1 105.13,83.87 ; H10.1 104.56,82.31 ; H10.1 103,81.74 ; H10.1 100.86,83.87 ; 206.12,34.05 H18.1 ; H18.1 209.78,34.05 ; H18.1 206.61,32.71 ; H18.1 209.29,32.71 ; H18.1 209.29,35.39 ; H18.1 207.95,32.22 ; H18.1 207.95,35.88 ; H18.1 206.61,35.39 ; 154.64,109.42 JDOCK1.162 ; JDOCK1.162 156.7,107.53 ; JDOCK1.162 158.76,107.53 ; JDOCK1.162 158.76,108.48 ; JDOCK1.162 154.64,108.48 ; JDOCK1.162 156.7,109.42 ; JDOCK1.162 158.76,109.42 ; 212.15,25.44 JMINI1.34 ; JMINI1.34 212.15,24.96 ; JMINI1.34 212.15,25.2 ; 220.47,96.84 JUSB2.10 ; JUSB2.10 222.23,100.39 ; JUSB2.10 222.23,98.61 ; JUSB2.10 222.23,96.84 ; JUSB2.10 221.35,96.84 ; JUSB2.10 220.47,98.61 ; 198.19,103.71 JHDMI1.17 ; JHDMI1.17 199.11,104.63 ; JHDMI1.17 198.65,104.75 ; JHDMI1.17 198.19,104.63 ; JHDMI1.17 199.11,103.71 ; JHDMI1.17 198.65,103.59 ; 48.1,79.9 H14.1 ; H14.1 50.69,81 ; H14.1 50.3,82.1 ; H14.1 48.1,82.1 ; H14.1 47.71,81 ; H14.1 50.3,79.9 ; H14.1 49.2,79.51 ; H14.1 49.2,82.49 ; 207.95,50.07 JMINI2.18 ; JMINI2.18 207.95,50.55 ; JMINI2.18 208.9,50.07 ; 206.97,96.84 JUSB2.11 ; JUSB2.11 208.73,96.84 ; JUSB2.11 207.85,96.84 ; JUSB2.11 206.97,98.61 ; JUSB2.11 208.73,98.61 ; JUSB2.11 206.97,100.39 ; PBATT1.10 152.05,0.67 ; PBATT1.10 150.1,0.67 ; PBATT1.10 150.1,4.43 ; PBATT1.10 151.08,0.67 ; PBATT1.10 152.05,2.55 ; PBATT1.10 150.1,2.55 ; PBATT1.10 151.08,4.43 ; PBATT1.10 152.05,4.43 ; H17.1 268.54,90.81 ; H17.1 267.2,90.32 ; H17.1 265.37,92.15 ; H17.1 265.86,93.49 ; H17.1 265.86,90.81 ; H17.1 267.2,93.98 ; H17.1 269.03,92.15 ; H17.1 268.54,93.49 ; JDOCK1.153 139.25,99.65 ; JDOCK1.153 137.15,101.6 ; JDOCK1.153 139.25,101.6 ; JDOCK1.153 137.15,99.65 ; JDOCK1.153 138.2,101.6 ; JDOCK1.153 139.25,100.62 ; JDOCK1.153 138.2,99.65 ; JDOCK1.153 137.15,100.62 ; JUSB3.10 275.68,67.9 ; JUSB3.10 275.68,67.02 ; JUSB3.10 272.12,68.78 ; JUSB3.10 273.9,67.02 ; JUSB3.10 272.12,67.02 ; JUSB3.10 272.12,67.9 ; JDOCK1.160 126.2,109.45 ; JDOCK1.160 127.25,109.45 ; JDOCK1.160 127.25,107.5 ; JDOCK1.160 125.15,107.5 ; JDOCK1.160 125.15,109.45 ; JDOCK1.160 126.2,107.5 ; JDOCK1.160 127.25,108.48 ; JDOCK1.160 125.15,108.48 ; 195.19,104.63 JHDMI1.11 ; JHDMI1.11 195.65,103.59 ; JHDMI1.11 195.65,104.75 ; JHDMI1.11 196.11,104.63 ; JHDMI1.11 196.11,103.71 ; JHDMI1.11 195.19,103.71 ; JDOCK1.159 107.7,109.42 ; JDOCK1.159 105.64,109.42 ; JDOCK1.159 109.76,109.42 ; JDOCK1.159 107.7,107.53 ; JDOCK1.159 105.64,108.48 ; JDOCK1.159 105.64,107.53 ; JDOCK1.159 109.76,108.48 ; 78.45,96.84 JUSB1.10 ; JUSB1.10 79.33,96.84 ; JUSB1.10 79.33,100.39 ; JUSB1.10 77.57,98.61 ; JUSB1.10 77.57,96.84 ; 212.15,31.6 JMINI1.50 ; JMINI1.50 212.15,31.84 ; JMINI1.50 212.15,31.36 ; JUSB3.4 272.04,79.82 ; JUSB3.4 270.9,78.68 ; JUSB3.4 270.73,79.25 ; JUSB3.4 271.47,78.51 ; JUSB3.4 272.04,78.68 ; JUSB3.4 271.47,79.99 ; JUSB3.4 272.2,79.25 ; JUSB3.4 270.9,79.82 ; 215.87,73.52 H13.1 ; H13.1 217.21,76.69 ; H13.1 214.04,75.35 ; H13.1 214.53,74.01 ; H13.1 217.7,75.35 ; H13.1 215.87,77.18 ; H13.1 214.53,76.69 ; H13.1 217.21,74.01 ; JMDP1.24 274.06,96.15 ; JMDP1.24 271.44,96.15 ; JMDP1.24 271.44,96.93 ; JMDP1.24 272.75,95.37 ; JMDP1.24 272.75,96.93 ; JMDP1.24 271.44,95.37 ; JMDP1.24 274.06,96.93 ; JDOCK1.154 158.76,100.62 ; JDOCK1.154 158.76,99.68 ; JDOCK1.154 156.7,99.68 ; JDOCK1.154 158.76,101.57 ; JDOCK1.154 154.64,99.68 ; JDOCK1.154 154.64,100.62 ; JDOCK1.154 156.7,101.57 ; JMDP1.7 274.05,91.19 ; JMDP1.7 273.13,92.11 ; JMDP1.7 273.01,91.65 ; JMDP1.7 273.13,91.19 ; JMDP1.7 273.59,91.07 ; JMDP1.7 274.05,92.11 ; JMDP1.7 274.17,91.65 ; JHDMI1.21 203.28,101.83 ; JHDMI1.21 201.52,103.4 ; JHDMI1.21 203.28,103.4 ; JHDMI1.21 202.4,104.98 ; JHDMI1.21 201.52,104.98 ; JHDMI1.21 203.28,104.98 ; JHDMI1.21 202.4,101.83 ; JHDMI1.21 201.52,101.83 ; PBATT1.6 160.94,3.04 ; PBATT1.6 160.2,3.28 ; PBATT1.6 160.2,1.32 ; PBATT1.6 159.46,3.04 ; PBATT1.6 160.94,1.56 ; PBATT1.6 159.46,1.56 ; 44.7,40.7 H15.1 ; H15.1 43.36,41.19 ; H15.1 42.87,42.53 ; H15.1 46.53,42.53 ; H15.1 44.7,44.36 ; H15.1 43.36,43.87 ; H15.1 46.04,41.19 ; H15.1 46.04,43.87 ; 80.2,3.22 H4.1 ; H4.1 81.54,6.39 ; H4.1 78.37,5.05 ; H4.1 78.86,3.71 ; H4.1 80.2,6.88 ; H4.1 81.54,3.71 ; H4.1 78.86,6.39 ; H4.1 82.03,5.05 ; H12.1 281.54,46.49 ; H12.1 278.86,46.49 ; H12.1 280.2,46.98 ; H12.1 281.54,43.81 ; H12.1 280.2,43.32 ; H12.1 278.86,43.81 ; H12.1 278.37,45.15 ; H12.1 282.03,45.15 ; JUSB1.4 68.74,98.68 ; JUSB1.4 67.66,98.68 ; JUSB1.4 67.51,98.14 ; JUSB1.4 68.2,97.46 ; JUSB1.4 68.89,98.14 ; JUSB1.4 68.74,97.61 ; JUSB1.4 67.66,97.61 ; JUSB1.4 68.2,98.83 ; 71.16,99.11 JUSB1.7 ; JUSB1.7 72.24,99.11 ; JUSB1.7 71.01,99.64 ; JUSB1.7 71.7,98.96 ; JUSB1.7 72.39,99.64 ; 274.21,93.35 JMDP1.1 ; JMDP1.1 274.33,93.81 ; JMDP1.1 274.33,92.89 ; JMDP1.1 275.25,92.89 ; JMDP1.1 274.79,93.93 ; JMDP1.1 275.25,93.81 ; JMDP1.1 275.37,93.35 ; 192.19,104.63 JHDMI1.5 ; JHDMI1.5 192.19,103.71 ; JHDMI1.5 193.11,104.63 ; JHDMI1.5 192.65,104.75 ; JHDMI1.5 193.11,103.71 ; JHDMI1.5 192.65,103.59 ; JMDP1.13 274.05,89.19 ; JMDP1.13 274.17,89.65 ; JMDP1.13 273.01,89.65 ; JMDP1.13 273.13,89.19 ; JMDP1.13 273.59,90.23 ; JMDP1.13 274.05,90.11 ; 242.97,105.45 JLOM1.15 ; JLOM1.15 243.42,105.45 ; JLOM1.15 243.42,108.95 ; JDOCK1.148 158.29,104.55 ; JDOCK1.148 158.29,102.7 ; JDOCK1.148 158.29,106.4 ; JDOCK1.148 157.37,102.7 ; JDOCK1.148 157.37,106.4 ; JLOM1.14 263.39,105.45 ; JLOM1.14 263.39,108.95 ; JLOM1.14 262.47,105.45 ; JLOM1.14 262.47,108.95 ; JLOM1.14 263.39,107.2 ; JDOCK1.156 127.25,104.55 ; JDOCK1.156 125.4,105.35 ; JDOCK1.156 127,105.35 ; JDOCK1.156 125.4,103.75 ; JDOCK1.156 125.15,104.55 ; JDOCK1.156 127,103.75 ; JDOCK1.156 126.2,103.5 ; JDOCK1.156 126.2,105.6 ; JDOCK1.152 127.25,101.6 ; JDOCK1.152 126.2,101.6 ; JDOCK1.152 127.25,100.62 ; JDOCK1.152 127.25,99.65 ; JDOCK1.152 126.2,99.65 ; JDOCK1.152 125.15,99.65 ; JDOCK1.152 125.15,100.62 ; JDOCK1.152 125.15,101.6 ; JDOCK1.155 115,103.75 ; JDOCK1.155 114.2,103.5 ; JDOCK1.155 115.25,104.55 ; JDOCK1.155 115,105.35 ; JDOCK1.155 114.2,105.6 ; JDOCK1.155 113.4,103.75 ; JDOCK1.155 113.15,104.55 ; JDOCK1.155 113.4,105.35 ; 187.02,101.83 JHDMI1.20 ; JHDMI1.20 187.9,104.98 ; JHDMI1.20 188.78,101.83 ; JHDMI1.20 187.02,103.4 ; JHDMI1.20 187.9,101.83 ; JHDMI1.20 188.78,103.4 ; JHDMI1.20 188.78,104.98 ; JHDMI1.20 187.02,104.98 ; 271.44,84.37 JMDP1.22 ; JMDP1.22 274.06,85.15 ; JMDP1.22 272.75,85.93 ; JMDP1.22 271.44,85.15 ; JMDP1.22 271.44,85.93 ; 212.15,10 JMINI1.4 ; JMINI1.4 212.15,10.24 ; JMINI1.4 212.15,9.76 ; 213.1,18.32 JMINI1.18 ; JMINI1.18 212.15,18.8 ; JMINI1.18 212.15,18.32 ; 211.79,37.45 JMINI2.53 ; JMINI2.53 215.11,36.64 ; JMINI2.53 211.79,36.64 ; JMINI2.53 213.45,36.64 ; JMINI2.53 215.11,37.45 ; JUSB3.7 273.54,76.32 ; JUSB3.7 272.97,76.49 ; JUSB3.7 273.54,75.18 ; JUSB3.7 272.4,75.18 ; JUSB3.7 272.23,75.75 ; JUSB3.7 272.97,75.01 ; JUSB3.7 272.4,76.32 ; 64.07,100.39 JUSB1.11 ; JUSB1.11 65.83,96.84 ; JUSB1.11 65.83,98.61 ; JUSB1.11 64.07,96.84 ; JUSB1.11 64.95,96.84 ; JUSB1.11 64.07,98.61 ; 156.76,82.31 H8.1 ; H8.1 159.88,85.43 ; H8.1 158.32,86 ; H8.1 159.88,82.31 ; H8.1 160.46,83.87 ; H8.1 158.32,81.74 ; H8.1 156.76,85.43 ; H8.1 156.19,83.87 ; JMINI1.53 219.31,4.89 ; JMINI1.53 219.31,5.7 ; JMINI1.53 217.65,4.89 ; JMINI1.53 215.99,4.89 ; JMINI1.53 215.99,5.7 ; H16.1 148.48,4.94 ; H16.1 147.99,3.6 ; H16.1 144.82,4.94 ; H16.1 145.31,3.6 ; H16.1 146.65,6.77 ; H16.1 147.99,6.28 ; H16.1 146.65,3.11 ; H16.1 145.31,6.28 ; 272.12,83.6 JUSB3.11 ; JUSB3.11 275.68,84.48 ; JUSB3.11 275.68,83.6 ; JUSB3.11 272.12,82.72 ; JUSB3.11 273.9,84.48 ; 207.95,57.19 JMINI2.34 ; JMINI2.34 207.95,56.71 ; JMINI2.34 207.95,56.95 ; 190.57,102.97 JHDMI1.2 ; JHDMI1.2 191.61,102.51 ; JHDMI1.2 190.69,103.43 ; JHDMI1.2 191.61,103.43 ; JHDMI1.2 190.69,102.51 ; JHDMI1.2 191.15,102.39 ; JHDMI1.2 191.15,103.56 ; 62.97,107.61 JUSB1.13 ; JUSB1.13 62.97,106.24 ; JUSB1.13 63.85,106.24 ; JUSB1.13 62.97,108.99 ; JUSB1.13 63.85,108.99 ; JDOCK1.161 138.2,109.45 ; JDOCK1.161 137.15,108.48 ; JDOCK1.161 138.2,107.5 ; JDOCK1.161 139.25,108.48 ; JDOCK1.161 137.15,107.5 ; JDOCK1.161 139.25,107.5 ; JDOCK1.161 139.25,109.45 ; JDOCK1.161 137.15,109.45 ; 106.11,106.4 JDOCK1.145 ; JDOCK1.145 106.11,104.55 ; JDOCK1.145 107.02,102.7 ; JDOCK1.145 107.02,106.4 ; JHDMI1.22 186.78,108.78 ; JHDMI1.22 185.02,111.72 ; JHDMI1.22 185.02,108.78 ; JHDMI1.22 186.78,110.25 ; JHDMI1.22 186.78,111.72 ; JHDMI1.22 185.02,110.25 ; JHDMI1.22 185.9,111.72 ; JHDMI1.22 185.9,108.78 ; 207.95,63.35 JMINI2.50 ; JMINI2.50 207.95,63.59 ; JMINI2.50 207.95,63.11 ; JUSB2.4 211.64,98.68 ; JUSB2.4 211.79,98.14 ; JUSB2.4 210.41,98.14 ; JUSB2.4 210.56,97.61 ; JUSB2.4 211.64,97.61 ; JUSB2.4 211.1,98.83 ; JUSB2.4 210.56,98.68 ; JUSB2.4 211.1,97.46 ; H11.1 159.88,63.29 ; H11.1 156.76,60.17 ; H11.1 160.46,61.73 ; H11.1 159.88,60.17 ; H11.1 158.32,63.86 ; H11.1 156.19,61.73 ; H11.1 156.76,63.29 ; H11.1 158.32,59.6 ; JDOCK1.151 107.7,101.57 ; JDOCK1.151 109.76,99.68 ; JDOCK1.151 109.76,100.62 ; JDOCK1.151 107.7,99.68 ; JDOCK1.151 105.64,99.68 ; JDOCK1.151 105.64,100.62 ; JDOCK1.151 105.64,101.57 ; H2.1 184.6,15.75 ; H2.1 185.94,12.58 ; H2.1 186.43,13.92 ; H2.1 182.77,13.92 ; H2.1 183.26,15.26 ; H2.1 185.94,15.26 ; H2.1 184.6,12.09 ; H2.1 183.26,12.58 ; JUSB2.12 223.33,107.61 ; JUSB2.12 222.45,108.99 ; JUSB2.12 223.33,108.99 ; JUSB2.12 223.33,106.24 ; JUSB2.12 222.45,106.24 ; 279.36,84.48 JUSB3.12 ; JUSB3.12 282.03,83.6 ; JUSB3.12 279.36,83.6 ; JUSB3.12 282.03,84.48 ; JUSB3.12 280.7,84.48 ; 207.95,53.99 JMINI2.26 ; JMINI2.26 207.95,53.75 ; JMINI2.26 207.95,53.51 ; JUSB1.12 80.43,107.61 ; JUSB1.12 80.43,106.24 ; JUSB1.12 80.43,108.99 ; JUSB1.12 79.55,108.99 ; JUSB1.12 79.55,106.24 ; 207.95,41.51 JMINI2.4 ; JMINI2.4 207.95,41.99 ; JMINI2.4 207.95,41.75 ; 279.36,67.9 JUSB3.13 ; JUSB3.13 282.03,67.02 ; JUSB3.13 280.7,67.02 ; JUSB3.13 282.03,67.9 ; JUSB3.13 279.36,67.02 ; 212.15,22 JMINI1.26 ; JMINI1.26 212.15,21.76 ; JMINI1.26 212.15,22.24 ; 276.44,85.15 JMDP1.21 ; JMDP1.21 277.75,84.37 ; JMDP1.21 279.06,85.15 ; JMDP1.21 276.44,84.37 ; JMDP1.21 279.06,84.37 ; JMDP1.21 276.44,85.93 ; 214.06,99.11 JUSB2.7 ; JUSB2.7 213.91,99.64 ; JUSB2.7 215.14,99.11 ; JUSB2.7 215.29,99.64 ; JUSB2.7 214.6,98.96
  VCC w0.203: 214.06,99.11 JUSB2.7 ; JUSB2.7 214.6,98.96 ; JUSB2.7 215.14,99.11 ; 201.52,103.4 JHDMI1.21 ; JHDMI1.21 203.28,103.4 ; JHDMI1.21 203.28,101.83 ; JHDMI1.21 202.4,101.83 ; JHDMI1.21 201.52,101.83 ; 64.07,98.61 JUSB1.11 ; JUSB1.11 64.07,96.84 ; JUSB1.11 65.83,98.61 ; JUSB1.11 65.83,96.84 ; JUSB1.11 64.95,96.84 ; JUSB1.4 68.74,97.61 ; JUSB1.4 67.51,98.14 ; JUSB1.4 68.2,98.83 ; JUSB1.4 67.66,97.61 ; JUSB1.4 68.2,97.46 ; JUSB1.4 67.66,98.68 ; JUSB1.4 68.74,98.68 ; JUSB1.4 68.89,98.14 ; 185.9,108.78 JHDMI1.22 ; JHDMI1.22 185.9,111.72 ; JHDMI1.22 185.02,111.72 ; JHDMI1.22 185.02,110.25 ; JHDMI1.22 185.02,108.78 ; 274.21,87.95 JMDP1.19 ; JMDP1.19 275.25,88.41 ; JMDP1.19 274.33,87.49 ; JMDP1.19 275.25,87.49 ; JMDP1.19 275.37,87.95 ; JMDP1.19 274.33,88.41 ; JMDP1.19 274.79,87.37 ; JMDP1.7 274.17,91.65 ; JMDP1.7 274.05,92.11 ; JMDP1.7 273.13,91.19 ; JMDP1.7 273.59,91.07 ; JMDP1.7 274.05,91.19 ; JMDP1.7 273.13,92.11 ; JMDP1.7 273.01,91.65 ; 271.44,96.15 JMDP1.24 ; JMDP1.24 274.06,96.15 ; JMDP1.24 271.44,95.37 ; JMDP1.24 272.75,95.37 ; 280.03,67.02 JUSB3.13 ; JUSB3.13 279.36,67.02 ; JUSB3.13 280.7,67.02 ; H9.1 104.56,63.29 ; H9.1 101.44,60.17 ; H9.1 104.56,60.17 ; H9.1 103,59.6 ; H9.1 105.13,61.73 ; 271.44,84.37 JMDP1.22 ; JMDP1.22 272.75,85.93 ; JMDP1.22 274.06,85.15 ; JMDP1.22 271.44,85.15 ; JMDP1.22 271.44,85.93 ; JHDMI1.23 204.4,111.72 ; JHDMI1.23 205.28,110.25 ; JHDMI1.23 204.4,108.78 ; JHDMI1.23 205.28,111.72 ; JHDMI1.23 205.28,108.78 ; 205.87,107.61 JUSB2.13 ; JUSB2.13 205.87,106.24 ; JUSB2.13 206.75,106.24 ; JUSB2.13 206.75,108.99 ; JUSB2.13 205.87,108.99 ; 267.2,90.32 H17.1 ; H17.1 268.54,90.81 ; H17.1 267.2,93.98 ; H17.1 265.86,90.81 ; H17.1 265.86,93.49 ; H17.1 265.37,92.15 ; H17.1 269.03,92.15 ; H17.1 268.54,93.49 ; 276.44,84.37 JMDP1.21 ; JMDP1.21 277.75,84.37 ; JMDP1.21 279.06,85.15 ; JMDP1.21 279.06,84.37 ; JMDP1.21 276.44,85.15 ; 271.47,78.51 JUSB3.4 ; JUSB3.4 272.04,78.68 ; JUSB3.4 270.73,79.25 ; JUSB3.4 272.2,79.25 ; JUSB3.4 272.04,79.82 ; JUSB3.4 271.47,79.99 ; JUSB3.4 270.9,78.68 ; JUSB3.4 270.9,79.82 ; 272.12,67.02 JUSB3.10 ; JUSB3.10 273.9,67.02 ; JUSB3.10 272.12,68.78 ; JUSB3.10 275.68,67.02 ; JUSB3.10 272.12,67.9 ; 274.33,92.89 JMDP1.1 ; JMDP1.1 274.21,93.35 ; JMDP1.1 274.79,93.93 ; JMDP1.1 275.25,93.81 ; JMDP1.1 274.33,93.81 ; JMDP1.1 275.25,92.89 ; JMDP1.1 275.37,93.35 ; JUSB2.11 208.73,98.61 ; JUSB2.11 206.97,98.61 ; JUSB2.11 206.97,97.72 ; JUSB3.12 280.7,84.48 ; JUSB3.12 282.03,84.48 ; JUSB3.12 279.36,84.48 ; 193.69,102.51 JHDMI1.8 ; JHDMI1.8 194.15,103.56 ; JHDMI1.8 193.69,103.43 ; JHDMI1.8 194.61,103.43 ; JHDMI1.8 194.15,102.39 ; JHDMI1.8 194.61,102.51 ; JHDMI1.20 188.78,103.4 ; JHDMI1.20 187.02,103.4 ; JHDMI1.20 187.9,101.83 ; JHDMI1.20 188.78,101.83 ; JHDMI1.20 187.02,101.83 ; 272.12,83.6 JUSB3.11 ; JUSB3.11 275.68,84.48 ; JUSB3.11 273.9,84.48 ; JUSB3.11 272.12,82.72 ; 191.15,102.39 JHDMI1.2 ; JHDMI1.2 191.61,103.43 ; JHDMI1.2 191.61,102.51 ; JHDMI1.2 190.69,102.51 ; JHDMI1.2 190.57,102.97 ; JHDMI1.2 191.15,103.56 ; JHDMI1.2 190.69,103.43 ; 198.65,103.59 JHDMI1.17 ; JHDMI1.17 199.11,103.71 ; JHDMI1.17 198.19,103.71 ; 220.47,98.61 JUSB2.10 ; JUSB2.10 220.47,97.72 ; JUSB2.10 220.47,99.5 ; 272.4,75.18 JUSB3.7 ; JUSB3.7 272.23,75.75 ; JUSB3.7 272.4,76.32 ; JUSB1.10 79.33,96.84 ; JUSB1.10 78.45,96.84 ; JUSB1.10 77.57,96.84 ; JUSB1.10 77.57,98.61 ; JMDP1.13 273.59,90.23 ; JMDP1.13 273.13,89.19 ; JMDP1.13 274.05,90.11 ; JMDP1.13 274.17,89.65 ; JMDP1.13 274.05,89.19 ; JMDP1.13 273.01,89.65 ; JHDMI1.5 193.11,103.71 ; JHDMI1.5 192.19,103.71 ; JHDMI1.5 192.65,103.59 ; JUSB2.4 211.79,98.14 ; JUSB2.4 210.56,98.68 ; JUSB2.4 211.64,97.61 ; JUSB2.4 210.41,98.14 ; JUSB2.4 210.56,97.61 ; JUSB2.4 211.64,98.68 ; JUSB2.4 211.1,98.83 ; JUSB2.4 211.1,97.46 ; JMDP1.23 279.06,96.54 ; JMDP1.23 276.44,96.15 ; JMDP1.23 279.06,96.15 ; 195.19,103.71 JHDMI1.11 ; JHDMI1.11 195.65,103.59 ; JHDMI1.11 196.11,103.71
  IN4 w0.508: v2(242.24,95.61) 241.33,96.52 239.03,96.52 238.35,97.19 238.35,100.35 239.22,101.22 242.79,101.22 243.42,101.86 JLOM1.15
  GND3 w0.203: JDOCK1.157 139,105.35 ; JDOCK1.157 137.4,105.35 ; JDOCK1.157 138.2,103.5 ; JDOCK1.157 139.25,104.55 ; JDOCK1.157 139,103.75 ; JDOCK1.157 137.4,103.75 ; JDOCK1.157 138.2,105.6 ; JDOCK1.157 137.15,104.55 ; H3.1 280.2,3.98 ; H3.1 278.86,0.81 ; H3.1 282.03,2.15 ; H3.1 278.37,2.15 ; H3.1 281.54,3.49 ; H3.1 278.86,3.49 ; H3.1 281.54,0.81 ; H10.1 103,86 ; H10.1 104.56,82.31 ; H10.1 104.56,85.43 ; H10.1 105.13,83.87 ; H10.1 100.86,83.87 ; H10.1 101.44,82.31 ; H10.1 101.44,85.43 ; H10.1 103,81.74 ; PBATT1.6 160.94,3.04 ; PBATT1.6 160.94,1.56 ; PBATT1.6 159.46,3.04 ; PBATT1.6 160.2,3.28 ; PBATT1.6 160.2,1.32 ; PBATT1.6 159.46,1.56 ; 155.46,1.56 PBATT1.8 ; PBATT1.8 156.2,3.28 ; PBATT1.8 155.46,3.04 ; PBATT1.8 156.94,3.04 ; PBATT1.8 155.22,2.3 ; PBATT1.8 156.94,1.56 ; PBATT1.8 156.2,1.32 ; JLOM1.15 243.42,108.95 ; JLOM1.15 242.97,105.45 ; JLOM1.15 243.42,105.45 ; H15.1 46.53,42.53 ; H15.1 46.04,43.87 ; H15.1 43.36,41.19 ; H15.1 44.7,40.7 ; H15.1 42.87,42.53 ; H15.1 44.7,44.36 ; H15.1 46.04,41.19 ; H15.1 43.36,43.87 ; JUSB2.12 222.45,108.99 ; JUSB2.12 223.33,107.61 ; JUSB2.12 222.45,106.24 ; JUSB2.12 223.33,108.99 ; JUSB2.12 223.33,106.24 ; H14.1 49.2,82.49 ; H14.1 48.1,82.1 ; H14.1 50.3,82.1 ; H14.1 49.2,79.51 ; H14.1 48.1,79.9 ; H14.1 50.69,81 ; H14.1 47.71,81 ; H14.1 50.3,79.9 ; 146.65,3.11 H16.1 ; H16.1 145.31,6.28 ; H16.1 146.65,6.77 ; H16.1 147.99,6.28 ; H16.1 147.99,3.6 ; H16.1 145.31,3.6 ; H16.1 148.48,4.94 ; H16.1 144.82,4.94 ; 198.19,104.63 JHDMI1.17 ; JHDMI1.17 198.65,104.75 ; JHDMI1.17 199.11,104.63 ; JHDMI1.17 198.19,103.71 ; JHDMI1.17 199.11,103.71 ; JHDMI1.17 198.65,103.59 ; 211.79,37.45 JMINI2.53 ; JMINI2.53 213.45,36.64 ; JMINI2.53 211.79,36.64 ; JMINI2.53 215.11,37.45 ; JMINI2.53 215.11,36.64 ; JUSB2.7 215.29,99.64 ; JUSB2.7 215.14,99.11 ; JUSB2.7 214.06,99.11 ; JUSB2.7 213.91,99.64 ; JUSB2.7 214.6,98.96 ; 272.4,75.18 JUSB3.7 ; JUSB3.7 273.54,76.32 ; JUSB3.7 272.97,75.01 ; JUSB3.7 273.54,75.18 ; JUSB3.7 272.4,76.32 ; JUSB3.7 272.23,75.75 ; JUSB3.7 272.97,76.49 ; 125.15,101.6 JDOCK1.152 ; JDOCK1.152 127.25,100.62 ; JDOCK1.152 127.25,101.6 ; JDOCK1.152 125.15,99.65 ; JDOCK1.152 127.25,99.65 ; JDOCK1.152 126.2,99.65 ; JDOCK1.152 125.15,100.62 ; JDOCK1.152 126.2,101.6 ; 220.47,98.61 JUSB2.10 ; JUSB2.10 220.47,96.84 ; JUSB2.10 222.23,96.84 ; JUSB2.10 222.23,100.39 ; JUSB2.10 222.23,98.61 ; JUSB2.10 221.35,96.84 ; 79.55,106.24 JUSB1.12 ; JUSB1.12 80.43,108.99 ; JUSB1.12 80.43,106.24 ; JUSB1.12 80.43,107.61 ; JUSB1.12 79.55,108.99 ; JDOCK1.156 127,103.75 ; JDOCK1.156 126.2,103.5 ; JDOCK1.156 127,105.35 ; JDOCK1.156 127.25,104.55 ; JDOCK1.156 125.15,104.55 ; JDOCK1.156 126.2,105.6 ; JDOCK1.156 125.4,105.35 ; JDOCK1.156 125.4,103.75 ; 265.86,93.49 H17.1 ; H17.1 267.2,93.98 ; H17.1 268.54,90.81 ; H17.1 269.03,92.15 ; H17.1 268.54,93.49 ; H17.1 267.2,90.32 ; H17.1 265.86,90.81 ; H17.1 265.37,92.15 ; 64.07,100.39 JUSB1.11 ; JUSB1.11 64.07,96.84 ; JUSB1.11 65.83,96.84 ; JUSB1.11 65.83,98.61 ; JUSB1.11 64.07,98.61 ; JUSB1.11 64.95,96.84 ; JDOCK1.145 107.02,106.4 ; JDOCK1.145 106.11,104.55 ; JDOCK1.145 107.02,102.7 ; JDOCK1.145 106.11,106.4 ; H9.1 105.13,61.73 ; H9.1 104.56,60.17 ; H9.1 101.44,60.17 ; H9.1 100.86,61.73 ; H9.1 103,63.86 ; H9.1 101.44,63.29 ; H9.1 104.56,63.29 ; H9.1 103,59.6 ; 276.44,96.93 JMDP1.23 ; JMDP1.23 279.06,96.15 ; JMDP1.23 276.44,95.37 ; JMDP1.23 276.44,96.15 ; JMDP1.23 279.06,96.93 ; JMDP1.23 277.75,96.93 ; H4.1 80.2,6.88 ; H4.1 81.54,6.39 ; H4.1 78.37,5.05 ; H4.1 80.2,3.22 ; H4.1 78.86,6.39 ; H4.1 81.54,3.71 ; H4.1 78.86,3.71 ; H4.1 82.03,5.05 ; JDOCK1.148 158.29,102.7 ; JDOCK1.148 158.29,106.4 ; JDOCK1.148 157.37,106.4 ; JDOCK1.148 158.29,104.55 ; JDOCK1.148 157.37,102.7 ; ST2.1 173.34,62.31 ; ST2.1 170.17,63.65 ; ST2.1 172,65.48 ; ST2.1 172,61.82 ; ST2.1 173.34,64.99 ; ST2.1 170.66,64.99 ; ST2.1 173.83,63.65 ; ST2.1 170.66,62.31 ; JHDMI1.5 193.11,104.63 ; JHDMI1.5 192.19,104.63 ; JHDMI1.5 192.65,104.75 ; JHDMI1.5 192.19,103.71 ; JHDMI1.5 193.11,103.71 ; JHDMI1.5 192.65,103.59 ; H1.1 50.48,86.98 ; H1.1 49.14,86.49 ; H1.1 51.82,86.49 ; H1.1 51.82,83.81 ; H1.1 52.31,85.15 ; H1.1 49.14,83.81 ; H1.1 50.48,83.32 ; H1.1 48.65,85.15 ; 211.79,68.06 JMINI2.54 ; JMINI2.54 215.11,68.06 ; JMINI2.54 215.11,67.25 ; JMINI2.54 211.79,67.25 ; JMINI2.54 213.45,68.06 ; JHDMI1.2 191.15,103.56 ; JHDMI1.2 191.61,103.43 ; JHDMI1.2 191.61,102.51 ; JHDMI1.2 190.69,103.43 ; JHDMI1.2 190.69,102.51 ; JHDMI1.2 190.57,102.97 ; JHDMI1.2 191.15,102.39 ; 156.76,82.31 H8.1 ; H8.1 159.88,85.43 ; H8.1 158.32,86 ; H8.1 156.19,83.87 ; H8.1 156.76,85.43 ; H8.1 159.88,82.31 ; H8.1 158.32,81.74 ; H8.1 160.46,83.87 ; 203.52,110.25 JHDMI1.23 ; JHDMI1.23 205.28,110.25 ; JHDMI1.23 203.52,108.78 ; JHDMI1.23 204.4,108.78 ; JHDMI1.23 204.4,111.72 ; JHDMI1.23 203.52,111.72 ; JHDMI1.23 205.28,111.72 ; JHDMI1.23 205.28,108.78 ; 151.08,0.67 PBATT1.10 ; PBATT1.10 151.08,4.43 ; PBATT1.10 150.1,2.55 ; PBATT1.10 152.05,4.43 ; PBATT1.10 152.05,0.67 ; PBATT1.10 150.1,0.67 ; PBATT1.10 150.1,4.43 ; PBATT1.10 152.05,2.55 ; 185.9,108.78 JHDMI1.22 ; JHDMI1.22 185.02,110.25 ; JHDMI1.22 185.02,111.72 ; JHDMI1.22 186.78,108.78 ; JHDMI1.22 185.02,108.78 ; JHDMI1.22 186.78,111.72 ; JHDMI1.22 186.78,110.25 ; JHDMI1.22 185.9,111.72 ; 270.9,78.68 JUSB3.4 ; JUSB3.4 272.04,79.82 ; JUSB3.4 270.73,79.25 ; JUSB3.4 271.47,78.51 ; JUSB3.4 272.2,79.25 ; JUSB3.4 272.04,78.68 ; JUSB3.4 270.9,79.82 ; JUSB3.4 271.47,79.99 ; PBATT1.9 154.94,1.56 ; PBATT1.9 153.22,2.3 ; PBATT1.9 154.2,3.28 ; PBATT1.9 153.46,3.04 ; PBATT1.9 154.94,3.04 ; PBATT1.9 153.46,1.56 ; PBATT1.9 154.2,1.32 ; PBATT1.9 155.18,2.3 ; JUSB3.11 275.68,84.48 ; JUSB3.11 272.12,82.72 ; JUSB3.11 272.12,83.6 ; JUSB3.11 275.68,83.6 ; JUSB3.11 273.9,84.48 ; 172.35,0.67 PBATT1.11 ; PBATT1.11 172.35,2.55 ; PBATT1.11 174.3,0.67 ; PBATT1.11 173.33,0.67 ; PBATT1.11 173.33,4.43 ; PBATT1.11 174.3,2.55 ; PBATT1.11 174.3,4.43 ; PBATT1.11 172.35,4.43 ; 206.97,100.39 JUSB2.11 ; JUSB2.11 206.97,96.84 ; JUSB2.11 206.97,98.61 ; JUSB2.11 208.73,98.61 ; JUSB2.11 208.73,96.84 ; JUSB2.11 207.85,96.84 ; H5.1 228.37,109.38 ; H5.1 227.2,112.14 ; H5.1 228.79,110.55 ; H5.1 226.03,109.38 ; H5.1 226.03,111.72 ; H5.1 225.61,110.55 ; H5.1 227.2,108.96 ; H5.1 228.37,111.72 ; 154.64,109.42 JDOCK1.162 ; JDOCK1.162 158.76,107.53 ; JDOCK1.162 158.76,109.42 ; JDOCK1.162 156.7,107.53 ; JDOCK1.162 156.7,109.42 ; JDOCK1.162 154.64,108.48 ; JDOCK1.162 158.76,108.48 ; JUSB2.4 211.64,98.68 ; JUSB2.4 211.79,98.14 ; JUSB2.4 210.56,98.68 ; JUSB2.4 211.1,97.46 ; JUSB2.4 210.56,97.61 ; JUSB2.4 211.64,97.61 ; JUSB2.4 210.41,98.14 ; JUSB2.4 211.1,98.83 ; 113.4,105.35 JDOCK1.155 ; JDOCK1.155 113.4,103.75 ; JDOCK1.155 115.25,104.55 ; JDOCK1.155 114.2,103.5 ; JDOCK1.155 115,103.75 ; JDOCK1.155 114.2,105.6 ; JDOCK1.155 115,105.35 ; JDOCK1.155 113.15,104.55 ; JHDMI1.21 202.4,104.98 ; JHDMI1.21 201.52,104.98 ; JHDMI1.21 203.28,101.83 ; JHDMI1.21 203.28,104.98 ; JHDMI1.21 201.52,103.4 ; JHDMI1.21 201.52,101.83 ; JHDMI1.21 202.4,101.83 ; JHDMI1.21 203.28,103.4 ; JDOCK1.158 151,103.75 ; JDOCK1.158 149.15,104.55 ; JDOCK1.158 151.25,104.55 ; JDOCK1.158 150.2,105.6 ; JDOCK1.158 151,105.35 ; JDOCK1.158 149.4,103.75 ; JDOCK1.158 149.4,105.35 ; JDOCK1.158 150.2,103.5 ; JUSB3.13 282.03,67.9 ; JUSB3.13 280.7,67.02 ; JUSB3.13 282.03,67.02 ; JUSB3.13 279.36,67.9 ; JUSB3.13 279.36,67.02 ; JMINI1.53 219.31,4.89 ; JMINI1.53 215.99,4.89 ; JMINI1.53 219.31,5.7 ; JMINI1.53 215.99,5.7 ; JMINI1.53 217.65,4.89 ; 212.15,31.36 JMINI1.50 ; JMINI1.50 212.15,31.84 ; JMINI1.50 212.15,31.6 ; 274.33,92.89 JMDP1.1 ; JMDP1.1 275.37,93.35 ; JMDP1.1 274.79,93.93 ; JMDP1.1 274.21,93.35 ; JMDP1.1 275.25,92.89 ; JMDP1.1 275.25,93.81 ; JMDP1.1 274.33,93.81 ; 194.15,102.39 JHDMI1.8 ; JHDMI1.8 194.15,103.56 ; JHDMI1.8 194.61,102.51 ; JHDMI1.8 194.61,103.43 ; JHDMI1.8 193.69,103.43 ; JHDMI1.8 193.69,102.51 ; JDOCK1.154 158.76,99.68 ; JDOCK1.154 158.76,100.62 ; JDOCK1.154 158.76,101.57 ; JDOCK1.154 156.7,99.68 ; JDOCK1.154 156.7,101.57 ; JDOCK1.154 154.64,100.62 ; JDOCK1.154 154.64,99.68 ; JUSB1.4 68.74,97.61 ; JUSB1.4 68.2,98.83 ; JUSB1.4 68.89,98.14 ; JUSB1.4 67.66,97.61 ; JUSB1.4 68.2,97.46 ; JUSB1.4 68.74,98.68 ; JUSB1.4 67.66,98.68 ; JUSB1.4 67.51,98.14 ; JDOCK1.161 139.25,109.45 ; JDOCK1.161 137.15,107.5 ; JDOCK1.161 137.15,108.48 ; JDOCK1.161 139.25,107.5 ; JDOCK1.161 139.25,108.48 ; JDOCK1.161 138.2,109.45 ; JDOCK1.161 137.15,109.45 ; JDOCK1.161 138.2,107.5 ; JMDP1.7 274.17,91.65 ; JMDP1.7 273.01,91.65 ; JMDP1.7 274.05,91.19 ; JMDP1.7 273.13,91.19 ; JMDP1.7 274.05,92.11 ; JMDP1.7 273.59,91.07 ; JMDP1.7 273.13,92.11 ; JDOCK1.153 139.25,101.6 ; JDOCK1.153 138.2,99.65 ; JDOCK1.153 138.2,101.6 ; JDOCK1.153 137.15,101.6 ; JDOCK1.153 137.15,100.62 ; JDOCK1.153 139.25,99.65 ; JDOCK1.153 139.25,100.62 ; JDOCK1.153 137.15,99.65 ; 105.64,108.48 JDOCK1.159 ; JDOCK1.159 109.76,108.48 ; JDOCK1.159 105.64,109.42 ; JDOCK1.159 107.7,109.42 ; JDOCK1.159 109.76,109.42 ; JDOCK1.159 105.64,107.53 ; JDOCK1.159 107.7,107.53 ; JUSB2.13 206.75,108.99 ; JUSB2.13 205.87,106.24 ; JUSB2.13 205.87,107.61 ; JUSB2.13 206.75,106.24 ; JUSB2.13 205.87,108.99 ; JLOM1.14 263.39,105.45 ; JLOM1.14 263.39,107.2 ; JLOM1.14 262.47,108.95 ; JLOM1.14 263.39,108.95 ; JLOM1.14 262.47,105.45 ; 271.44,85.93 JMDP1.22 ; JMDP1.22 271.44,85.15 ; JMDP1.22 272.75,85.93 ; JMDP1.22 274.06,85.15 ; JMDP1.22 271.44,84.37 ; JDOCK1.151 109.76,99.68 ; JDOCK1.151 105.64,99.68 ; JDOCK1.151 105.64,101.57 ; JDOCK1.151 107.7,99.68 ; JDOCK1.151 109.76,100.62 ; JDOCK1.151 105.64,100.62 ; JDOCK1.151 107.7,101.57 ; H2.1 185.94,12.58 ; H2.1 182.77,13.92 ; H2.1 186.43,13.92 ; H2.1 183.26,15.26 ; H2.1 184.6,12.09 ; H2.1 185.94,15.26 ; H2.1 183.26,12.58 ; H2.1 184.6,15.75 ; JUSB3.12 282.03,84.48 ; JUSB3.12 279.36,84.48 ; JUSB3.12 280.7,84.48 ; JUSB3.12 282.03,83.6 ; JUSB3.12 279.36,83.6 ; JHDMI1.20 188.78,104.98 ; JHDMI1.20 187.9,101.83 ; JHDMI1.20 188.78,101.83 ; JHDMI1.20 187.9,104.98 ; JHDMI1.20 188.78,103.4 ; JHDMI1.20 187.02,104.98 ; JHDMI1.20 187.02,103.4 ; JHDMI1.20 187.02,101.83 ; 207.95,53.75 JMINI2.26 ; JMINI2.26 207.95,53.51 ; JMINI2.26 207.95,53.99 ; JUSB1.7 72.39,99.64 ; JUSB1.7 71.7,98.96 ; JUSB1.7 72.24,99.11 ; JUSB1.7 71.01,99.64 ; JUSB1.7 71.16,99.11 ; 206.61,32.71 H18.1 ; H18.1 206.61,35.39 ; H18.1 206.12,34.05 ; H18.1 209.29,35.39 ; H18.1 207.95,35.88 ; H18.1 209.78,34.05 ; H18.1 207.95,32.22 ; H18.1 209.29,32.71 ; 77.57,98.61 JUSB1.10 ; JUSB1.10 79.33,96.84 ; JUSB1.10 78.45,96.84 ; JUSB1.10 79.33,100.39 ; JUSB1.10 77.57,96.84 ; 156.19,61.73 H11.1 ; H11.1 158.32,59.6 ; H11.1 156.76,63.29 ; H11.1 156.76,60.17 ; H11.1 160.46,61.73 ; H11.1 159.88,60.17 ; H11.1 158.32,63.86 ; H11.1 159.88,63.29 ; 207.95,50.07 JMINI2.18 ; JMINI2.18 207.95,50.55 ; JMINI2.18 208.9,50.07 ; 271.44,96.15 JMDP1.24 ; JMDP1.24 271.44,95.37 ; JMDP1.24 271.44,96.93 ; JMDP1.24 272.75,96.93 ; JMDP1.24 274.06,96.93 ; JMDP1.24 274.06,96.15 ; JMDP1.24 272.75,95.37 ; JUSB3.10 275.68,67.9 ; JUSB3.10 272.12,68.78 ; JUSB3.10 275.68,67.02 ; JUSB3.10 272.12,67.9 ; JUSB3.10 272.12,67.02 ; JUSB3.10 273.9,67.02 ; 277.75,84.37 JMDP1.21 ; JMDP1.21 276.44,84.37 ; JMDP1.21 279.06,85.15 ; JMDP1.21 276.44,85.93 ; JMDP1.21 279.06,84.37 ; JMDP1.21 276.44,85.15 ; H13.1 215.87,77.18 ; H13.1 217.21,76.69 ; H13.1 214.53,74.01 ; H13.1 214.53,76.69 ; H13.1 217.7,75.35 ; H13.1 214.04,75.35 ; H13.1 215.87,73.52 ; H13.1 217.21,74.01 ; 125.15,109.45 JDOCK1.160 ; JDOCK1.160 125.15,107.5 ; JDOCK1.160 126.2,109.45 ; JDOCK1.160 126.2,107.5 ; JDOCK1.160 125.15,108.48 ; JDOCK1.160 127.25,107.5 ; JDOCK1.160 127.25,109.45 ; 274.79,87.37 JMDP1.19 ; JMDP1.19 275.25,87.49 ; JMDP1.19 274.33,87.49 ; JMDP1.19 275.25,88.41 ; JMDP1.19 274.33,88.41 ; JMDP1.19 274.21,87.95 ; JMDP1.19 275.37,87.95 ; 212.15,18.32 JMINI1.18 ; JMINI1.18 212.15,18.8 ; JMINI1.18 213.1,18.32 ; 195.65,103.59 JHDMI1.11 ; JHDMI1.11 195.65,104.75 ; JHDMI1.11 195.19,104.63 ; JHDMI1.11 196.11,104.63 ; JHDMI1.11 195.19,103.71 ; JHDMI1.11 196.11,103.71 ; 207.95,41.99 JMINI2.4 ; JMINI2.4 207.95,41.51 ; JMINI2.4 207.95,41.75 ; 212.15,25.44 JMINI1.34 ; JMINI1.34 212.15,25.2 ; JMINI1.34 212.15,24.96 ; 212.15,10.24 JMINI1.4 ; JMINI1.4 212.15,10 ; JMINI1.4 212.15,9.76 ; JMDP1.13 274.05,89.19 ; JMDP1.13 273.13,89.19 ; JMDP1.13 274.17,89.65 ; JMDP1.13 273.59,90.23 ; JMDP1.13 274.05,90.11 ; JMDP1.13 273.01,89.65 ; 207.95,63.35 JMINI2.50 ; JMINI2.50 207.95,63.59 ; JMINI2.50 207.95,63.11 ; 207.95,57.19 JMINI2.34 ; JMINI2.34 207.95,56.71 ; JMINI2.34 207.95,56.95 ; 63.85,106.24 JUSB1.13 ; JUSB1.13 62.97,108.99 ; JUSB1.13 62.97,106.24 ; JUSB1.13 63.85,108.99 ; JUSB1.13 62.97,107.61 ; 212.15,21.76 JMINI1.26 ; JMINI1.26 212.15,22 ; JMINI1.26 212.15,22.24
  BOTTOM w0.089: v5(195.02,81.77) 194.47,81.22 v4(194.38,81.22) ; 193.45,101.96 v2(193.45,101.96)
  BOTTOM w0.127: UC1.AV39 128.1,61.64 128.47,62 128.47,62.51 128.45,62.53 ; UC1.AV43 124.95,61.64 125.32,62 125.32,62.48 125.27,62.52 ; v5(22.44,43.31) 21.86,42.72 v2(21.81,42.72) ; 123.73,62.59 123.73,62.28 123.74,62.27 123.74,62 123.38,61.64 UC1.AV46 ; v2(100.64,89.74) 100.44,89.74 v5(99.83,89.13) ; 129.97,62.53 130.04,62.45 130.04,62 129.68,61.64 UC1.AV36 ; v5(92.71,74.46) 92.44,74.19 92.08,74.19 ; v5(262.47,80.78) 262.45,80.81 261.54,80.81 v2(261.48,80.87) ; v5(212.19,91.99) 211.56,91.35 v2(211.38,91.35) ; 229.9,81.34 231.01,81.34 v5(231.2,81.53) ; UC1.AV41 126.53,61.64 126.89,62 126.89,62.48 126.94,62.53 ; v5(215.27,86.55) 215.27,86.54 213.84,85.11 v2(213.46,85.11) ; v5(68.87,63.5) 68.32,64.06 v2(68.32,64.13) ; v5(105.54,4.48) 105.92,4.86 v2(105.92,6.13)
  BOTTOM w0.152: v2(135.41,59.35) 135.41,59.4 135.61,59.6 UC1.AY26 ; UC1.AD3 149.91,69.64 149.58,69.97 149.19,69.97 148.99,69.77 148.99,69.53 148.83,69.37 v2(148.83,69.37)
  BOTTOM w0.178: UC1.AP52 119.69,63.82 119.68,63.81 119.68,63.44 119.69,63.43 UC1.AR52 ; v2(133.1,59.59) 133.17,59.67 UC1.AY30 ; UC1.AW33 131.58,61.16 UC1.AV34 ; UC1.AW33 131.82,61.76 UC1.AV33 ; UC1.AW33 UC1.AY33 ; v2(112.05,71.77) 112.17,71.89 UC1.Y63 ; v2(111.72,64.28) 111.88,64.43 UC1.AN63 ; UC1.D2 150.55,80.74 150.17,81.13 149.66,81.13 v2(149.54,81.25) ; UC1.AV59 UC1.AW59 ; UC1.AT46 UC1.AT43 ; UC1.AV51 UC1.AW51 UC1.AY51 120.29,58.71 v2(120.2,58.62) ; UC1.D8 147.42,81.03 147.76,81.37 147.84,81.37 148.01,81.54 v2(148.01,81.58) ; v2(136.88,59.58) 136.96,59.65 UC1.AY24 UC1.AW24 UC1.AV24 ; UC1.AV16 UC1.AW16 142.05,60.55 UC1.AY16 142.09,59.56 v2(142.14,59.51) ; UC1.AU33 132.64,62.48 132.66,62.46 UC1.AU30 ; v2(111.68,66.59) 112.01,66.59 112.28,66.86 UC1.AJ63 ; 128.7,62.53 128.45,62.53 ; v2(116.44,59.54) 116.51,59.61 UC1.AY57 ; UC1.AY59 115.19,59.63 v2(115.13,59.57) ; v2(138.37,59.57) 138.31,59.63 UC1.AY22 ; v2(118.75,59.3) 118.75,59.66 118.94,59.86 UC1.AY53 ; v2(131.11,63.04) 130.84,62.77 UC1.AT35 ; v2(114.95,75.26) 114.95,75.07 115.17,74.85 UC1.P59 ; UC1.AD63 112.63,69.65 v2(112.13,69.65) ; v2(140.67,59.59) 140.74,59.66 UC1.AY18
  BOTTOM w0.203: v2(148,65.08) 147.94,65.08 147.59,64.74 UC1.AN7 ; UC1.AC61 113.95,70.36 113.65,70.66 v2(113.65,70.76) ; v2(151.77,74.06) 151.73,74.09 UC1.T1 ; U31.11 v2(196.52,72.53) U31.15 ; v2(147.82,59.66) 147.9,59.75 UC1.AY6 ; UC1.AW59 114.95,60.84 UC1.AW60 ; v2(113.65,73.76) 113.95,73.46 UC1.U61 ; v2(150.28,72.22) 150.27,72.22 149.97,72.52 UC1.V3 ; UC1.AM1 151.77,65.1 v2(151.82,65.06) ; UC1.AP3 150,63.64 150.31,63.33 v2(150.31,63.23) ; v2(150.27,75.22) 149.97,75.52 UC1.N3 ; UC1.AV8 146.33,61.49 v2(146.03,61.19) ; v2(149.55,59.49) 149.35,59.69 UC1.AY4 149.3,60.23 UC1.AW4 ; v2(208.42,71.55) 208.32,71.65 U43.11 ; v2(112.07,78) 112.19,77.88 UC1.J63 ; v2(148.83,69.37) 148.64,69.17 UC1.AE5 ; UC1.D59 115.37,80.6 115.9,80.08 UC1.F58 ; v2(150.27,66.23) 149.97,66.53 UC1.AK3 ; UC1.AN49 121.37,64.6 121.26,64.49 120.89,64.49 120.78,64.6 UC1.AN51 120.44,64.6 120.31,64.47 119.93,64.47 119.8,64.6 UC1.AN52 ; UC1.F61 113.95,79.46 v2(113.65,79.75) ; UC1.K1 151.41,77.09 151.7,77.38 v2(152.01,77.38)
  BOTTOM w0.229: v2(151.82,68.15) 151.77,68.1 UC1.AG1 ; UC1.AL51 120.45,65.9 v2(120.12,65.57) ; UC1.F26 136,79.11 v2(135.99,79.11) ; UC1.AJ39 127.6,66.72 127.73,66.59 UC1.AL39 ; UC1.AJ39 127.96,67.2 128.25,66.91 v2(128.25,66.87) ; UC1.AJ39 v2(127.6,67.76) ; UC1.AJ52 119.8,66.65 UC1.AK52 119.33,66.55 v2(119.17,66.38) ; v2(138.18,65.57) 138.5,65.9 UC1.AL22 ; v2(121.99,63.62) 122.31,63.95 UC1.AP48 UC1.AN48 ; UC1.J10 145.67,77.59 v2(145.31,77.95) ; UC1.AN23 137.66,64.6 v2(137.33,64.27) 137.66,63.95 UC1.AP23 ; UC1.AH53 119.15,66.4 v2(119.17,66.38) ; UC1.AV34 131.13,61.49 130.84,61.2 v2(130.84,61.19) 130.78,61.19 UC1.AW35 ; v2(130.98,79.11) 130.98,79.11 UC1.F34 ; v2(138.18,63.62) 138.5,63.95 UC1.AP22 ; UC1.AF18 141.15,68.81 v2(141.47,69.13) ; UC1.F30 133.49,79.11 v2(133.49,79.11) ; UC1.AH49 121.75,67.08 v2(121.86,66.97) ; v2(132.04,66.87) 132.04,67.41 UC1.AH32 ; UC1.AH42 125.65,67.08 v2(125.77,66.96) ; UC1.D5 148.71,81.08 148.72,81.08 148.77,81.13 149.42,81.13 v2(149.54,81.25) ; 119.63,65.25 119.33,64.95 v2(119.19,64.95) ; 119.63,65.25 UC1.AM52 ; 119.63,65.25 119.3,65.57 v2(119.24,65.57) 119.17,65.57 119.5,65.9 UC1.AL52 ; UC1.D12 144.54,80.53 v2(144.44,80.43) 144.57,80.43 144.81,80.2 UC1.E11 ; UC1.AP26 135.75,63.95 v2(135.43,63.62) ; v2(113.66,76.74) 113.95,76.45 UC1.L61 ; UC1.AP57 116.69,63.95 v2(116.37,63.62) ; UC1.AJ25 136.7,67.09 136.5,66.89 v2(136.24,66.89) 136.16,66.97 135.64,66.97 UC1.AJ27 ; v2(131.01,66.94) 130.85,67.1 UC1.AH34 ; UC1.AN43 125.12,64.34 124.66,64.34 UC1.AN45 124.29,64.49 123.58,64.49 UC1.AN46 123.25,64.6 v2(122.98,64.87) 122.71,64.6 UC1.AN48 ; UC1.AJ60 114.92,66.49 114.96,66.44 114.96,66.14 114.92,66.1 UC1.AL60 ; UC1.AN36 129.37,64.6 v2(129.2,64.42) ; v2(116.45,71.48) UC1.AA58 ; v2(117.76,61.3) 117.73,61.34 UC1.AV55 ; UC1.F50 120.95,79.11 v2(120.95,79.11) ; UC1.AH28 134.75,67.9 v2(134.61,68.05) ; UC1.AV20 139.52,61.34 v2(139.56,61.3) ; v2(118.27,63.62) 118.6,63.95 UC1.AP54 ; UC1.AN48 122.25,64.43 121.69,64.43 UC1.AN49 ; UC1.AN32 132.45,64.69 132.68,64.92 UC1.AN31 ; UC1.AP29 133.85,63.95 v2(133.52,63.62) ; v2(140.98,66.87) 141.45,67.34 UC1.AH17 141.74,67.16 142.19,67.16 UC1.AH16 ; UC1.AW37 128.96,60.84 v2(129.27,61.14) ; UC1.AH40 127.18,67.76 v2(127.6,67.76) ; v2(143.51,78.57) 143.84,78.24 UC1.H13 ; UC1.AN40 127.47,64.27 UC1.AP39 ; UC1.AN40 127.08,64.6 v2(126.75,64.27) 126.43,64.6 UC1.AN42 ; UC1.AN40 127.47,64.92 UC1.AN39 ; UC1.N21 139.56,75.36 v2(139.06,75.36) ; UC1.A18 140.67,83.36 v2(140.7,83.4) ; v2(128.47,79.11) 128.47,79.11 UC1.F38 ; v2(139.06,75.36) 138.67,75.75 UC1.M22 ; v2(139.06,75.36) 138.68,74.98 UC1.P22 ; UC1.AN31 UC1.AP31 UC1.AR31 133.01,62.62 UC1.AU30 133.55,62.46 133.59,62.5 133.9,62.5 133.94,62.46 UC1.AU28 134.84,62.46 134.88,62.5 135.19,62.5 135.23,62.46 UC1.AU26 136.09,62.46 136.13,62.5 136.43,62.5 136.48,62.46 UC1.AU24 ; UC1.AN31 UC1.AM31 UC1.AL31 133.01,66.37 v2(133.52,66.87) 133.85,67.2 UC1.AJ29 ; UC1.W22 138.57,72.54 UC1.V23 138.16,72.93 v2(137.78,72.55) ; v2(125.77,66.96) 125.24,66.96 UC1.AJ43 ; v2(125.77,66.96) 126.01,67.2 UC1.AJ41 ; v2(121.86,66.97) 122.16,66.97 122.4,67.2 UC1.AJ47 122.75,67.2 v2(122.98,66.97) 123.47,66.97 UC1.AJ45 ; v2(121.86,66.97) 121.4,66.97 121.17,67.2 UC1.AJ50 ; UC1.AL45 124.39,65.9 124.13,65.63 v2(123.93,65.63) 123.74,65.63 UC1.AL46 ; v2(147.52,73.14) 147.34,72.97 UC1.V7 ; UC1.AL60 114.92,65.28 114.97,65.23 114.97,64.85 114.92,64.8 UC1.AN60 114.92,63.95 114.96,63.91 114.96,63.43 v2(114.84,63.3) ; UC1.AL60 UC1.AL61 113.8,65.65 v2(113.76,65.61) ; v2(119.17,66.38) 118.68,65.9 UC1.AL54 ; UC1.AR33 131.37,63.3 v2(131.11,63.04) 131.66,62.48 UC1.AU33 ; 137.66,66.55 v2(137.33,66.87) 137.35,66.89 UC1.AH24 ; 137.66,66.55 UC1.AK23 ; 137.66,66.55 v2(137.33,66.22) 137.66,65.9 ; v2(141.48,78.57) 141.67,78.57 142,78.24 UC1.H17 ; UC1.D18 141.17,80.91 v2(141.51,80.57) 141.71,80.57 142.01,80.27 UC1.E17 ; v2(145.13,70.8) 145.17,70.76 UC1.AB10 ; UC1.AL10 145.51,66.04 v2(145.22,66.33) ; UC1.AH36 129.79,67.76 v2(130.2,67.76) ; v2(131.11,65.64) 131.37,65.9 UC1.AL33 ; UC1.AY11 144.9,59.59 v2(145.02,59.47) ; UC1.R22 138.67,73.93 v2(139.24,73.36) UC1.U22 ; v2(142.74,66.91) 142.74,66.92 ; 142.74,66.92 142.05,66.24 UC1.AL17 ; 142.74,66.92 142.82,67 143.14,66.69 UC1.AJ14 143.18,66.55 UC1.AL13 143.82,66.15 143.82,66.51 UC1.AJ13 144.09,66.69 v2(144.39,66.4) ; UC1.AW44 124.2,60.84 v2(124.55,61.18) 124.69,61.18 124.95,61.44 UC1.AV43 ; v2(133.52,65.57) 133.85,65.9 UC1.AL29 ; UC1.AH38 128.02,67.76 v2(127.6,67.76) ; v2(123.46,79.11) 123.46,79.11 UC1.F46 ; UC1.AH34 130.62,67.76 v2(130.2,67.76) ; UC1.AH34 v2(131.34,68.01) ; UC1.AL36 129.37,65.9 v2(129.2,65.73) ; v2(142.68,62.9) 142.92,62.9 UC1.AR15 ; v2(140.58,70.52) 140.45,70.52 140.09,70.88 UC1.AB20 ; UC1.AL57 116.69,65.9 v2(116.37,65.57) ; UC1.AN52 119.54,64.6 119.29,64.35 v2(119.2,64.35) ; UC1.AN35 130.48,64.6 v2(130.15,64.27) ; UC1.AV41 126.43,61.49 v2(126.12,61.18) 125.78,60.84 UC1.AW42 ; v2(116.4,74.21) 116.28,74.09 UC1.T58 ; UC1.AW47 122.67,60.84 v2(122.96,61.13) 123.32,61.49 UC1.AV46 ; UC1.AL20 140.41,65.9 v2(140.08,65.57) ; UC1.AF11 144.84,68.91 v2(144.84,69.1) ; UC1.AV39 127.98,61.49 v2(127.69,61.19) 127.33,60.84 UC1.AW40 ; 137.66,65.9 v2(137.33,65.57) 137.66,65.25 UC1.AM23 ; 137.66,65.9 UC1.AL23 ; UC1.R8 146.69,74.85 v2(146.91,75.07) ; UC1.AV28 134.39,61.34 v2(134.42,61.3) ; UC1.AG60 UC1.AG61 UC1.AG62 UC1.AG63 112.88,68.3 112.12,68.3 v2(111.94,68.11) ; v2(130.2,67.76) UC1.AJ35 ; UC1.F54 118.44,79.11 v2(118.44,79.11) ; UC1.AU59 115.64,62.46 115.68,62.5 115.99,62.5 116.03,62.46 UC1.AU57 116.89,62.46 116.93,62.5 117.23,62.5 117.28,62.46 UC1.AU55 118.18,62.46 118.22,62.5 118.53,62.5 118.57,62.46 UC1.AU53 119.42,62.46 119.47,62.5 119.77,62.5 119.81,62.46 UC1.AU51 120.55,62.72 120.72,62.72 v2(121.08,63.07) ; UC1.AT49 121.36,62.79 v2(121.08,63.07) ; UC1.AH57 116.87,67.2 UC1.AJ56 ; UC1.AH57 116.22,67.2 UC1.AJ58 ; UC1.AH57 116.69,67.67 116.89,67.67 117.27,68.05 v2(117.3,68.05) ; 139.59,69.67 139.59,69.62 139.18,69.21 139.18,69.25 v2(139.19,69.25) ; v2(135.43,65.57) 135.75,65.9 UC1.AL26 ; v2(121.08,63.07) 121.13,63.07 121.24,63.19 121.26,63.19 121.37,63.3 UC1.AR49 ; v2(125.96,79.11) 125.97,79.11 UC1.F42 ; UC1.F20 139.83,79.82 v2(139.69,79.82) 139.36,79.82 138.67,79.13 UC1.G22 ; UC1.AV49 121.5,61.19 v2(121.39,61.19) 121.04,60.84 UC1.AW50 ; UC1.W20 140.13,72.54 v2(140.52,72.93) UC1.U20 ; v2(143.59,69.19) UC1.AF14 ; v2(146.86,70.27) 146.86,70.33 147.29,70.76 UC1.AB7 ; v2(140.08,63.62) 140.41,63.95 UC1.AP20 ; UC1.L15 142.96,76.46 143.24,76.17 v2(143.24,76.2) 143.71,76.67 UC1.L13 144.35,77.11 UC1.K12 ; UC1.AU16 141.61,62.46 141.57,62.5 141.26,62.5 141.22,62.46 UC1.AU18 140.37,62.46 140.32,62.5 140.02,62.5 139.97,62.46 UC1.AU20 139.07,62.46 139.03,62.5 138.72,62.5 138.68,62.46 UC1.AU22 137.84,62.46 137.53,62.78 v2(137.4,62.78) ; UC1.AR39 v2(128.25,63.62) 128.57,63.95 UC1.AP38 ; v2(139.24,70.92) UC1.AB22 ; v2(116.45,68.88) UC1.AE58 ; UC1.AR43 125.21,63.3 v2(124.89,62.97) 124.54,62.62 UC1.AT43 124.61,62.52 126.04,62.52 UC1.AT42 126.5,62.59 126.57,62.53 126.94,62.53 127,62.59 UC1.AT40 127.76,62.52 128.69,62.52 128.77,62.59 UC1.AT37 129.9,62.59 129.97,62.53 130.34,62.53 130.41,62.59 UC1.AT35 ; UC1.V58 v2(116.45,72.78)
  BOTTOM w0.254: UC1.D12 144.89,81.38 144.89,81.59 UC1.C11 ; v2(144.98,83.29) 144.91,83.22 UC1.A11 ; 60.55,73.71 60.82,73.03 60.69,72.76 v2(60.38,72.58) ; v2(128.38,109.89) 128.45,109.82 JDOCK1.58 ; UC1.AH55 117.52,67.2 UC1.AJ56 ; UC1.AH55 v2(118.33,68.01) ; UC1.AH55 118.17,67.2 UC1.AJ54 118.82,67.2 UC1.AH53 v2(119.64,68.01) ; UC1.AE10 145.71,68.86 145.71,68.85 145.53,68.85 UC1.AF11 144.81,68.13 ; UC1.U9 145.8,72.7 UC1.V10 143.83,72.67 v2(143.12,73.38) ; UC1.AN42 126.13,64.4 125.95,64.4 125.87,64.32 v2(125.89,64.32) ; UC1.AH44 124.67,67.53 UC1.AJ43 ; UC1.AH44 124.02,67.53 UC1.AJ45 ; UC1.AH44 v2(124.84,68.01) ; JDOCK1.93 137.45,99.75 137.79,99.41 v2(137.94,99.41) 137.76,99.22 137.4,99.22 136.95,99.68 JDOCK1.91 ; UC1.AL17 UC1.AM17 UC1.AN17 UC1.AP17 UC1.AR17 142.05,63.27 142.42,62.9 v2(142.68,62.9) ; v2(147.95,109.83) JDOCK1.132 ; v2(120.77,99.26) 120.77,99.53 120.95,99.71 JDOCK1.31 ; C274.2 195,100.91 v2(196.3,102.22) ; UC1.Y59 115.25,71.91 114.96,72.2 v2(114.96,72.24) ; v2(149.53,99.02) 149.45,99.1 JDOCK1.137 ; JDOCK1.63 129.95,99.37 v2(129.49,98.91) 129.45,98.94 JDOCK1.61 ; UC1.F30 UC1.D30 ; JDOCK1.51 126.95,99 v2(126.86,98.91) ; v2(115.07,99.21) 115.07,99.22 115.07,99.62 114.95,99.74 JDOCK1.7 ; UC1.AH42 v2(126.14,68.01) ; UC1.AL39 127.47,66.22 UC1.AL40 ; JDOCK1.14 116.45,109.68 v2(116.57,109.81) ; UC1.D21 139.04,80.14 139.36,79.82 ; v2(121.89,99.19) 121.91,99.19 122.45,99.73 JDOCK1.37 ; UC1.AG11 144.81,68.13 ; 144.81,68.13 UC1.AF12 ; v2(143.24,83.3) UC1.A14 143.24,82.46 143.36,82.34 143.36,81.63 UC1.C14 143.75,81.21 UC1.D14 ; v2(148.85,82.2) 148.88,82.16 UC1.B4 ; JDOCK1.20 117.95,109.82 v2(117.96,109.83) ; v2(148.83,63.7) 148.83,63.69 148.58,63.44 UC1.AR5 ; 145.95,99.29 146.36,99.29 146.45,99.38 JDOCK1.125 ; 145.95,99.29 145.95,98.91 146.33,98.53 v2(146.33,97.84) ; 145.95,99.29 JDOCK1.123 ; v2(138.66,99.33) 138.66,99.47 138.95,99.76 JDOCK1.95 ; UC1.AU24 137.09,62.46 v2(137.4,62.78) 137.4,62.97 137.73,63.3 UC1.AR23 ; UC1.F38 UC1.D38 ; v2(120.95,109.83) JDOCK1.32 ; UC1.AJ41 126.53,66.97 v2(126.81,66.97) 126.81,67.39 UC1.AH40 ; JDOCK1.114 143.45,110.07 v2(143.12,110.4) ; UC1.AL40 127.73,65.31 UC1.AN39 ; UC1.AL40 126.75,65.51 126.75,65.51 v2(126.73,65.52) ; JDOCK1.81 134.45,99.6 134.09,99.24 v2(133.99,99.24) ; v2(143.02,61.23) 143.18,61.23 UC1.AV14 ; JDOCK1.13 116.45,99.35 v2(116.31,99.21) ; UC1.AJ25 v2(136.7,67.76) ; v2(129.91,109.89) 129.95,109.85 JDOCK1.64 ; UC1.J59 115.25,77.88 114.92,78.21 v2(114.92,78.2) ; JDOCK1.88 v2(135.95,109.83) ; UC1.G8 147.09,79.22 v2(147.32,79.22) 147.44,79.22 147.72,78.94 UC1.G6 147.9,78.89 v2(148.25,79.25) 148.6,78.89 UC1.G5 ; v2(113.94,99.17) 113.45,99.66 JDOCK1.1 ; UC1.F46 UC1.D46 ; JDOCK1.49 125.45,99.72 125.79,99.38 125.79,99.01 125.7,98.92 ; UC1.AJ29 134.43,67.2 UC1.AH28 135.08,67.2 UC1.AJ27 ; v2(112,74.88) UC1.P63 UC1.P62 ; v2(147.55,76.91) 147.34,76.7 UC1.L7 ; v2(123.81,109.96) 123.95,109.82 JDOCK1.44 ; v2(114.84,63.3) 114.71,63.18 UC1.AT61 114.22,63.12 UC1.AT62 113.11,63.12 112.95,62.97 UC1.AT63 112.43,62.97 v2(111.96,62.5) ; UC1.AH51 120.12,67.2 UC1.AJ52 ; UC1.AH51 120.77,67.2 UC1.AJ50 ; UC1.AH51 v2(120.94,68.01) ; JDOCK1.138 149.45,110 149.91,110.46 v2(150.1,110.46) ; JDOCK1.75 132.95,98.24 v2(133.07,98.12) ; v2(140.53,110.5) 140.45,110.43 JDOCK1.102 ; UC1.AF17 141.96,68.86 v2(142.23,69.13) 142.78,68.58 UC1.AF15 ; v2(196.9,102.22) 196.9,102.13 196.08,101.31 C275.2 ; v2(61.33,75.2) 61.01,75.2 60.76,74.94 60.76,74.57 JEDP1.19 ; JDOCK1.113 143.45,99.64 143.25,99.45 143.25,98.46 142.21,97.42 v2(142.01,97.42) 141.9,97.54 141.9,99.62 141.95,99.67 JDOCK1.107 ; UC1.C20 139.76,81.88 139.91,82.03 v2(139.91,82.31) 139.56,82.31 UC1.B20 ; v2(131.45,109.97) JDOCK1.70 ; 125.7,98.92 v2(125.7,98.89) ; 125.7,98.92 125.63,98.92 124.95,99.6 JDOCK1.47 ; JDOCK1.26 119.45,109.85 v2(119.46,109.85) ; UC1.D59 115.37,80.94 114.77,81.54 114.77,81.68 114.61,81.85 UC1.B60 ; v2(122.35,109.85) 122.35,109.77 122.45,109.67 JDOCK1.38 ; JDOCK1.19 117.95,99.31 v2(117.86,99.21) ; UC1.F34 UC1.D34 ; UC1.AR11 145.05,62.96 144.82,62.73 v2(144.49,62.73) 144.44,62.67 143.81,62.67 UC1.AT13 ; v2(61.76,72.47) 61.86,72.57 61.86,73.12 JEDP1.20 ; v2(151.87,62.03) 151.74,62.16 UC1.AU1 ; UC1.Y10 145.47,72.05 143.93,72.05 v2(143.42,71.54) ; v2(123.05,68.05) UC1.AH46 ; JEDP1.3 53.21,71.93 53.21,72.25 53.76,72.8 53.76,73.15 v2(53.91,73.3) ; v2(131.27,99.19) 131.45,99.37 JDOCK1.69 ; v2(189.05,101.7) 189.05,101.29 188.9,101.14 C279.2 ; UC1.F26 UC1.D26 ; UC1.AH32 v2(132.64,68.01) ; UC1.AH38 v2(128.74,68.01) ; UC1.AJ60 115.09,66.86 v2(115.37,67.14) ; v2(146.45,109.83) JDOCK1.126 ; UC1.AU59 UC1.AV59 ; UC1.L17 141.55,76.21 v2(141.52,76.21) 141.51,76.21 UC1.L18 140.73,76.35 v2(140.73,76.21) 140.49,76.21 UC1.L20 ; JDOCK1.57 128.45,99.11 v2(128.28,98.93) 127.95,99.26 JDOCK1.55 ; JDOCK1.87 135.95,99.65 135.59,99.29 v2(135.59,99.28) ; v2(132.95,110.01) JDOCK1.76 ; UC1.AH20 139.97,67.34 140.14,67.17 140.54,67.17 140.71,67.34 UC1.AH19 140.74,67.11 v2(140.98,66.87) ; UC1.D18 140.77,81.43 UC1.C18 ; v2(112.11,81) 112.27,80.84 UC1.D63 112.7,80.78 UC1.D62 ; v2(145.02,110.01) 144.96,109.94 144.96,109.53 144.88,109.45 JDOCK1.120 ; UC1.AH22 139.29,67.67 UC1.AG21 139.32,67.26 v2(139.44,67.15) ; UC1.F50 UC1.D50 ; UC1.F54 UC1.D54 ; JDOCK1.43 123.95,99.53 124.66,98.82 v2(124.66,98.83) ; v2(145.97,64.41) 145.97,64.41 145.94,64.41 145.62,64.09 UC1.AP10 ; JEDP1.14 58.34,73.82 v2(58.34,74.08) 58.85,74.02 JEDP1.15 ; UC1.AA1 v2(151.81,71.1) ; C24.2 192.41,80.62 193.1,79.92 v4(193.73,79.92) ; JDOCK1.101 140.45,99.35 v2(140.51,99.29) ; PQ807.1 148.78,11.26 149.02,11.02 v2(149.02,10.58) ; JDOCK1.82 134.45,109.81 v2(134.47,109.83) ; UC1.F42 UC1.D42 ; UC1.F58 115.9,79.27 v2(115.77,79.13) 116.19,78.71 UC1.H57 ; UC1.N10 145.54,75.52 145.15,75.13 v2(145.15,74.87) 145.45,74.57 UC1.R10 ; v2(201.73,2.59) 202.24,3.1 202.24,3.83 202.35,3.95 PQ813.4 ; UC1.AH49 v2(122.24,68.01) ; UC1.AD21 139.59,69.67 ; JDOCK1.108 141.95,110.32 v2(141.8,110.48) ; JDOCK1.119 144.95,99.34 v2(145.01,99.28) ; v2(147.55,98.58) 147.7,98.58 148.13,99.01 148.13,99.47 147.95,99.65 JDOCK1.131 ; UC1.AJ23 UC1.AG23 138.16,68.11 v2(137.79,68.48) ; JEDP1.35 68.33,77.22 68.58,77.69 68.58,77.74 v2(68.59,77.75) 68.6,77.77 68.94,77.77 69.32,77.39 JEDP1.37 ; UC1.AR52 119.51,63.3 118.94,62.73 UC1.AU53 ; UC1.AH30 v2(133.94,68.01) ; JEDP1.17 59.77,74.42 58.76,75.42 v2(58.27,75.42) ; v2(141.48,78.57) 141.36,78.57 141.05,78.87 UC1.G18 ; UC1.G3 150.27,78.33 v2(150.27,78.22) ; JDOCK1.8 114.95,109.77 v2(114.91,109.81) ; v2(119.45,99.26) JDOCK1.25
  BOTTOM w0.279: UC1.L20 140.02,76.68 139.41,76.68 UC1.J22 ; UC1.L58 v2(116.42,76.69)
  BOTTOM w0.305: JDEG1.1 8.67,42.98 8.56,43.09 8.29,43.09 8.13,42.93 v2(8.13,42.66)
  BOTTOM w0.381: v2(185.47,96.95) 186.06,97.54 C88.2 ; U13.7 185.45,85.78 185.06,85.39 v2(185.06,85.34) ; v2(205.89,61.05) 206.39,60.55 JMINI2.43 ; PQ813.1 205.48,5.25 205.84,4.89 v2(205.96,4.89) ; PQ807.4 v2(147.48,14.96) ; C319.2 146.86,97.84 v2(146.33,97.84) ; v2(206.36,56.87) 206.84,57.35 JMINI2.35 ; v2(204.26,87.4) 204.26,87.04 204,86.77 U11.7
  BOTTOM w0.406: JDEG1.11 14.17,40.6 13.97,40.8 13.36,40.8 v2(13.35,40.82) ; JMDP1.14 273.49,89.75 JMDP1.13 ; v2(210.49,20.14) 210.63,20 JMINI1.21 ; JMINI2.29 206.86,54.95 206.46,54.56 v2(205.94,54.56) 206.35,54.15 JMINI2.27 ; JMINI2.15 205.46,46.15 v2(205.03,45.72) ; JMINI1.27 210.95,22.4 v2(210.54,22.81) 210.93,23.2 JMINI1.29 ; JMINI2.9 205.26,43.75 205.07,43.56 v2(205.07,43.55) ; JMDP1.8 267.8,91.55 H17.1 ; JMINI1.15 210.78,14.4 209.82,15.37 v2(209.82,15.6) ; v2(210.52,25.31) 210.81,25.6 JMINI1.35 ; JMINI2.21 206.45,51.75 v2(206.33,51.87) ; JDEG1.12 7.74,40.3 v2(8.24,40.3) ; JMINI1.9 210.78,12 210.67,11.89 v2(210.31,11.89) ; v2(209.8,28.13) 210.46,28.13 211.13,28.8 JMINI1.43
  BOTTOM w0.457: C132.2 199.82,75.58 199.67,75.42 v2(199.5,75.42) ; v2(2.06,40.5) 2.39,40.83 2.46,40.83 3.34,41.71 PQ832.3 ; v2(174.51,76.63) 174.51,77.33 JTAA1.22
  BOTTOM w0.508: R108.2 67.07,73.6 v2(67.07,71.78) ; v2(127.28,93.45) 126.9,93.83 CC78.2 ; U48.2 184.06,99.84 C333.2 v2(184.06,101.88) ; v2(97.37,87.19) 97.54,87.35 PU2.4 ; v2(272.49,31.47) 272.5,31.48 JSD1.10 ; v2(105.66,72.17) 105.66,71.84 PC904.2 ; 193.45,101.96 193.6,101.81 C273.2 ; PC916.2 102.06,78.69 v2(102.06,79.11) ; C336.2 20.26,38.1 v2(20.36,38) ; v2(77.36,65.7) PC503.1 ; RC158.2 153.33,86.96 v2(153.44,87.07) 153.44,87.86 CC450.2 ; JUSB2.7 v2(214.6,98.57) ; v2(250.43,30.77) 249.91,30.25 JSD1.22 ; JMINI3.40 41.38,13.05 41.9,12.53 v2(41.9,12.51) ; v2(179.82,84.11) 179.82,83.87 180.2,83.49 C97.2 ; C21.2 205.21,76.52 v2(205.44,76.75) ; v2(125.53,94.88) 124.86,94.88 R268.2 C310.2 ; Q31.3 233.71,88.82 233.71,87.57 C284.2 ; JDIMM2.206 134.86,33.84 v2(134.86,31.12) ; RC2.2 164.64,56.95 165.27,57.57 v2(165.38,57.57) ; v2(195.76,72.53) 195.59,72.36 C392.1 ; C8.2 197.76,75.95 v2(197.99,75.95) ; C16.2 195.68,86.08 v2(195.54,86.22) ; CC76.2 132.85,91.5 132.46,91.11 v2(132.46,90.09) 131.27,90.09 130.76,90.6 RC47.2 RC46.2 ; C193.2 231.27,98.26 v2(231.47,98.06) ; Q6.3 181.6,88.86 v2(180.78,88.86) ; 168.64,71.73 168.09,71.73 167.71,71.35 167.11,71.35 v2(166.66,71.8) ; v2(156.07,95.54) 155.75,95.54 155.03,94.82 CC47.2 ; v2(95.26,75.55) 95.26,75.22 PC907.2 ; v2(164.96,60.02) 165.03,60.09 CC30.2 RC52.2 ; v2(178.55,79.86) 178.88,80.19 C76.1 ; v2(139.37,89.58) 139.37,89.39 139.66,89.1 CC58.2 ; v2(105.92,6.13) PC202.2 PC203.2 ; v2(64.12,72.77) C65.2 C52.2 ; v2(248.1,21.31) 248.72,21.31 248.93,21.09 JSD1.3 ; C433.2 197.46,75.03 v2(197.2,75.29) ; JMINI3.27 49.68,18.25 49.91,18.02 49.91,17.68 49.68,17.45 JMINI3.29 47.25,17.45 v2(46.66,16.87) ; JMINI3.21 47.33,20.65 46.56,21.42 v2(46.56,21.51) ; JDIMM1.205 v2(123.95,30.89) ; C14.2 196.18,84.96 C22.2 195.68,84.46 v4(195.68,83.17) ; v2(87.73,67.28) PC509.1 ; RC233.2 RC232.2 107.99,69.68 v2(107.81,69.51) ; v2(162.13,57.12) 161.85,56.84 RC78.1 ; v2(269.37,77.7) 269.37,78.6 268.85,79.12 D33.1 ; JMINI3.4 40.94,30.65 41.71,29.88 v2(41.71,29.5) ; v2(36.47,18.77) 36.59,18.65 JMINI3.26 ; v2(100.46,79.1) 100.46,78.55 PC921.2 ; C29.2 199.71,83.95 v4(199.58,83.82) ; JSD1.20 248.93,5.08 v2(247.96,4.11) ; v2(30.76,40.93) 31.15,41.33 PQ827.3 ; PC401.2 v2(97.71,98.78) ; JSD1.23 v2(257.26,4.37) ; JLOM1.14 262.47,96.06 264.92,93.61 ; PC811.2 156.77,10.39 v2(156.39,10.01) ; C393.2 213.63,70.62 v2(213.45,70.45) ; v2(95.26,72.2) 95.26,71.87 PC910.2 ; v2(154.31,91.77) 154.31,91.4 154.39,91.31 CC55.2 ; v2(143.36,55.04) 143.31,55.09 RC237.2 RC168.2 ; v2(79.81,69.32) 79.81,69.5 80.12,69.81 RC127.1 ; v2(212.08,94.84) 212.08,94.63 211.28,93.83 D16.1 ; v2(42.18,9.92) 42.18,9.45 41.78,9.05 JMINI3.50 ; v2(229.29,85.24) 229.29,84.96 229.57,84.68 C447.2 229.57,83.78 229.06,83.27 C446.2 ; v2(197.68,101.14) 197.35,100.81 C276.2 ; PC915.2 96.99,71.86 v2(96.99,72.19) ; v4(197.63,83.17) 197.6,83.15 C11.2 ; CC77.2 135.78,88.26 CC7.1 v2(136.12,87.15) ; PC914.2 98.72,71.86 v2(98.72,72.19) ; v2(193.75,90.98) 193.97,91.2 R438.2 ; v2(93.78,98.02) 93.38,97.62 C3.2 ; v2(96.99,75.54) 96.99,75.21 PC919.2 ; PC803.2 206.45,7.47 v2(206.69,7.71) ; PC927.2 102.18,71.86 v2(102.18,72.19) ; PC924.2 96.95,78.61 v2(96.95,79.03) ; JSD1.25 v2(270.2,3.01) ; PC918.2 98.72,75.21 v2(98.72,75.54) ; v2(100.44,75.54) 100.44,75.21 PC917.2 ; PC400.2 102.68,93.57 PC402.2 PR401.2 103.87,92.76 v2(104.24,93.14) ; CC42.2 140.87,88.82 RC236.1 141.81,89.21 v2(142.23,89.64) ; v2(192.81,101.59) 192.81,100.29 C278.2 ; v2(73.62,73.15) 73.81,72.96 CE1.2 CE2.2 ; PC730.2 96.9,80.37 97.36,79.91 v2(97.36,79.88) 97.46,79.98 97.54,79.98 97.79,80.24 PR743.2 ; v2(137.91,89.67) 137.91,88.89 CC6.1 ; Q10.3 211.39,91.34 v2(211.38,91.35) ; C277.2 191.19,100.7 190.94,100.94 v2(190.94,101.7) ; C5.2 178.68,84.1 v2(178.68,84.56) ; PC913.2 100.44,71.86 v2(100.44,72.19) ; RC115.2 v2(112,89.55) ; v4(193.73,83.17) 193.12,83.17 C9.2 ; JMINI3.15 49.38,26.25 49.64,26.52 v2(49.64,28.17) 49.16,28.65 JMINI3.9 ; v2(248.17,13.91) 248.26,14 JSD1.6 ; PC806.2 204.79,6.07 205.02,5.84 205.56,5.84 v2(205.59,5.82) ; RC241.2 RC240.2 107.43,73.76 v2(107.37,73.82) ; v2(155.96,57.56) 155.83,57.43 CC1.1 CC2.1 ; JTAA1.21 JTAA1.22 ; C329.2 19.32,43.08 v2(19,43.08) 18.58,42.66 R313.1 18.17,42.49 R310.1 ; CE9.2 131.23,97.22 v2(131.23,98.12) ; v2(45.57,34.3) 46.53,34.3 46.94,34.7 JMINI3.53 ; v2(98.82,79.07) 98.82,78.47 PC923.2 ; JRTC1.2 277.13,35.78 276.36,35.01 v2(275.13,35.01) 275.13,34.34 275.8,33.67 JSD1.13 ; PC901.2 95.71,78.1 PC911.2 95.07,78.76 v2(95.07,79.03) ; C87.2 198.31,99.86 v2(198.31,101.14) ; v2(102.18,75.53) 102.18,75.2 PC929.2 ; v2(53.25,52.98) 53.48,53.21 ME1.1 ; CC4.1 56.81,60.63 v2(57.01,60.83) ; C23.2 198.93,83.17 v4(198.93,83.17) ; C389.2 204.43,71.16 204.43,70.56 v2(204.66,70.33) ; JSD1.24 v2(257.35,32.57) ; CE8.2 133.58,97.27 134.4,98.09 134.4,98.83 v2(133.99,99.24) ; v2(57.82,36.75) 58.35,36.22 JDIMM1.206 ; C63.2 60.68,71.74 C431.2 61.01,71.41 v2(61.77,71.41) ; v2(94.34,90.89) 94.4,90.96 PR403.2 94.46,92.13 PU400.1 ; v2(267.11,31.28) 268.35,32.52 JSD1.26 ; v2(163.97,59.42) 163.4,59.42 RC136.1 ; v2(207.23,24.98) 207.2,25.01 C257.2 ; v2(249.73,80.68) 249.1,80.05 248.59,80.05 248.21,80.43 C325.2 C326.2 ; v2(38.1,16.41) 39.06,15.45 JMINI3.34 ; v2(61.35,75.84) 61.35,75.96 61.07,76.24 61.07,76.27 JEDP1.43 ; C6.2 176.34,65.04 175.92,64.62 175.31,64.62 174.34,63.65 ST2.1 ; v2(162.48,92.81) 163.94,94.27 CC75.2 ; JRTC1.3 271.94,39.36 270.95,40.35 270.95,44.11 270.93,44.13 ; v2(41.45,21.31) 40.91,21.85 JMINI3.18 ; U1.4 167.49,88.49 R164.1 167.13,89.12 v2(167.7,89.69) ; v2(92.52,96.62) PC404.2 ; C93.2 209.92,81.81 v2(209.92,81.22) ; v2(109.59,67.98) 109.33,67.73 RC22.2 108.92,67.72 RC235.2 ; JDIMM2.205 198.33,33.85 v2(196.71,35.47) ; v4(194.38,83.82) 194.38,84.55 C28.2 ; CC3.1 57.71,57.21 v2(57.95,57.45) ; C382.2 v2(190.23,101.68) ; v2(103.91,72.19) 103.91,71.86 PC926.2 ; v2(108,87.35) 107.62,87.73 RC258.2 ; C323.2 C324.2 258.05,80.56 257.61,81 v2(257.61,81.25) ; C85.1 v2(178.3,76.17) ; D8.1 77.79,74.13 v2(77.46,74.46) ; v2(47.6,7.09) JMINI3.54 ; PR744.2 93,80.59 v2(92.61,80.98) 92.12,80.49 PC12.2 ; C258.2 208.1,25.44 208.52,25.02 v2(208.52,25.01) 209,25.49 C260.1 ; C432.2 197.22,72.52 v2(197.21,72.53) ; v2(196.33,8.46) 195.61,9.18 PQ816.3 ; D20.1 105.56,96.09 v2(105.56,96.58) ; U7.4 191.12,86.44 191.38,86.18 v2(191.82,86.18) ; RC169.2 v2(157.56,73.19) ; v2(280.11,36.96) 279.68,37.39 JRTC1.4 ; v2(105.73,79.12) 105.73,78.5 PC909.2 ; v2(247.52,16.93) 248.84,18.25 JSD1.21 ; JUSB1.7 v2(71.7,97.92) ; v2(103.91,75.53) 103.91,75.2 PC925.2 ; v2(105.65,75.53) 105.65,75.2 PC905.2 ; PC920.2 103.91,78.56 v2(103.91,79.11) ; v2(209.14,68.96) 209.37,69.19 C391.2 C390.2 ; JSD1.17 v2(272.5,2.69) ; v4(197.63,79.92) 197.47,79.92 197.27,79.72 C10.2 ; CMOS1.1 v2(53.59,51.84)
  vias: v2(0.5,38.76) v2(0.5,32.57) v2(0.5,26.38) v2(0.53,4.43) v2(3.07,9.09) v2(5.13,29.63) v2(5.13,26.45) v2(6,43.74) v2(6.3,2.45) v2(6.46,19.47) v2(6.46,10.71) v2(6.78,28.1) v2(8.37,29.69) v2(8.37,26.52) v2(9.93,43.54) v2(11.14,2.46) v2(11.24,43.74) v2(15.77,14.58) v2(15.8,13.78) v2(16.45,2.46) v2(16.48,43.74) v2(18.34,36.49) v2(18.4,34.65) v2(18.47,32.61) v2(20.35,36.52) v2(20.32,34.67) v2(20.35,32.61) v2(21.75,2.46) v2(21.9,44.21) v2(22.09,36.49) v2(22.15,34.65) v2(22.1,32.56) v2(23.1,16.61) v2(23.1,14.71) v2(23.23,12.61) v2(24.82,16.61) v2(24.82,14.77) v2(24.82,12.61) v2(26.53,16.61) v2(26.52,14.76) v2(26.47,12.61) v2(27.15,45.6) v2(27.06,2.46) v2(27.53,36.54) v2(32.09,47.87) v2(32.37,2.46) v2(35.17,29.44) v2(35.8,29.44) v2(35.84,28.8) v2(36.44,29.44) v2(36.56,50.96) v2(37.14,27.77) v2(37.68,2.46) v2(38.53,4.1) v2(40.44,54.77) v2(42.56,41.76) v2(42.65,27.83) v2(42.99,2.46) v2(43.79,20.44) v2(43.94,44.61) v2(44.78,40.35) v2(46.48,65.6) v2(46.46,44.2) v2(46.74,41.63) v2(48.3,2.46) v2(48.76,83.72) v2(48.82,74.02) v2(48.95,86.59) v2(49.76,14.15) v2(50.97,83.03) v2(51.04,76.43) v2(52.18,86.46) v2(52.5,84.49) v2(53.6,2.46) v2(54.83,87.63) v2(55.14,32.42) v2(55.17,30.45) v2(55.28,33.64) v2(55.8,8.41) v2(56.92,64.49) v2(57,15.61) v2(57.65,15.61) v2(58.91,2.46) v2(59.51,24.28) v2(59.62,29.82) v2(59.62,28.29) v2(59.75,21.76) v2(59.75,20.24) v2(62.25,24.39) v2(62.67,112.48) v2(62.67,106.52) v2(62.67,100.56) v2(62.67,94.61) v2(62.67,88.65) v2(62.82,22.02) v2(62.82,19.73) v2(63.21,29.82) v2(63.21,28.29) v2(63.93,89.97) v2(64.05,92.63) v2(64.22,2.46) v2(64.43,112.48) v2(64.45,101.89) v2(64.6,21.63) v2(64.6,20.11) v2(65.19,91.38) v2(65.75,29.69) v2(65.75,28.29) v2(66.27,78.94) v2(66.61,92.63) v2(67.06,24.44) v2(67.14,21.63) v2(67.14,20.11) v2(67.75,30.2) v2(67.75,27.91) v2(68.46,81.85) v2(68.5,24.49) v2(68.85,62.04) v2(68.8,21.63) v2(68.8,20.11) v2(69.02,29.82) v2(69.02,28.29) v2(69.53,2.46) v2(69.93,47.19) v2(69.87,24.48) v2(70.6,20.14) v2(70.92,82.12) v2(71.56,29.82) v2(71.56,28.29) v2(71.9,24.49) v2(73,16.29) v2(73.07,21.63) v2(73.07,20.11) v2(73.65,86.02) v2(73.71,24.49) v2(73.89,30.2) v2(73.89,27.91) v2(74.84,2.46) v2(74.88,21.63) v2(75.2,29.82) v2(75.2,28.29) v2(75.4,16.36) v2(75.67,88) v2(75.74,24.47) v2(75.97,84.35) v2(77.2,16.36) v2(77.42,21.63) v2(77.42,20.11) v2(77.52,24.42) v2(77.74,29.82) v2(77.74,28.29) v2(77.99,5.37) v2(78.35,3.85) v2(78.95,112.5) v2(78.93,22.02) v2(78.93,19.73) v2(78.97,101.92) v2(80.2,21.63) v2(80.2,20.11) v2(80.26,28.29) v2(80.67,99.31) v2(80.7,16.29) v2(80.78,112.48) v2(80.78,104.35) v2(81.13,98.72) v2(81.1,88.65) v2(81.33,99.31) v2(81.25,6.83) v2(81.51,62.74) v2(81.51,62.13) v2(81.51,61.01) v2(81.51,60.4) v2(81.75,98.69) v2(81.79,68.71) v2(81.9,67.6) v2(81.9,66.99) v2(81.9,66.31) v2(81.9,65.67) v2(81.9,65.06) v2(81.97,3.59) v2(82.22,5.24) v2(82.37,68.71) v2(82.52,67.62) v2(82.52,67.01) v2(82.52,66.32) v2(82.52,65.68) v2(82.52,65.07) v2(82.9,30.58) v2(82.9,29.05) v2(82.9,27.53) v2(82.95,99.1) v2(82.97,68.71) v2(83.17,67.61) v2(83.17,66.95) v2(83.19,66.31) v2(83.17,65.65) v2(83.21,65.04) v2(84.32,22.18) v2(84.32,20.66) v2(84.32,19.13) v2(85.45,2.46) v2(85.62,79.73) v2(85.82,30.58) v2(85.82,29.05) v2(86.21,79.73) v2(86.28,22.18) v2(86.28,20.66) v2(86.28,19.13) v2(86.79,79.73) v2(86.97,76.68) v2(87.38,79.73) v2(87.91,76.56) v2(88.06,21.42) v2(88.06,19.9) v2(88.2,96.93) v2(88.6,79.73) v2(89.1,73.46) v2(89.22,30.58) v2(89.22,29.05) v2(89.52,72.81) v2(89.66,74.47) v2(89.99,73.43) v2(90.48,74.47) v2(90.75,30.58) v2(90.75,29.05) v2(90.75,27.53) v2(90.81,73.43) v2(90.76,2.46) v2(91.36,22.18) v2(91.36,20.66) v2(91.36,19.13) v2(91.57,97.73) v2(92.27,30.96) v2(92.27,28.67) v2(92.31,21.42) v2(93.08,67.67) v2(93.4,29.82) v2(93.4,22.56) v2(93.4,20.28) v2(95.06,67.7) v2(95.12,30.58) v2(95.12,29.05) v2(95.1,22.18) v2(95.1,20.66) v2(95.1,19.13) v2(95.6,110.95) v2(95.6,104.35) v2(96.07,2.46) v2(97.07,30.58) v2(97.07,29.05) v2(97.56,22.18) v2(97.56,20.66) v2(98.52,30.58) v2(98.52,29.05) v2(98.93,108.08) v2(99.35,30.6) v2(100,19.11) v2(100.8,29.82) v2(100.8,28.29) v2(101.12,106.96) v2(101.14,21.42) v2(101.14,19.9) v2(101.27,102.08) v2(101.38,2.46) v2(101.91,102.08) v2(102.01,24.53) v2(102.1,16.23) v2(102.54,102.08) v2(102.58,30.2) v2(102.58,27.91) v2(102.77,16.23) v2(103.03,21.42) v2(103.03,19.9) v2(103.24,54.26) v2(103.18,52.55) v2(103.3,24.59) v2(103.91,109.24) v2(104.42,24.59) v2(104.61,29.82) v2(104.61,28.29) v2(104.8,19.11) v2(105.01,54.26) v2(105.01,52.36) v2(105.56,52.57) v2(105.57,21.42) v2(105.57,19.9) v2(106.02,112.48) v2(106.6,19.11) v2(106.65,30.47) v2(106.69,2.46) v2(107.15,29.82) v2(107.15,28.29) v2(107.2,24.49) v2(107.69,21.8) v2(107.69,19.52) v2(108,60.38) v2(108.1,24.34) v2(108.32,64.38) v2(108.94,29.82) v2(108.94,28.29) v2(108.96,21.42) v2(108.96,19.9) v2(109.14,61.92) v2(109.7,65.52) v2(110.05,94.34) v2(110.41,63.1) v2(110.35,16.17) v2(110.63,94.39) v2(110.66,30.71) v2(110.78,61.27) v2(110.92,24.46) v2(111.2,94.58) v2(111.26,112.48) v2(111.48,29.82) v2(111.48,28.29) v2(111.5,19.9) v2(111.82,56.86) v2(111.75,24.48) v2(112,2.46) v2(112.66,55.03) v2(112.94,19.23) v2(113.15,30.2) v2(113.15,27.91) v2(113.2,58.23) v2(113.31,91.74) v2(113.5,24.59) v2(113.95,21.42) v2(113.95,19.9) v2(114.04,56.41) v2(114.15,53.68) v2(114.35,5.63) v2(115.05,5.56) v2(115.06,24.56) v2(115.18,29.82) v2(115.18,28.29) v2(115.42,57.79) v2(115.41,10.39) v2(115.81,5.56) v2(116,10.74) v2(116.34,15.85) v2(116.45,5.56) v2(116.49,112.48) v2(116.58,21.42) v2(116.58,19.9) v2(116.91,56.44) v2(117.04,81.34) v2(117.04,24.51) v2(117.3,92.1) v2(117.32,2.97) v2(117.72,29.82) v2(118.29,57.82) v2(118.28,21.8) v2(118.28,19.52) v2(118.36,91.36) v2(119.52,81.35) v2(119.55,21.42) v2(119.55,19.9) v2(119.64,29.82) v2(120.03,85.42) v2(120.62,88.34) v2(121.39,92.94) v2(121.73,112.48) v2(122.41,81.33) v2(122.89,87.1) v2(123.02,58.52) v2(123.28,91.92) v2(123.85,83.82) v2(124.3,2.96) v2(124.9,81.35) v2(125.11,91.93) v2(126.1,59.36) v2(126.38,90.61) v2(126.96,112.48) v2(127.42,81.33) v2(127.79,90.61) v2(127.89,72.77) v2(129.59,84.73) v2(129.93,81.33) v2(130.4,2.96) v2(130.9,54.67) v2(130.9,54.09) v2(132.2,112.48) v2(132.44,81.33) v2(132.95,57.79) v2(132.96,56.04) v2(134.58,56.24) v2(134.58,53.68) v2(134.58,52.38) v2(134.95,81.33) v2(136.54,56.93) v2(136.54,54.98) v2(136.5,2.96) v2(137.08,24.56) v2(137.2,22.24) v2(137.2,20.72) v2(137.22,16.26) v2(137.26,109.85) v2(137.44,112.48) v2(137.45,81.33) v2(137.64,84.71) v2(137.77,29.67) v2(138.04,16.19) v2(138.57,56.93) v2(138.55,55.04) v2(139.54,22.62) v2(139.54,20.34) v2(139.6,24.58) v2(139.9,16.23) v2(139.97,29.67) v2(139.97,28.15) v2(140.17,97.42) v2(140.2,55.03) v2(140.67,93.01) v2(141.1,92.56) v2(141.17,22.24) v2(141.17,20.72) v2(141.7,16.19) v2(142.28,56.28) v2(142.28,54.33) v2(142.51,29.67) v2(142.51,28.15) v2(142.64,16.19) v2(142.67,112.48) v2(143.38,111) v2(143.56,16.15) v2(143.71,24.46) v2(143.71,22.24) v2(143.71,20.72) v2(144.4,3.77) v2(144.5,30.05) v2(144.5,27.77) v2(144.49,5.64) v2(145.24,15.92) v2(145.77,29.67) v2(145.77,28.15) v2(146.02,111.16) v2(146.17,15.92) v2(146.51,22.24) v2(146.51,20.72) v2(146.72,7.14) v2(147.91,112.48) v2(148.31,29.67) v2(148.31,28.15) v2(148.51,84.89) v2(148.84,6.32) v2(148.9,16.33) v2(149.06,22.24) v2(149.06,20.72) v2(149.07,4.19) v2(149.65,0.5) v2(150.63,30.05) v2(150.63,27.77) v2(151.33,22.24) v2(151.33,20.72) v2(151.38,52.04) v2(151.89,29.67) v2(151.89,28.15) v2(153.14,112.48) v2(153.87,22.24) v2(153.87,20.72) v2(154.43,108.94) v2(154.45,29.67) v2(154.45,28.15) v2(154.53,16.44) v2(154.75,0.5) v2(155.14,22.62) v2(155.14,20.34) v2(155.22,16.42) v2(156.65,22.24) v2(156.65,20.72) v2(156.97,28.15) v2(157.05,16.39) v2(158.4,112.5) v2(159.27,24.52) v2(159.27,23) v2(159.27,21.47) v2(159.27,19.95) v2(159.85,0.5) v2(159.92,97.03) v2(160.62,109.76) v2(161.16,27.56) v2(161.19,23) v2(161.19,21.47) v2(161.19,19.95) v2(161.49,101.12) v2(161.98,108.05) v2(162.04,104.24) v2(162.04,103.29) v2(163.01,24.52) v2(163.01,23) v2(163.01,21.47) v2(163.83,88.8) v2(163.78,85.04) v2(164.25,30.45) v2(164.25,28.93) v2(164.43,88.8) v2(164.95,0.5) v2(165.01,108.34) v2(165.06,88.8) v2(165.42,109.79) v2(165.61,24.58) v2(165.71,23) v2(165.71,21.47) v2(165.71,19.95) v2(165.91,104.3) v2(166.85,30.45) v2(166.85,28.93) v2(166.85,27.4) v2(167.95,23) v2(167.95,21.47) v2(168,106.27) v2(168.57,78.93) v2(168.71,30.83) v2(168.71,28.55) v2(168.78,110.93) v2(168.78,104.35) v2(168.81,20.71) v2(168.94,81.64) v2(169.08,76.33) v2(169.82,87.22) v2(169.78,21.86) v2(169.78,19.57) v2(169.85,29.69) v2(170.05,0.5) v2(170.95,99.1) v2(171.05,23) v2(171.05,21.47) v2(171.05,19.95) v2(171.22,30.45) v2(171.22,28.93) v2(171.29,82.46) v2(171.93,87.2) v2(172.61,23) v2(172.61,20.71) v2(172.78,30.45) v2(172.78,28.93) v2(174.02,87.25) v2(174.8,30.45) v2(174.8,28.93) v2(175.15,0.5) v2(176.2,96.93) v2(176.7,90.14) v2(176.66,77.23) v2(177.1,21.42) v2(177.1,19.9) v2(177.3,29.69) v2(177.3,28.17) v2(177.45,24.48) v2(177.94,90.27) v2(178.57,19.18) v2(178.78,15.93) v2(179.17,73.81) v2(179.64,21.42) v2(179.64,19.9) v2(180.04,30.07) v2(180.04,27.78) v2(180.9,64.03) v2(180.9,63.4) v2(180.91,62.75) v2(180.86,24.49) v2(181.07,0.7) v2(181.3,19.13) v2(181.45,99.1) v2(181.37,29.69) v2(181.37,28.17) v2(182.18,21.42) v2(182.18,19.9) v2(182.55,14.07) v2(182.63,75.46) v2(183.24,76.63) v2(183.24,76.05) v2(183.24,75.46) v2(183.24,74.88) v2(183.45,21.8) v2(183.45,19.52) v2(183.62,112.48) v2(183.62,104.35) v2(183.62,29.69) v2(183.62,28.17) v2(183.69,12.1) v2(183.76,24.58) v2(185.18,107.2) v2(185.5,21.42) v2(185.5,19.9) v2(185.74,29.69) v2(185.74,28.17) v2(186.23,12.67) v2(186.36,15.02) v2(186.38,0.7) v2(186.78,112.48) v2(186.78,106.79) v2(186.83,19.29) v2(187.22,67.46) v2(187.69,24.49) v2(188.04,21.42) v2(188.04,19.9) v2(188.19,67.46) v2(188.18,29.69) v2(188.18,28.17) v2(189.82,21.42) v2(189.82,19.9) v2(190.53,30.07) v2(190.53,27.78) v2(190.81,95.48) v2(191.31,90.93) v2(191.7,0.7) v2(191.86,29.69) v2(191.86,28.17) v2(192.29,23.52) v2(192.36,21.42) v2(192.36,19.9) v2(192.46,32.87) v2(194.17,64.05) v2(194.41,61.38) v2(194.41,60.74) v2(194.41,60.11) v2(194.41,59.47) v2(194.41,58.84) v2(194.41,58.2) v2(194.36,29.69) v2(194.36,28.17) v2(194.5,24.68) v2(194.74,21.8) v2(194.81,64.05) v2(195,61.38) v2(195,60.74) v2(195,60.11) v2(195,59.47) v2(195,58.84) v2(195,58.2) v2(195.76,62.2) v2(195.76,61.57) v2(195.76,60.93) v2(195.76,60.3) v2(195.76,59.66) v2(195.78,59.05) v2(195.78,58.42) v2(196.01,21.42) v2(196.01,19.9) v2(196.39,62.2) v2(196.39,61.57) v2(196.39,60.93) v2(196.39,60.3) v2(196.39,59.66) v2(196.47,49.58) v2(196.49,48.79) v2(196.53,29.69) v2(196.53,28.17) v2(197,61.42) v2(197.03,16.1) v2(197.02,0.7) v2(197.23,49.61) v2(197.21,48.79) v2(197.43,19.41) v2(197.64,61.42) v2(197.69,95.5) v2(201.24,67.92) v2(201.28,38.77) v2(201.28,38.01) v2(201.28,37.25) v2(201.38,66.26) v2(201.4,65.66) v2(201.4,65.07) v2(201.4,64.49) v2(201.83,67.92) v2(202.34,0.7) v2(202.5,25.92) v2(202.62,51.79) v2(203.15,25.91) v2(203.77,25.88) v2(204.11,55.04) v2(204.11,54.43) v2(204.11,53.82) v2(204.85,107.19) v2(205.03,104.72) v2(204.99,84.51) v2(205.87,20.5) v2(205.96,111.89) v2(206.1,109.65) v2(206.63,67.44) v2(206.62,66.83) v2(207.65,0.7) v2(208.32,73.38) v2(212.97,0.7) v2(214,76.38) v2(214.49,73.67) v2(216.03,81.67) v2(216.05,77.55) v2(216.59,90.33) v2(217.74,74.18) v2(217.98,76.4) v2(218.29,0.7) v2(221.87,112.48) v2(221.87,101.92) v2(222.58,99.83) v2(222.57,97.83) v2(223.48,102.12) v2(223.6,0.7) v2(224.35,103.83) v2(225.29,93.89) v2(225.41,109.42) v2(225.59,111.68) v2(226.14,99.69) v2(226.14,99.11) v2(226.16,96.09) v2(226.63,108.46) v2(227.81,79.27) v2(227.81,78.69) v2(228.4,79.29) v2(228.4,78.69) v2(228.92,0.7) v2(229.08,111.62) v2(229.11,109.69) v2(229.92,90.89) v2(229.92,90.31) v2(230.51,90.89) v2(230.51,90.31) v2(231.95,74.9) v2(232.38,91.19) v2(232.59,74.9) v2(233.06,76.85) v2(233.06,76.21) v2(233.06,75.58) v2(233.7,112.5) v2(233.7,103.65) v2(233.69,76.85) v2(233.69,76.21) v2(233.69,75.58) v2(234.09,85.32) v2(234.24,0.7) v2(234.37,76.87) v2(234.37,76.24) v2(234.7,102.65) v2(234.7,85.32) v2(236.65,74.9) v2(236.65,73.19) v2(237.67,74.9) v2(237.67,73.19) v2(239.56,0.7) v2(244.87,0.7) v2(250.19,0.7) v2(251.45,78.59) v2(251.45,77.11) v2(252.53,77.57) v2(253.54,78.65) v2(253.64,77.27) v2(255.51,0.7) v2(256.34,21.63) v2(256.32,19.94) v2(256.34,18.26) v2(257.99,21.63) v2(257.98,19.94) v2(257.99,18.26) v2(259.7,21.69) v2(259.69,20) v2(259.7,18.33) v2(260.55,32.55) v2(260.68,24.56) v2(260.82,0.7) v2(261.19,32.55) v2(261.82,32.55) v2(262.59,17.45) v2(263.78,80.67) v2(265.02,29.46) v2(265.06,92.8) v2(265.35,90.78) v2(266.08,83.68) v2(266.14,0.7) v2(266.17,83.06) v2(266.33,87.08) v2(267.53,94.58) v2(267.46,14.3) v2(267.97,19.41) v2(267.97,18.77) v2(267.97,18.14) v2(268.12,84.95) v2(268.77,90.6) v2(269.28,93.43) v2(269.49,9.8) v2(270.35,44.28) v2(270.97,10.77) v2(271.16,67.91) v2(271.46,0.7) v2(271.72,68.17) v2(271.82,84.05) v2(271.82,83.41) v2(272.26,35.42) v2(272.63,36.04) v2(272.8,34.84) v2(272.9,7.77) v2(272.96,35.42) v2(273.38,36) v2(273.49,34.84) v2(273.63,35.42) v2(275.12,35.76) v2(275.53,85.04) v2(276.29,94.24) v2(276.29,87.06) v2(276.45,68.02) v2(277.26,97.15) v2(278.08,83.73) v2(278.22,46.09) v2(278.17,3.19) v2(278.23,1.47) v2(278.64,68.06) v2(278.6,43.65) v2(280.15,85.23) v2(280.24,47.35) v2(280.47,42.99) v2(280.54,4.43) v2(280.56,96.34) v2(282.09,35.08) v2(282.09,30.43) v2(282.12,7.78) v2(282.38,45.17) v2(282.99,52.72) v2(283.4,97.15) v2(283.4,95.55) v2(283.38,49.58) v2(283.38,40.92) v2(283.6,25.23) v2(283.59,20.14) v2(283.59,15) v3(58.39,9.4) v3(58.42,8.75) v3(59.06,9.38) v3(59.06,8.75) v3(59.06,8.11) v3(59.69,9.38) v3(59.69,8.75) v3(59.69,8.11) v3(59.69,7.48) v3(60.33,9.38) v3(60.33,8.75) v3(60.33,8.11) v3(60.33,7.48) v3(60.96,9.38) v3(60.96,8.75) v3(60.96,8.11) v3(60.96,7.48) v3(72.62,4.75) v3(73.25,4.75) v3(73.39,64.17) v3(73.37,63.54) v3(73.37,62.9) v3(73.37,62.27) v3(74.3,4.75) v3(74.93,4.75) v3(75.91,15.15) v3(75.91,14.52) v3(75.93,13.88) v3(85.93,59.31) v3(86.56,59.31) v3(87.2,59.31) v3(87.83,59.28) v3(91.49,8.99) v3(92.13,8.99) v3(92.76,8.99) v3(94.12,58.26) v3(94.78,58.24) v3(95.42,58.24) v3(96.05,58.24) v3(96.13,8.99) v3(96.69,58.24) v3(96.76,8.99) v3(96.93,67.32) v3(97.4,8.99) v3(98.55,67.28) v3(100.38,67.32) v3(102.23,67.28) v3(103.78,67.32) v3(105.09,15.82) v3(105.09,15.19) v3(105.56,67.32) v3(105.73,15.82) v3(105.73,15.19) v3(106.39,15.82) v3(106.39,15.19) v3(107.02,15.82) v3(107.02,15.19) v3(107.66,15.82) v3(107.66,15.19) v3(108.29,15.82) v3(108.29,15.19) v3(109,15.82) v3(109,15.19) v3(109.64,15.82) v3(109.64,15.19) v3(115.32,14.1) v3(115.27,13.44) v3(120.18,54.24) v3(120.69,54.69) v3(125.4,53.31) v3(125.91,53.82) v3(152.32,4.67) v3(152.32,4.04) v3(152.32,3.31) v3(152.32,2.68) v3(152.96,4.67) v3(152.96,4.04) v3(152.96,3.31) v3(152.96,2.68) v3(153.59,4.67) v3(153.59,4.04) v3(154.23,4.67) v3(154.23,4.04) v3(231.37,74.04) v3(237.16,74.08) v5(35.23,28.8) v5(58.85,6.01) v5(70.16,89.53) v5(77.65,14.45) v5(81.8,69.8) v5(85.76,62.62) v5(90.94,7.21) v5(93.08,4.8) v5(104.13,53.19) v5(106.48,14.58) v5(111.62,93.07) v5(114.73,4.47) v5(154.93,4.74) v5(187.69,67.86) v5(194.74,61.89) v5(195.82,57.82) v5(200.39,78.33) v5(206.22,104.65) v5(232.27,73.44) v5(234.81,77.57)
