# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JTAG_CLK: length 83
  TOP w0.102: v2(21.39,17.02) 20.95,16.58 U38.B56 ; RP1.7 8.48,4.54 7.85,3.91 6.41,3.91 v1(5.91,4.41) 4.1,6.22 4.1,7.02 5.04,7.96 v2(5.22,7.96)
  IN3 w0.122: v2(21.39,17.02) 20.92,16.55 19.53,16.55 18.97,17.1 18,17.1 16.97,18.14 13.83,18.14 13.29,17.59 12.18,17.59 11.2,16.61 9.88,16.61 8.67,15.4 8.67,9.46 7.18,7.96 v2(5.22,7.96)
  BOTTOM w0.102: v2(5.22,7.96) 6.02,7.16 7.4,7.16 8.23,7.99 8.23,20.62 4.62,24.23 4.62,31.93 3.63,32.92 3.63,34.29 5.16,35.81 6.99,35.81 7.65,35.15 10.26,35.15 10.52,35.41 10.52,36.04 11.61,37.13 11.61,37.79 11.15,38.25 11.15,39.83 11.14,39.83 10.9,40.07 10.9,41.09 11.01,41.19 11.32,41.19 11.72,41.59 11.72,42.14 11.67,42.19 JDEG1.7
JTAG_RST#: length 13.8
  TOP w0.102: U38.A57 18.75,14.33 18.5,14.58 18.5,14.75 18.5,14.75 v2(18.5,14.74) ; JTAG1.1 11.96,16.51 C362.1 R384.1 R380.2 12.32,18.45 v1(12.93,19.06) 12.64,19.35 v2(12.48,19.35)
  BOTTOM w0.102: v2(12.48,19.35) 12.69,19.35 15.27,16.78 15.74,16.78 17.77,14.74 v2(18.5,14.74)
JTAG_TDI: length 81.3
  TOP w0.102: v1(9.25,3.24) 8.92,3.57 v2(8.92,4) 8.98,4.06 RP1.8 ; v2(18.25,17.79) 18.45,17.79 18.92,17.33 U38.A51
  IN3 w0.122: v2(18.25,17.79) 17.37,18.68 11.73,18.68 11.44,18.97 10.32,18.97 9.48,18.12 9.48,17.02 8.17,15.71 8.17,10.53 7.11,9.47 6.19,9.47 5.87,9.16 5.33,9.16 4.31,8.13 4.31,6.93 4.52,6.72 4.94,6.72 4.98,6.75 5.69,6.75 5.75,6.69 7.73,6.69 8.92,5.51 v2(8.92,4)
  BOTTOM w0.102: v2(8.92,4) 8.62,4.29 8.62,6.6 8.69,6.67 8.69,20.88 8.31,21.26 8.31,22.02 6.3,24.03 6.3,25.89 7.59,27.19 7.59,28.68 5.26,31.01 5.26,33.68 5.54,33.96 7.04,33.96 7.16,34.09 9.93,34.09 11.02,35.18 11.02,35.86 12.19,37.03 12.19,39.89 12.06,40.02 12.06,41.22 12.38,41.54 12.9,41.54 12.97,41.6 12.97,42.16 12.92,42.2 12.92,42.2 12.67,42.45 JDEG1.9
JTAG_TDO: length 65.7
  TOP w0.102: v2(20.75,17.02) 20.69,17.08 U38.B55 ; v1(7.28,9.65) 7.76,9.17 v2(7.76,9.17) 7.98,8.95 R391.2
  IN3 w0.122: v2(20.75,17.02) 20.65,17.02 20.32,17.35 18.11,17.35 17.03,18.43 11.27,18.43 10.53,17.69 10.11,17.69 9.73,17.31 9.73,16.91 8.42,15.61 8.42,9.83 v2(7.76,9.17)
  BOTTOM w0.102: v2(7.76,9.17) 7.99,9.4 7.99,20.4 4.39,23.99 4.39,31.83 3.4,32.82 3.4,34.38 5.06,36.04 10.16,36.04 10.92,36.8 10.92,39.67 10.67,39.92 10.67,41.33 10.76,41.42 11.22,41.42 11.49,41.69 11.49,42.04 11.17,42.36 JDEG1.6
JTAG_TMS: length 78.1
  TOP w0.102: v2(6.38,9.05) 6.95,8.48 R385.2 ; U38.A53 18.55,16.33 v2(18.44,16.44)
  IN3 w0.122: v2(18.44,16.44) 18.19,16.44 16.75,17.89 13.93,17.89 13.39,17.35 12.28,17.35 11.3,16.36 10.28,16.36 8.92,15 8.92,9.31 7.1,7.49 5.08,7.49 4.8,7.77 4.8,8.19 5.03,8.42 5.75,8.42 v2(6.38,9.05)
  BOTTOM w0.102: JDEG1.8 12.17,42.18 11.95,41.96 11.95,41.5 11.83,41.38 11.83,39.47 11.38,39.01 11.38,38.4 11.84,37.95 11.84,36.99 10.74,35.9 10.74,35.25 10.41,34.92 7.68,34.92 6.94,34.19 5.44,34.19 5.03,33.77 5.03,30.92 7.37,28.58 7.37,27.51 6.07,26.21 6.07,23.93 8.08,21.93 8.08,21.16 8.46,20.78 8.46,7.86 7.14,6.54 6.41,6.54 5.78,5.9 5.47,5.9 4.41,6.97 4.41,8.34 5.12,9.05 v2(6.38,9.05)
KB_DET#: length 119.6
  TOP w0.102: v2(160.46,57.71) 161.56,58.8 v5(166.87,58.8) 168.36,58.8 168.72,58.44 168.72,55.52 169.78,54.46 174.73,54.46 175.44,53.75 175.44,48.2 179.35,44.28 179.35,23.77 180.05,23.07 180.05,17.04 179.6,16.6 v2(179.6,16.34) ; v2(152.77,61.32) 154.04,60.05 154.04,59.28 155.41,57.91 155.41,57.48 155.99,56.9 RP10.5 ; v2(205.58,6.46) 205.58,6.88 205.47,6.98 205.04,6.98 204.95,6.89 JKBTP1.16
  IN3 w0.122: v2(179.6,16.34) 180,15.94 180,9.69 183.37,6.32 189.46,6.32 190.47,7.34 190.47,8.84 190.97,9.34 196.63,9.34 197.03,8.94 197.03,7.77 198.98,5.82 204.5,5.82 205.14,6.46 v2(205.58,6.46)
  IN4 w0.084: v2(160.46,57.71) 159.47,58.7 156.57,58.7 153.53,61.73 153.19,61.73 v2(152.77,61.32)
  BOTTOM w0.076: UC1.AT3 150.25,62.55 150.76,62.55 150.92,62.7 150.92,62.95 151.11,63.15 151.41,63.15 151.65,62.91 152.11,62.91 152.77,62.25 v2(152.77,61.32)
LAN_ACTLED_YEL#: length 11.7
  TOP w0.102: R274.1 242.41,94 240.35,94 v1(240.3,93.95) 240.09,93.75 232.65,93.75 232.32,93.42 Q32.6
LAN_ACTLED_YEL_R#: length 5.7
  TOP w0.102: R274.2 244.3,94.72 v1(245.14,95.56) 247.76,98.18 JLOM1.10
LAN_DISABLE#_R: length 332.7
  TOP w0.102: R173.2 R182.1 262.92,71.4 R180.2 263.72,72.31 262.97,73.06 262.97,73.56 v1(262.35,74.18) 261.85,74.68 v2(261.82,74.68) ; v2(19.99,37.44) 19.88,37.32 18.52,37.32 18.18,37.66 U37.B47 ; v2(257.7,75.86) 257.38,76.17 U21.3
  IN3 w0.122: v2(261.82,74.68) 260.96,73.81 259.74,73.81 v2(257.7,75.86) 257.08,75.24 248.16,75.24 247.16,76.24 246.28,76.24 241.8,80.72 239.35,80.72 238.93,81.14 224.51,81.14 223.28,79.91 214.38,79.91 208.89,74.41 208.59,74.41 206.43,72.25 204.56,72.25 203.25,70.95 203.25,69.73 204.08,68.9 204.08,68.19 204.47,67.81 204.47,64.97 203.63,64.14 203.63,53.64 204.11,53.16 204.11,51.44 204.57,50.98 204.57,47.21 205.91,45.87 205.91,41.98 204.69,40.75 203.48,40.75 201.73,39 201.73,37.01 198.91,34.19 197.89,34.19 194.8,31.09 194.18,31.09 193.77,31.51 193.77,32.54 192.73,33.58 189.89,33.58 188.41,32.1 187.3,32.1 186.26,33.14 185.91,33.14 184.8,34.25 139.64,34.25 133.39,28 133.39,27.46 131.71,25.78 v2(131.67,25.78)
  BOTTOM w0.102: v2(19.99,37.44) 20.18,37.44 20.69,36.93 22.56,36.93 22.87,36.62 23.26,36.62 23.67,37.03 25.25,37.03 26.16,37.94 26.35,37.94 26.62,38.22 26.62,38.39 27.53,39.31 29.33,39.31 29.97,39.94 31.47,39.94 35.43,43.9 35.43,46.65 38.11,49.33 39.21,49.33 40.92,51.05 45.93,51.05 47.08,49.9 47.71,49.9 49.41,48.2 50.25,48.2 52.72,45.73 57.15,45.73 58.24,44.64 65.55,44.64 66.25,43.94 124.34,43.94 130.24,38.04 130.24,33.48 130.54,33.17 130.54,31.31 131.86,29.99 131.86,28.56 131.34,28.04 131.34,27.2 131.5,27.05 131.5,25.96 v2(131.67,25.78)
LAN_RST#: length 116.6
  TOP w0.102: v1(242.75,71.48) 243.13,71.09 v2(243.45,71.09) 243.94,71.59 R331.1 244.22,71.79 245.16,71.79 245.39,71.57 U20.1
  IN1 w0.084: v2(154.42,71.48) 154.83,71.89 159.98,71.89 160.33,72.24 162.31,72.24 164.15,70.4 166.48,70.4 166.99,69.89 168.82,69.89 169.78,68.92 170.04,68.66 171.44,68.66 172.43,69.65 179.21,69.65 180.78,68.08 195.05,68.08 195.7,68.73 200.75,68.73 200.84,68.82 203.54,68.82 204.17,69.44 205.07,69.44 206.08,70.45 206.08,72.2 207.49,73.62 207.49,73.92 208.25,74.69 208.78,74.69 210.01,75.92 210.01,76.11 215.07,81.17 223.56,81.17 224.63,82.24 235.4,82.24 235.7,81.94 237.53,81.94 238.43,81.04 239.85,81.04 240.86,80.03 241.85,80.03 242.13,79.76 242.13,79.4 245.09,76.43 245.09,75.2 243.45,73.56 v2(243.45,71.09)
  BOTTOM w0.076: UC1.Y1 151.99,71.85 152.04,71.91 152.87,71.91
  BOTTOM w0.102: 152.87,71.91 153.48,71.91 153.54,71.84 154.05,71.84 v2(154.42,71.48)
LAN_SMBCLK: length 100.5
  TOP w0.102: v2(161.42,67.03) 161.37,66.98 159.58,66.98 RC29.1 ; v2(241.67,79.56) 241.84,79.39 242.46,79.39 243.38,78.46 245.14,78.46 245.65,78.97 R174.1
  IN1 w0.084: v2(161.42,67.03) 161.65,67.26 162.22,67.26 163.42,66.05 163.42,65.44 165.42,63.45 166.97,63.45 168.53,65.01 168.53,65.25 170.82,67.55 176.45,67.55 176.97,67.03 190.22,67.03 191.07,67.87 195.14,67.87 195.67,68.41 200.75,68.41 200.93,68.59 203.63,68.59 204.27,69.23 205.17,69.23 206.29,70.34 206.29,72.07 207.71,73.49 207.71,73.78 208.39,74.46 208.85,74.46 210.27,75.89 210.27,76.08 215.15,80.96 223.65,80.96 224.71,82.02 235.32,82.02 235.61,81.73 237.44,81.73 238.34,80.83 239.62,80.83 241.08,79.37 241.48,79.37 v2(241.67,79.56)
LAN_SMBCLK_R: length 2.9
  TOP w0.102: R174.2 247.03,79.11 247.98,79.11 v1(248.02,79.07) 248.37,78.71 248.91,78.71 249.05,78.57 U21.28
LAN_SMBDATA: length 93.3
  TOP w0.102: v2(168.35,63.88) 168.75,64.27 168.75,64.32 v1(169.15,64.73) 169.15,65.21 167.84,66.52 RC31.1 ; R177.1 245.62,77.19 244.58,78.23 243.29,78.23 242.36,79.16 241.86,79.16 v2(241.67,78.97)
  IN1 w0.084: v2(241.67,78.97) 241.48,79.16 240.99,79.16 239.53,80.62 238.26,80.62 237.35,81.52 235.52,81.52 235.23,81.81 224.8,81.81 223.74,80.75 215.24,80.75 210.48,75.99 210.48,75.8 208.93,74.25 208.48,74.25 207.92,73.7 207.92,73.41 206.5,71.98 206.5,70.26 205.26,69.02 204.36,69.02 203.72,68.38 201.02,68.38 200.84,68.2 195.76,68.2 195.22,67.66 191.15,67.66 190.31,66.82 176.88,66.82 176.36,67.33 170.91,67.33 168.74,65.16 168.74,64.92 168.35,64.53 v2(168.35,63.88)
LAN_SMBDATA_R: length 2.7
  TOP w0.102: U21.31 247.07,77.37 R177.2
LAN_TEST_EN: length 2.8
  TOP w0.102: R184.1 247.45,78.08 247.79,77.74 v1(248.02,77.74) 248.05,77.77 U21.30
LAN_TX0+: length 42.2
  TOP w0.089: U21.13 254.73,81.04 255.7,82.02 255.7,82.44 v2(255.84,82.58)
  IN4 w0.084: v2(239.45,91.72) 239.37,91.64 239.37,89.1 239.7,88.77 239.7,88.11 243.43,84.38 245.18,84.38 245.79,84.99 254.36,84.99 255.7,83.65 255.7,82.71 v2(255.84,82.58)
  BOTTOM w0.089: v2(239.45,91.72) 239.32,91.86 239.32,96.24 237.33,98.23 237.33,100.59 235.83,102.08 234.05,102.08 232.82,103.31 232.51,103.31 232.05,103.76 L27.1
LAN_TX0+R: length 3.7
  BOTTOM w0.089: L27.2 230.77,103.82 230.24,103.29 229.79,103.29 v3(229.67,103.16) 229.48,102.97 229.48,102.13 229.35,102 229.16,102 229.07,102.09 U23.2
LAN_TX0-: length 41.8
  TOP w0.089: U21.14 254.33,81.09 254.41,81.17 254.41,81.17 255.38,82.15 255.38,82.44 v2(255.25,82.58)
  IN4 w0.084: v2(238.87,91.72) 238.99,91.6 238.99,88.94 239.32,88.61 239.32,87.95 243.27,84 245.34,84 245.95,84.61 254.2,84.61 255.32,83.49 255.32,82.65 v2(255.25,82.58)
  BOTTOM w0.089: L28.1 232.05,102.56 232.48,102.99 232.69,102.99 233.92,101.76 235.7,101.76 237.01,100.46 237.01,98.1 239,96.11 239,91.86 v2(238.87,91.72)
LAN_TX0-R: length 3.8
  BOTTOM w0.089: L28.2 230.77,102.57 230.37,102.97 229.93,102.97 229.79,102.84 229.79,102.01 v3(229.64,101.85) 229.47,101.68 229.16,101.68 229.07,101.59 U23.3
LAN_TX1+: length 37.8
  TOP w0.089: v2(249.02,83.44) 249.02,83.15 249.13,83.04 249.3,83.04 250.45,84.2 v3(251.77,84.2) 252.63,84.2 253.16,83.67 253.16,81.18 253.13,81.14 U21.17
  IN4 w0.084: v2(238.23,91.72) 238.13,91.61 238.13,89.84 237.87,89.59 237.87,88.07 238.16,87.78 238.65,87.78 243.29,83.14 245.41,83.14 246.27,84 248.11,84 248.67,83.44 v2(249.02,83.44)
  BOTTOM w0.089: v2(238.23,91.72) 238.1,91.86 238.1,95.94 236.33,97.71 236.33,99.35 235.43,100.26 234.11,100.26 L29.1
LAN_TX1+R: length 4.2
  BOTTOM w0.089: L29.2 231.79,100.42 v3(230.64,100.42) 229.84,100.42 229.42,100 229.16,100 229.07,100.09 U23.6
LAN_TX1-: length 37.2
  TOP w0.089: U21.18 252.73,81.19 252.84,81.31 252.84,83.54 252.5,83.88 250.58,83.88 249.43,82.73 249,82.73 248.69,83.03 v2(248.51,83.03)
  IN4 w0.084: v2(237.65,91.75) 237.74,91.66 237.74,90 237.49,89.74 237.49,87.91 238,87.4 238.49,87.4 243.14,82.76 245.57,82.76 246.43,83.62 247.95,83.62 248.49,83.08 248.49,83.06 v2(248.51,83.03)
  BOTTOM w0.089: L30.1 234.11,99.94 235.3,99.94 236.02,99.22 236.02,97.57 237.78,95.81 237.78,91.89 v2(237.65,91.75)
LAN_TX1-R: length 4.4
  BOTTOM w0.089: L30.2 231.47,100.1 229.98,100.1 229.56,99.68 229.16,99.68 229.07,99.59 U23.7
LAN_TX2+: length 37.6
  TOP w0.089: U21.20 251.93,82.37 252.08,82.52 252.28,82.52 v2(252.41,82.39)
  IN4 w0.084: v2(236.96,91.76) 236.88,91.68 236.88,90.42 235.76,89.3 235.76,86.93 236.36,86.33 237.32,86.33 240.24,83.41 241.38,83.41 243.01,81.79 246.63,81.79 247.26,82.42 249.58,82.42 250.69,81.32 252.76,81.32 252.97,81.53 252.97,82.24 252.69,82.52 252.54,82.52 v2(252.41,82.39)
  BOTTOM w0.089: L31.1 234.11,97.21 235.43,97.21 236.84,95.8 236.84,91.88 v2(236.96,91.76)
LAN_TX2+R: length 4.6
  BOTTOM w0.089: U23.9 229.07,98.59 229.16,98.5 230.2,98.5 v3(231.1,97.6) 231.49,97.21 231.63,97.21 L31.2
LAN_TX2-: length 39.5
  TOP w0.089: U21.21 251.53,81.21 251.61,81.29 251.61,82.5 251.95,82.84 252.28,82.84 v2(252.41,82.97)
  IN4 w0.084: v2(252.41,82.97) 252.48,82.91 252.84,82.91 253.35,82.4 253.35,81.37 252.92,80.94 250.53,80.94 249.42,82.04 247.42,82.04 246.79,81.41 242.85,81.41 241.22,83.03 240.08,83.03 237.16,85.95 236.2,85.95 235.38,86.77 235.38,89.46 236.5,90.58 236.5,91.64 v2(236.38,91.76)
  BOTTOM w0.089: L32.1 234.11,96.89 235.3,96.89 236.53,95.66 236.53,91.91 v2(236.38,91.76)
LAN_TX2-R: length 4.6
  BOTTOM w0.089: L32.2 231.63,96.89 231.36,96.89 230.07,98.18 v3(229.74,98.18) 229.16,98.18 229.07,98.09 U23.10
LAN_TX3+: length 30
  TOP w0.089: v2(248.97,81.44) 249.11,81.3 249.26,81.3 249.78,81.83 250.44,81.83 250.69,81.58 250.69,81.3 250.73,81.26 U21.23
  IN4 w0.084: v2(234.98,90.58) 234.9,90.5 234.9,89.88 234.44,89.43 234.44,86.87 235.95,85.36 236.91,85.36 239.94,82.33 241.09,82.33 242.88,80.54 246.79,80.54 247.6,81.36 248.89,81.36 v2(248.97,81.44)
  BOTTOM w0.089: L33.1 234.11,94.16 234.79,94.16 235.13,93.83 235.13,91.6 234.87,91.35 234.87,90.69 v2(234.98,90.58)
LAN_TX3+R: length 6.3
  BOTTOM w0.089: L33.2 232.23,94.63 231.86,94.26 231.7,94.26 231.06,94.9 v3(231.06,95.5) 231.06,96.31 229.87,97.5 229.16,97.5 229.07,97.59 U23.11
LAN_TX3-: length 29.6
  TOP w0.089: v2(248.97,80.85) 249.11,80.99 249.39,80.99 249.91,81.51 250.3,81.51 250.37,81.44 250.37,81.3 250.33,81.26 U21.24
  IN4 w0.084: v2(248.97,80.85) 248.85,80.97 247.76,80.97 246.94,80.16 242.72,80.16 240.93,81.95 239.78,81.95 236.75,84.98 235.79,84.98 234.06,86.71 234.06,89.59 234.52,90.04 234.52,90.46 v2(234.4,90.58)
  BOTTOM w0.089: v2(234.4,90.58) 234.56,90.74 234.56,91.48 234.81,91.74 234.81,93.7 234.66,93.85 234.11,93.85 L34.1
LAN_TX3-R: length 6.4
  BOTTOM w0.089: L34.2 232.23,93.45 231.74,93.94 231.57,93.94 230.74,94.77 230.74,96.18 v3(229.99,96.93) 229.74,97.18 229.16,97.18 229.07,97.09 U23.12
LAN_WAKE#: length 346.2
  TOP w0.102: U38.B27 29.13,15.08 28.63,14.58 28.25,14.58 27.93,14.26 v2(27.93,14.12) ; R179.1 259.49,75.29 v2(259.83,75.63)
  IN3 w0.122: v2(27.93,14.12) 28.36,13.69 29.36,13.69 29.76,13.28 33.36,13.28 34.79,14.71 35.99,14.71 36.64,15.36 39.17,15.36 40.11,16.29 40.11,22.1 42.51,24.49 42.51,25.44 44.1,27.04 45.21,27.04 45.71,27.53 45.71,27.7 47.84,29.84 50.52,29.84 52.15,31.47 55.18,31.47 57.08,33.37 62.07,33.37 62.86,34.16 117.04,34.16 121.49,29.71 121.49,26.81 122.99,25.31 126.16,25.31 127.35,26.5 129.12,26.5 130.38,27.75 130.67,27.75 132.01,29.09 132.11,29.09 133.78,30.76 133.78,32.09 137.49,35.81 185.43,35.81 186.23,35 191.1,35 v2(191.33,35.23) 192.34,36.25 194.31,36.25 194.76,35.8 195.75,35.8 197.46,37.51 197.46,38.55 199.03,40.13 200.51,40.13 205.66,45.28 205.66,45.76 204.32,47.1 204.32,50.87 203.86,51.34 203.86,53.06 203.38,53.54 203.38,64.24 204.22,65.08 204.22,67.7 203.83,68.09 203.83,68.8 203,69.63 203,71.05 204.45,72.5 206.32,72.5 208.48,74.66 208.78,74.66 214.28,80.16 223.18,80.16 224.41,81.39 239.03,81.39 239.45,80.96 242.09,80.96 243.62,79.43 244.93,79.43 248.84,75.52 256.77,75.52 257.62,76.37 259.05,76.37 259.79,75.63 v2(259.83,75.63)
  BOTTOM w0.102: RC301.1 166.88,40.89 165.49,39.51 165.49,38.24 166.62,37.11 178.26,37.11 179.39,35.97 190.58,35.97 v2(191.33,35.23)
LAN_WAKE#_R: length 3.9
  TOP w0.102: R176.1 R179.2 257.69,75.29 257.16,75.82 v1(256.91,75.82) 256.33,75.82 256.28,75.77 U21.2
LANCLK_REQ#: length 137.3
  TOP w0.102: v2(257.06,74.81) 256.79,74.54 v1(256.79,74.19) R169.1 ; v2(152.34,74.06) 153.16,73.24 154.83,73.24 154.99,73.08 154.99,72.61 155.18,72.41 155.96,72.41 157.07,71.31 RP6.7
  IN2 w0.089: v2(152.34,74.06) 152.34,73.9 152.91,73.33 152.91,73 151.42,71.51 151.42,70.87 151.57,70.71 152.58,70.71 v2(152.96,70.33)
  IN4 w0.084: v2(152.34,74.06) 153.24,74.95 154.09,74.95 154.61,75.48 154.61,76.33 155.38,77.1 158.93,77.1 159.19,76.83 160.01,76.83 161.6,75.25 163,75.25 164.18,76.43 167.78,76.43 168.79,75.41 169.68,75.41 169.92,75.17 172.58,75.17 173.7,74.05 174.69,74.05 177.42,71.33 196.64,71.33 198.02,72.71 202.92,72.71 204.69,74.47 205.22,74.47 205.93,75.18 206.56,75.18 208.72,77.34 210.85,77.34 213.07,79.56 213.07,81.97 215.55,84.46 217.79,84.46 218.23,84.89 224.93,84.89 226.36,83.47 232.67,83.47 234.11,82.02 236.42,82.02 240.18,78.26 240.61,78.26 241.31,77.55 244.09,77.55 244.88,76.76 250.41,76.76 250.9,76.28 255.59,76.28 v2(257.06,74.81)
  BOTTOM w0.076: v2(152.96,70.33) 152.5,69.88 151.55,69.88 151.47,69.8 UC1.AD1
LANCLK_REQ#_R: length 2.3
  TOP w0.102: R169.2 255.88,73.58 255.7,73.76 255.13,73.76 254.73,74.16 U21.48
LCD_CBL_DET#: length 133.8
  TOP w0.102: RC189.2 160.86,77.86 157.2,77.86 v2(157.19,77.88)
  IN1 w0.084: v2(75.09,89.08) 75.28,89.27 81.27,89.27 82.02,88.52 91.02,88.52 91.03,88.52 97.34,88.52 99.1,86.75 101.91,86.75 104.67,89.51 106.98,89.51 111.13,85.36 111.13,84.53 113.94,81.72 138.14,81.72 138.73,81.13 146.79,81.13 147.75,80.17 148.36,80.17 148.9,79.64 148.9,77.7 149.71,76.89 v2(149.71,76.71)
  IN2 w0.122: v2(75.09,89.08) 75.07,89.1 66.63,89.1 63.38,85.85 58.44,85.85 51.89,79.3 51.89,73.8 v2(52.26,73.43)
  IN3 w0.089: 153.85,77.52 153.79,77.52 153.67,77.41 152.79,77.41 152.44,77.76 151.37,77.76 150.74,77.13 150.13,77.13 v2(149.71,76.71)
  IN3 w0.122: 153.85,77.52 155.76,77.52 156.11,77.88 v2(157.19,77.88)
  BOTTOM w0.076: UC1.J3 149.95,77.8 149.64,77.49 149.64,76.77 v2(149.71,76.71)
  BOTTOM w0.102: v2(52.26,73.43) 52.25,73.41 52.25,72.52 52.6,72.17 JEDP1.2
LCD_SMBCLK: length 20.1
  TOP w0.102: U38.B5 22.69,10.75 v2(22.16,11.28) ; v2(34.42,7.69) 34.42,6.64 32.92,5.14 R387.2 32.51,4.3 v1(32.25,4.04)
  IN2 w0.122: v2(22.16,11.28) 23.75,9.69 28.52,9.69 29.89,8.32 33.79,8.32 v2(34.42,7.69)
LCD_SMBDAT: length 2.1
  TOP w0.102: R451.2 21.9,7.91 v1(22.17,8.19) 22.44,8.46 U38.A4
LCD_TST: length 65.1
  TOP w0.102: v2(23.25,41.84) 22.5,41.84 R309.2 22.47,41.27 22.63,41.11 22.63,40.53 22.43,40.32 U37.A36
  IN1 w0.084: v2(56.57,74.02) 52.97,70.42 52.97,67.62 51.82,66.47 51.82,62.64 54.53,59.92 54.53,57.35 51.47,54.28 51.47,52.4 50.99,51.92 50.99,51.25 48.69,48.96 45.41,48.96 v2(44.15,47.7)
  IN4 w0.084: v2(23.25,41.84) 23.37,41.73 26.79,41.73 29.22,44.16 30.8,44.16 32.11,45.47 33.57,45.47 36.87,48.76 43.08,48.76 v2(44.15,47.7)
  BOTTOM w0.102: JEDP1.13 57.86,73.74 57.58,74.02 v2(56.57,74.02)
LCD_VCC_TEST_EN: length 58
  TOP w0.102: D2.2 57,68.41 v2(54.92,66.33) ; v2(50.75,52.43) 50.43,52.11 49.15,52.11 48.25,51.21 46.69,51.21 46.4,51.49 44.05,51.49 43.3,52.23 39.23,52.23 32.37,45.38 28.18,45.38 26.8,43.99 23.88,43.99 23.41,43.52 21.79,43.52 21.03,42.76 21.03,41.12 20.82,40.91 20.82,40.66 20.43,40.27 U37.A40
  IN1 w0.084: v2(52.9,62.23) 52.9,64.31 v2(54.92,66.33)
  BOTTOM w0.102: v2(52.9,62.23) 54.06,61.07 54.06,57.81 50.75,54.5 v2(50.75,52.43)
LED_10_GRN#: length 36.7
  TOP w0.102: R275.1 261.06,88.85 v2(260.73,89.18) ; v1(236.18,94.27) v2(235.48,94.27) 235.48,94.58 235.24,94.82 234.92,94.82 234.76,94.65 Q33.6
  IN1 w0.084: v2(260.73,89.18) 260.73,86.96 259.85,86.08 244.88,86.08 242.65,88.32 242.65,92.05 240.84,93.85 235.9,93.85 v2(235.48,94.27)
LED_10_GRN_R#: length 10.1
  TOP w0.102: JLOM1.11 257.63,97.37 259.77,95.22 v1(259.8,95.22) 261.54,93.48 R275.2
LED_100_ORG#: length 65
  TOP w0.102: v2(231.18,93.78) 231.18,94.46 231.02,94.62 Q32.3 ; v2(243.43,93.88) v1(243.43,93.26) ; v2(263.4,88.58) 263.13,88.85 R276.1
  IN2 w0.122: v2(231.18,93.78) 232.27,94.87 240.94,94.87 241.94,93.88 v2(243.43,93.88)
  BOTTOM w0.102: v2(263.4,88.58) 263.97,88.01 263.97,84.89 263.37,84.29 263.37,76.53 262.33,75.49 260.78,75.49 259.94,76.33 257.45,76.33 256.77,75.64 249.68,75.64 249.23,76.1 248.54,76.1 245.54,79.1 245.54,80.37 242.85,83.06 242.85,93.29 v2(243.43,93.88)
LED_100_ORG_R#: length 9.5
  TOP w0.102: R276.2 262.5,94.83 v1(262.14,95.19) 262.14,95.95 JLOM1.13
LED_SATA_DIAG_OUT#: length 226.4
  TOP w0.102: v2(191.09,93.31) 190.49,93.9 D24.1 v1(189.12,93.9) ; v2(21.24,27.86) 21.24,28.5 20.93,28.81 U37.A10
  IN3 w0.122: v2(21.24,27.86) 21.66,28.28 23.7,28.28 24.25,27.72 26.18,27.72 27.27,28.81 27.75,28.81 29.11,30.17 29.11,31.04 29.98,31.91 31.93,31.91 32.43,32.42 35.95,32.42 38.25,34.72 44.63,34.72 46.27,36.37 46.27,37.24 49.52,40.49 50.34,40.49 52.07,42.21 56.4,42.21 58.04,43.85 58.04,45.88 61.77,49.62 61.77,61.66 62.99,62.88 63.87,62.88 65.29,64.3 65.29,74.74 67.89,77.34 69.27,77.34 73.94,82.01 73.94,82.06 75.31,83.43 77.99,83.43 79.05,84.48 82.87,84.48 83.16,84.77 83.16,86.51 85.19,88.54 89.05,88.54 90.54,90.03 92.85,90.03 94.15,91.33 96.14,91.33 98.58,93.77 101.33,93.77 101.88,94.31 102.85,94.31 104.29,95.74 112.19,95.74 112.65,96.21 129.01,96.21 130.63,94.59 136.33,94.59 136.74,95 149.04,95 149.31,94.73 151.92,94.73 153.59,93.06 153.59,91.25 154.87,89.97 159.21,89.97 159.94,90.7 176.88,90.7 177.95,89.62 178.07,89.62 179.89,87.8 180.91,87.8 183,89.89 186.58,89.89 190,93.31 v2(191.09,93.31)
LED_WWAN_OUT#: length 23.3
  TOP w0.102: JMINI2.42 208.08,60.15 207.33,59.4 v1(207.33,58.29) 207.33,55.17 205.49,53.33 205.49,51.76 205.87,51.38 207.14,51.38 207.54,50.98 207.54,50.22 208.08,49.68 208.08,47.99 207.86,47.78 207.33,47.78 207.04,47.48 206.35,47.48 206.1,47.23 206.1,45.64 R226.1 207.48,44.26 207.48,43.52 207.14,43.18 Q30.4
LG_3V: length 5.2
  TOP w0.102: v3(198.03,52.21) 198.5,52.21 v1(198.79,51.92)
  IN4 w1.016: 197.84,53.16 197.84,56.46 197.13,57.17
  vias: v3(196.65,58.58) v3(196.65,57.95) v3(198.03,51.57)
LG_5V: length 7.5
  TOP w0.102: v3(195.01,51.29) 195.01,51.69 v1(194.81,51.89)
  IN4 w1.016: 193.42,59.94 193.42,55.12 194.82,53.72
  vias: v2(193.09,60.87) v2(193.73,60.87) v3(195.52,50.85)
LG_+V1.05SP: length 0.8
  BOTTOM w0.102: v1(233.46,78.46) 233.27,78.46 v2(232.84,78.03)
  vias: v2(233.22,77.51) v2(235.57,75.6) v2(236.08,75.98)
LID_CL#: length 424.8
  TOP w0.102: v2(8.92,40.23) 8.93,40.25 10.25,40.25 10.36,40.36 10.63,40.36 10.83,40.56 11.09,40.56 11.43,40.22 R325.1 11.99,40.94 12.5,41.45 12.74,41.45 12.99,41.71 12.99,42 13.03,42.04 U47.2 ; v2(272.11,11.05) 272.44,11.05 273.43,10.06 273.43,7.33 271.3,5.19 v1(271.3,4.9) 270.62,4.23 268.05,4.23 267.53,4.74 JSH1.11
  IN3 w0.122: v2(8.92,40.23) 8.78,40.09 8.78,38.78 8.66,38.66 8.66,32.74 9.3,32.11 11.13,32.11 12.43,30.8 13.63,30.8 13.89,30.53 13.89,29.82 13.84,29.76 13.84,29.14 14.16,28.81 14.16,27.74 14.45,27.45 16.95,27.45 18.2,26.19 20.99,26.19 21.53,26.74 23.96,26.74 24.2,26.98 26.49,26.98 26.81,27.29 27.82,27.29 29.79,29.27 31.35,29.27 31.65,28.97 33.42,28.97 34.37,29.92 39.84,29.92 40.9,30.98 45.06,30.98 51.04,36.96 56.44,36.96 57.22,37.74 65.56,37.74 66.99,36.3 118.28,36.3 122.67,31.91 124.93,31.91 127.25,29.59 128.68,29.59 130.22,31.13 131.71,31.13 132.15,31.57 132.15,32.77 136.84,37.45 186.1,37.45 186.91,36.64 187.26,36.64 187.58,36.96 187.58,37.61 188.65,38.68 189.6,38.68 192.47,41.55 200.87,41.55 204.1,44.78 204.1,46.12 203.54,46.68 203.54,49.82 201.93,51.43 201.93,55.9 202.63,56.6 202.63,63.73 202.51,63.84 202.51,66.56 201.83,67.25 200.94,67.25 200.26,67.93 200.26,70.94 201.77,72.45 202.04,72.45 204.04,74.45 205.43,74.45 206.51,75.53 207.75,75.53 212.87,80.66 222.97,80.66 224.2,81.89 241.51,81.89 243.72,79.68 245.03,79.68 248.94,75.77 256.67,75.77 257.52,76.62 259.16,76.62 259.57,76.21 259.97,76.21 260.79,75.39 262.46,75.39 262.88,74.97 262.88,73.13 263.57,72.44 266.55,72.44 267.81,71.18 267.81,51.47 273.68,45.61 275.37,45.61 275.79,45.19 275.79,41.58 276.2,41.16 276.2,38.52 276,38.32 276,34.19 277.69,32.51 277.69,30.66 280.36,27.98 280.79,27.98 281.27,27.49 281.27,24.97 282.4,23.84 282.4,17.06 280.05,14.7 276.43,14.7 272.56,10.83 272.33,10.83 v2(272.11,11.05)
LID_CL_SIO#: length 12.9
  TOP w0.102: U37.B54 16,37.52 16.11,37.63 16.62,37.63 16.99,37.26 v2(16.99,37.16) ; v1(9,39.69) 9.07,39.62 R322.2 10.47,40.13 11.17,40.13 11.42,39.89 11.42,39.66 11.78,39.3 R325.2 12.39,39.3 12.42,39.33 C337.1 12.89,38.73 v2(12.96,38.66)
  IN1 w0.084: v2(16.99,37.16) 16.4,37.76 15.53,37.76 13.72,39.57 13.15,39.57 12.96,39.39 v2(12.96,38.66)
LOM_ACTLED_YEL#: length 32.1
  TOP w0.102: v2(246.76,83.21) v1(246.76,82.02) 246.76,81.49 248.88,79.37 U21.26
  IN1 w0.084: v2(229.46,95.31) 229.46,94.6 229.86,94.21 231.33,94.21 232.85,92.68 239.76,92.68 240.53,91.92 240.53,87.67 243.98,84.21 246.36,84.21 246.76,83.81 v2(246.76,83.21)
  BOTTOM w0.102: v2(229.46,95.31) 229.18,95.31 228.91,95.59 U23.15
LOM_SPD10LED_GRN#: length 41.4
  TOP w0.102: U21.25 248.8,79.77 247.65,80.92 247.65,83.29 v1(247.29,83.64) U24.2 244.7,83.64 244.53,83.82 v2(244.53,84.94)
  IN1 w0.084: v2(227.76,104.69) 228.91,104.69 232.4,101.2 232.4,95.95 235,93.34 240.26,93.34 241.78,91.82 241.78,88.24 244.53,85.5 v2(244.53,84.94)
  BOTTOM w0.102: v2(227.76,104.69) 227.43,104.36 U23.42
LOM_SPD100LED_ORG#: length 32
  TOP w0.102: v2(243.94,84.94) 244.07,84.81 244.07,83.24 244.31,82.99 U24.1 245.99,82.99 246.23,82.75 246.23,81.2 v1(247.12,80.31) 247.53,80.31 248.87,78.97 U21.27
  IN1 w0.084: v2(243.94,84.94) 243.81,84.94 240.94,87.81 240.94,91.82 239.76,93 232.91,93 231.13,94.78 v2(230.11,94.78)
  BOTTOM w0.102: v2(230.11,94.78) 229.6,94.78 229.51,94.87 229.13,94.87 228.91,95.09 U23.16
LP_CTL: length 6.7
  TOP w0.102: R207.1 192.72,89.65 v1(192.23,89.16) 191.86,88.79 191.86,87.76 192.27,87.35 192.27,85.89 192.31,85.85 192.31,85.13 192.46,84.98 192.46,84.49 192.11,84.15 U6.B2
LPC_LAD0: length 186.8
  TOP w0.102: U25.26 36.62,35.39 36.18,34.95 27.5,34.95 27.28,35.16 27.18,35.16 v2(26.86,35.48) 26.58,35.77 U37.A27 ; v2(30.87,17.7) 30.87,17.71 30.49,17.33 U38.A30
  IN1 w0.084: v2(30.87,17.7) 30.89,17.73 30.89,18.93 31.79,19.83 31.79,21.28 32.04,21.53 32.04,25.55 32.93,26.44 32.93,32.68 30.12,35.48 v2(26.86,35.48)
  IN2 w0.089: v2(145.28,55.45) 144.37,54.53 144.37,54.43 142.1,52.16 141.19,52.16 140.44,51.41
  IN2 w0.122: v2(26.86,35.48) 28.19,35.48 29.39,36.68 33.31,36.68 35.42,38.79 35.42,39.28 37.45,41.31 37.78,41.31 43.33,46.85 54.34,46.85 55.05,47.57 56.96,47.57 58.71,49.32 62.58,49.32 63.67,48.24 68.89,48.24 69.65,49 71.45,49 71.95,48.5 74.53,48.5 75.21,49.18 114.55,49.18 115.54,50.18 139.21,50.18 140.44,51.41
  IN3 w0.122: v2(30.87,17.7) 30.98,17.58 33.53,17.58 36.7,20.76 36.7,22.38 37.77,23.44 37.77,24.26 38.8,25.28 v2(38.8,25.42)
  BOTTOM w0.076: UC1.AU14 143.75,61.83 143.75,60.88 143.86,60.77 143.86,59.01 145.4,57.47
  BOTTOM w0.089: 145.4,57.47 145.4,55.57 v2(145.28,55.45)
  BOTTOM w0.102: JMINI3.16 38.91,25.85 38.8,25.73 v2(38.8,25.42)
LPC_LAD1: length 199.1
  TOP w0.102: U38.B32 29.03,17.58 28.69,17.24 27.89,17.24 v2(27.47,17.67) ; U37.A26 26.5,35.27 v2(26.91,34.86) 27.14,34.86 27.36,34.65 37.49,34.65 38.57,35.72 U25.23
  IN1 w0.084: v2(26.91,34.86) 30.34,34.86 32.39,32.82 32.39,32 31.53,31.15 31.53,29.79 29.73,27.99 29.73,24.81 30.1,24.44 30.1,23.55 29.88,23.34 29.88,20.67 28.93,19.72 28.93,17.64 28.52,17.23 27.91,17.23 v2(27.47,17.67)
  IN2 w0.089: 141.38,51.41 141.76,51.79 142.71,51.79 145.26,54.34 v2(145.28,54.34)
  IN2 w0.122: 141.38,51.41 139.5,49.53 115.81,49.53 114.82,48.53 75.48,48.53 74.8,47.85 71.68,47.85 71.18,48.35 69.92,48.35 69.16,47.59 63.4,47.59 62.31,48.67 58.98,48.67 57.23,46.92 55.32,46.92 54.61,46.2 43.6,46.2 38.35,40.96 38.35,40.5 36.69,38.84 35.93,38.84 33.45,36.35 29.7,36.35 28.21,34.86 v2(26.91,34.86)
  BOTTOM w0.076: UC1.AW12 144.22,60.84 144.44,60.61 144.44,59.28
  BOTTOM w0.102: v2(145.28,54.34) 145.41,54.34 145.91,54.84 145.91,57.59 144.44,59.06 144.44,59.28 ; v2(27.47,17.67) 27.05,18.08 27.05,18.97 27.48,19.41 28.94,19.41 31.04,21.5 31.04,22.07 31.55,22.58 31.93,22.58 34.15,22.58 35.01,23.45 35.01,23.98 35.65,24.61 41.12,24.61 41.4,24.89 41.4,26.26 41.01,26.65 JMINI3.14
LPC_LAD2: length 197.2
  TOP w0.102: U38.A31 30.42,17.83 30.81,18.22 30.81,18.29 v2(31.36,18.83) ; U25.20 40.52,37.56 40.13,37.95 40.13,37.96 40.02,38.07 40.02,38.63 39.29,39.36 v1(39.29,40.06) 38.81,40.54 v2(37.54,40.54) ; v2(23.53,33.93) 24.12,34.52 U37.B26
  IN1 w0.084: v2(37.54,40.54) 37.54,40.54 37.65,40.43 37.65,38.35 38.01,37.99 38.01,32.65 37.65,32.3 37.65,31.59 38.76,30.48 38.76,26.62 v2(37.54,25.4) ; v2(23.53,33.93) 23.94,34.34 25.04,34.34 26.62,35.92 30.1,35.92 33.22,32.8 33.22,25.91 33.21,25.9 33.21,24.94 32.75,24.49 32.75,21.71 32.14,21.1 32.14,19.62 v2(31.36,18.83)
  IN2 w0.089: v2(145.34,54.89) 145.3,54.89 142.38,51.97 141.48,51.97 140.92,51.41
  IN2 w0.122: v2(37.54,40.54) 37.54,40.61 43.46,46.53 54.48,46.53 55.19,47.24 57.09,47.24 58.85,49 62.45,49 63.53,47.91 69.03,47.91 69.79,48.67 71.32,48.67 71.81,48.18 74.67,48.18 75.35,48.86 114.68,48.86 115.68,49.86 139.37,49.86 140.92,51.41
  IN4 w0.084: v2(23.53,33.93) 23.94,34.34 24.93,34.34 25.83,33.44 27.48,33.44 30.02,35.97 36.74,35.97 38.02,37.25 38.02,40.06 37.54,40.54 v2(37.54,40.54)
  BOTTOM w0.076: UC1.AY12 144.15,59.34
  BOTTOM w0.102: v2(145.34,54.89) 145.72,55.27 145.72,57.47 144.15,59.03 144.15,59.34 ; v2(37.54,25.4) 37.54,26.19 38.8,27.45 JMINI3.12
LPC_LAD3: length 203.9
  TOP w0.102: v2(36.96,25.4) 37.75,24.61 39.09,24.61 39.6,24.1 v1(42.34,24.1) 44.94,24.1 46.2,25.37 46.2,31.42 46.81,32.03 46.81,33.07 46.28,33.6 45.64,33.6 44.54,34.71 44.54,37.1 44.1,37.54 43.06,37.54 42.73,37.87 v2(42.28,37.87) 42.28,37.5 42.47,37.31 U25.17 ; v2(24.12,33.94) 24.19,34.02 U37.B25 ; v2(28.32,17.7) 28.7,18.08 U38.B33
  IN1 w0.084: v2(28.32,17.7) 28.63,18.01 28.63,19.82 29.6,20.79 29.6,23.46 29.81,23.67 29.81,24.32 29.44,24.69 29.44,28.11 31.24,29.91 31.24,31.46 30.15,32.55 28.52,32.55 27.29,33.78 25.42,33.78 25.26,33.94 v2(24.12,33.94)
  IN2 w0.089: 144.87,51.41 144.87,51.85 146.69,53.67 146.69,57.11 145.45,58.35 v2(145.45,59.03)
  IN2 w0.122: v2(42.28,37.87) 42.31,37.87 41.83,38.34 41.83,43.52 43.57,45.26 47.9,45.26 48.48,44.68 49.69,44.68 50.37,45.35 54.68,45.35 55.59,46.27 57.5,46.27 59.25,48.02 62.04,48.02 63.37,46.69 67.35,46.69 67.78,46.27 115.93,46.27 116.93,47.26 141.67,47.26 144.87,50.46 144.87,51.41
  IN4 w0.084: v2(42.28,37.87) 42.16,37.87 39.67,35.39 30.24,35.39 27.7,32.84 26.81,32.84 26.57,32.6 26.03,32.6 24.68,33.94 v2(24.12,33.94)
  BOTTOM w0.076: v2(145.45,59.03) 145.45,59.57 145.19,59.82 145.19,60.54 UC1.AW11
  BOTTOM w0.102: v2(36.96,25.4) 36.96,26.04 39.17,28.25 JMINI3.10
LPC_LDRQ1#: length 3.1
  TOP w0.102: U37.A22 25.98,33.27 26.47,33.76 v1(27.36,33.76) R296.2
LPC_LFRAME#: length 176.6
  TOP w0.102: v2(38.52,38.56) 38.6,38.56 39.03,38.12 v1(39.03,38.06) 39.03,37.5 39.22,37.31 U25.22 ; U37.A21 25.99,32.77 26.21,32.99 v2(26.4,32.99) ; U38.B31 28.97,17.08 28.83,16.93 27.65,16.93 27.29,17.3 27.13,17.3 v2(26.9,17.53)
  IN1 w0.084: v2(39.01,32.18) 39.14,32.31 39.14,37.95 38.53,38.56 v2(38.52,38.56) ; v2(26.4,32.99) 27.66,32.99 28.09,32.57 28.09,22.83 28.29,22.63 28.29,21.09 27.58,20.38 27.58,20.31 27.13,19.86 27.13,18.07 26.9,17.84 v2(26.9,17.53)
  IN2 w0.089: 143.43,51.41 143.43,51.92 144.72,53.21 145.44,53.21 145.9,53.66 145.9,56.3 144.15,58.04 144.15,61.4 v2(144.51,61.76)
  IN2 w0.122: 143.43,51.41 140.55,48.53 116.28,48.53 115.28,47.53 71.5,47.53 71,48.02 70.06,48.02 69.3,47.26 63.26,47.26 62.18,48.35 59.12,48.35 57.36,46.59 55.46,46.59 54.54,45.68 50.23,45.68 49.56,45 48.62,45 48.03,45.58 43.44,45.58 39.08,41.23 39.08,39.12 v2(38.52,38.56)
  IN4 w0.084: v2(38.52,38.56) 39.08,38 39.08,37.89 36.86,35.67 30.12,35.67 27.58,33.13 26.54,33.13 v2(26.4,32.99)
  BOTTOM w0.076: v2(144.51,61.76) 144.24,61.49 UC1.AV12
  BOTTOM w0.102: JMINI3.8 39.1,29.05 38.65,29.5 38.65,31.81 v2(39.01,32.18)
M_CLK_DDR0: length 78.1
  IN4 w0.084: v2(129.52,58.1) 129.91,57.72 129.91,56.36 128.43,54.88 128.43,52.84 127.75,52.16 127.75,51.43 127.75,51.43 127.75,51.41
  IN4 w0.091: v2(92.27,29.44) 92.5,29.67 92.67,29.67 92.92,29.92 92.92,30.16 93.01,30.25 93.24,30.25 93.47,30.48 93.47,30.83 93.24,31.06 93.01,31.06 92.92,31.15 92.92,31.42 93.01,31.51 93.37,31.51 93.59,31.74 93.59,32.09 93.37,32.32 93.01,32.32 92.92,32.41 92.92,32.8 93.15,33.03 101.69,33.03 101.78,32.94 101.78,32.27 101.97,32.08 102.39,32.08 102.58,32.27 102.58,32.94 102.67,33.03 102.95,33.03 103.04,32.94 103.04,32.13 103.24,31.93 103.64,31.93 103.84,32.13 103.84,32.94 103.93,33.03 104.21,33.03 104.3,32.94 104.3,32.13 104.5,31.93 104.91,31.93 105.1,32.12 105.1,32.86 105.19,32.95 105.47,32.95 105.56,32.86 105.56,32.12 105.75,31.93 117.01,31.93 118.11,33.03 120.53,33.03 127.75,40.25 127.75,51.41
  BOTTOM w0.076: v2(129.52,58.1) 129.52,57.94 129.38,57.8 129.02,57.8 128.56,58.26 128.56,61.19 UC1.AV37
  BOTTOM w0.102: JDIMM1.101 91.9,26.91 92.11,27.12 92.11,27.5 92.75,28.14 92.75,29.55 92.62,29.67 92.4,29.67 92.27,29.55 v2(92.27,29.44)
M_CLK_DDR1: length 76.7
  IN4 w0.084: v2(129.28,59.86) 129.52,60.1 129.68,60.1 129.72,60.07 129.72,58.46 130.08,58.1 130.08,56.29 129.91,56.12 129.91,55.98 128.6,54.67 128.6,52.46 128.26,52.11 128.26,51.48 128.26,51.48 128.26,51.43 128.25,51.43 128.25,51.41
  IN4 w0.091: 128.25,51.41 128.25,40.05 120.68,32.47 118.26,32.47 117.21,31.43 114.63,31.43 114.44,31.24 114.44,30.99 114.32,30.86 114.11,30.86 113.99,30.99 113.99,31.24 113.79,31.43 101.86,31.43 100.76,32.53 95.07,32.53 94.02,31.48 94.02,21.64 93.88,21.51 93.69,21.51 v2(93.4,21.8)
  BOTTOM w0.076: UC1.AY36 129.6,60.19 v2(129.28,59.86)
  BOTTOM w0.102: v2(93.4,21.8) 93.09,21.49 92.96,21.49 92.64,21.18 92.64,20.21 92.39,19.96 92.39,19.08 92.2,18.89 JDIMM1.102
M_CLK_DDR2: length 89.8
  IN1 w0.091: v2(128.25,64.27) 128.01,64.51 127.88,64.51 127.76,64.38 127.76,62.54 127.29,62.07 127.29,58.79 128.07,58.01 128.07,53.95 127.12,53.01 127.12,51.7 126.93,51.5 126.16,51.5 126.04,51.38 126.04,51.13 126.16,51.01 126.93,51.01 127.12,50.81 127.12,50.36 126.93,50.16 125.69,50.16 125.57,50.04 125.57,49.79 125.69,49.67 126.93,49.67 127.12,49.47 127.12,49.01 126.93,48.82 125.69,48.82 125.57,48.7 125.57,48.45 125.69,48.32 126.93,48.32 127.12,48.13 127.12,47.67 126.93,47.48 125.89,47.48 125.76,47.35 125.76,47.11 125.89,46.98 126.93,46.98 127.12,46.79 127.12,45.75 137.75,35.12 165.23,35.12 165.91,34.45 166.04,34.45 166.38,34.79 166.65,34.79 166.97,34.46 166.97,34.19 166.47,33.69 166.47,33.51 166.65,33.34 166.83,33.34 167.32,33.84 167.6,33.84 167.92,33.52 167.92,33.24 167.42,32.74 167.42,32.56 167.59,32.39 167.77,32.39 168.27,32.89 168.55,32.89 168.87,32.57 168.87,32.29 168.53,31.95 168.53,31.82 169.36,30.99 169.36,29.8 169.17,29.6 169,29.6 v2(168.71,29.31)
  BOTTOM w0.076: UC1.AN38 128.57,64.6 v2(128.25,64.27)
  BOTTOM w0.102: v2(168.71,29.31) 169,29.59 169.1,29.59 169.14,29.55 169.14,28.29 168.59,27.74 168.59,27.18 168.4,26.99 JDIMM2.101
M_CLK_DDR3: length 88.2
  IN1 w0.091: v2(169.78,21.09) 169.78,21.07 169.58,20.87 169.53,20.87 169.31,21.09 169.31,22.64 169.4,22.74 169.78,22.74 170.01,22.96 170.01,23.31 169.78,23.54 169.4,23.54 169.31,23.63 169.31,24.57 169.39,24.64 169.58,24.64 169.81,24.87 169.81,27.76 169.58,27.99 168.27,27.99 168.15,28.12 168.15,30.83 164.52,34.45 137.47,34.45 124.89,47.03 124.89,51.6 126.73,53.44 126.73,62.18 127.31,62.75 127.31,64.99 127.69,65.37 127.69,65.64 127.82,65.78 128.21,65.78 128.25,65.73 v2(128.25,65.57)
  BOTTOM w0.076: UC1.AL38 128.57,65.9 v2(128.25,65.57)
  BOTTOM w0.102: JDIMM2.102 168.7,18.91 168.97,19.18 168.97,19.84 169.14,20.01 169.14,20.48 169.39,20.73 169.61,20.73 169.78,20.9 v2(169.78,21.09)
M_CLK_DDR#0: length 78.4
  IN4 w0.084: v2(129.52,57.45) 129.74,57.23 129.74,56.43 128.26,54.95 128.26,52.91 127.58,52.23 127.58,51.43 127.58,51.43 127.58,51.41
  IN4 w0.091: 127.58,51.41 127.58,40.32 120.46,33.2 118.04,33.2 116.94,32.1 105.82,32.1 105.73,32.19 105.73,32.93 105.54,33.12 105.12,33.12 104.93,32.93 104.93,32.19 104.84,32.1 104.57,32.1 104.47,32.2 104.47,33.01 104.28,33.2 103.86,33.2 103.67,33.01 103.67,32.2 103.57,32.1 103.31,32.1 103.21,32.2 103.21,33.01 103.02,33.2 102.6,33.2 102.41,33.01 102.41,32.34 102.32,32.25 102.04,32.25 101.95,32.34 101.95,33.01 101.76,33.2 93.07,33.2 92.75,32.87 92.75,32.34 92.94,32.14 93.29,32.14 93.42,32.02 93.42,31.81 93.29,31.69 92.94,31.69 92.75,31.49 92.75,31.08 92.94,30.88 93.17,30.88 93.29,30.76 93.29,30.55 93.17,30.43 92.94,30.43 92.75,30.23 92.75,29.99 92.6,29.84 92.39,29.84 92.27,29.96 v2(92.27,30.2)
  BOTTOM w0.076: v2(129.52,57.45) 129.34,57.63 128.96,57.63 128.39,58.2 128.39,61.26 128.56,61.43 128.56,61.61 128.8,61.85 UC1.AU37
  BOTTOM w0.102: v2(92.27,30.2) 92.59,29.88 92.73,29.88 92.97,29.64 92.97,28.05 92.33,27.41 92.33,27.11 92.5,26.94 JDIMM1.103
M_CLK_DDR#1: length 76.9
  IN4 w0.084: 128.42,51.41 128.42,52.05 128.77,52.39 128.77,54.6 130.07,55.91 130.07,56.05 130.24,56.22 130.24,58.16 129.88,58.53 129.88,60.13 129.75,60.27 129.52,60.27 v2(129.28,60.51)
  IN4 w0.091: v2(93.4,21.04) 93.69,21.33 93.95,21.33 94.19,21.57 94.19,31.41 95.14,32.36 100.68,32.36 101.78,31.26 113.72,31.26 113.81,31.17 113.81,30.92 114.04,30.69 114.39,30.69 114.61,30.92 114.61,31.17 114.71,31.26 117.29,31.26 118.33,32.3 120.75,32.3 128.42,39.97 128.42,51.41
  BOTTOM w0.076: v2(129.28,60.51) 129.6,60.84 UC1.AW36
  BOTTOM w0.102: v2(93.4,21.04) 93.16,21.28 93.05,21.28 92.86,21.09 92.86,20.12 92.61,19.87 92.61,19.09 92.8,18.9 JDIMM1.104
M_CLK_DDR#2: length 90.1
  IN1 w0.091: v2(168.71,30.07) 169,29.78 169.1,29.78 169.19,29.87 169.19,30.92 168.36,31.75 168.36,32.03 168.7,32.37 168.7,32.49 168.47,32.72 168.35,32.72 167.85,32.22 167.52,32.22 167.25,32.49 167.25,32.82 167.75,33.31 167.75,33.44 167.53,33.67 167.4,33.67 166.9,33.17 166.57,33.17 166.3,33.44 166.3,33.76 166.8,34.26 166.8,34.39 166.58,34.62 166.45,34.62 166.11,34.28 165.83,34.28 165.16,34.95 137.68,34.95 126.95,45.68 126.95,46.72 126.86,46.81 125.82,46.81 125.59,47.04 125.59,47.43 125.82,47.65 126.86,47.65 126.95,47.75 126.95,48.06 126.86,48.15 125.62,48.15 125.39,48.38 125.39,48.77 125.62,49 126.86,49 126.95,49.09 126.95,49.4 126.86,49.49 125.62,49.49 125.39,49.72 125.39,50.11 125.62,50.34 126.86,50.34 126.95,50.43 126.95,50.74 126.86,50.83 126.09,50.83 125.86,51.06 125.86,51.45 126.09,51.68 126.86,51.68 126.95,51.77 126.95,53.08 127.89,54.02 127.89,57.94 127.11,58.72 127.11,62.14 127.58,62.61 127.58,64.45 127.81,64.68 128,64.68 128.25,64.92 v2(128.25,64.92)
  BOTTOM w0.076: v2(128.25,64.92) 128.57,65.25 UC1.AM38
  BOTTOM w0.102: v2(168.71,30.07) 168.97,29.81 169.19,29.81 169.36,29.64 169.36,28.2 168.81,27.65 168.81,27.21 169,27.01 JDIMM2.103
M_CLK_DDR#3: length 88.5
  IN1 w0.091: v2(169.78,20.33) 169.81,20.37 169.81,20.55 169.66,20.7 169.46,20.7 169.14,21.02 169.14,22.72 169.33,22.91 169.71,22.91 169.84,23.03 169.84,23.24 169.71,23.36 169.33,23.36 169.14,23.56 169.14,24.64 169.32,24.82 169.51,24.82 169.63,24.94 169.63,27.69 169.51,27.82 168.2,27.82 167.97,28.05 167.97,30.75 164.45,34.28 137.4,34.28 124.72,46.96 124.72,51.67 126.56,53.51 126.56,62.25 127.13,62.82 127.13,65.06 127.51,65.44 127.51,65.71 127.75,65.95 128.21,65.95 128.31,66.05 128.31,66.16 v2(128.25,66.22)
  BOTTOM w0.076: v2(128.25,66.22) 128.57,66.55 UC1.AK38
  BOTTOM w0.102: v2(169.78,20.33) 169.59,20.51 169.48,20.51 169.35,20.39 169.35,19.92 169.19,19.75 169.19,19.1 169.3,18.99 JDIMM2.104
M_ODT0: length 3.5
  TOP w0.17: v2(97.59,19.85) 97.71,19.98 R29.2
  BOTTOM w0.17: JDIMM1.116 96.4,18.74 97.59,19.93 v2(97.59,19.85)
M_ODT1: length 2.2
  TOP w0.17: R30.2 97.73,19.09 v2(97.6,19.21)
  BOTTOM w0.17: v2(97.6,19.21) JDIMM1.120
M_ODT2: length 5.5
  TOP w0.17: v2(174.93,15.91) v1(175.43,16.41) 175.91,16.89 R31.2
  BOTTOM w0.17: JDIMM2.116 172.9,16.16 173.15,15.91 v2(174.93,15.91)
M_ODT3: length 5.3
  TOP w0.17: v2(175.57,15.91) 175.63,15.98 v1(176.77,15.98) 176.99,15.98 177.45,16.44 R33.2
  BOTTOM w0.17: JDIMM2.120 174.1,16.81 174.55,16.36 175.12,16.36 v2(175.57,15.91)
MASK_BASE_LEDS#: length 326.9
  TOP w0.102: Q24.2 199.75,93.61 199.5,93.85 198.89,93.85 v2(198.67,94.07) ; U47.4 11.82,42.69 v2(12.56,41.95) ; v2(111.73,107.67) 111.37,108.04 111.37,108.62 111.62,108.88 Q23.2 Q23.5 ; Q32.5 231.67,94.22 ; 231.67,94.22 232.64,94.22 234.11,95.69 Q33.2 234.11,96.49 v2(235.5,97.88) ; 231.67,94.22 Q32.2
  IN1 w0.084: v2(111.73,107.67) 113.26,106.15 115.14,106.15 115.68,105.6 115.68,98.87 115.95,98.6 v2(116.27,98.6) ; v2(235.5,97.88) 235.5,100.27 233.05,102.72 233.05,106.13 v2(231.95,107.23)
  IN2 w0.122: v2(219.81,93.17) 219.81,94.17 220.39,94.74 222.69,94.74 222.86,94.91 222.86,95.89 225.31,98.35 225.31,102.14 227.31,104.14 227.81,104.14 230.7,107.02 231.75,107.02 v2(231.95,107.23)
  IN3 w0.122: v2(43.97,50.29) 43.97,49.76 44.4,49.32 52.61,49.32 54.83,51.55 54.83,64.86 55.83,65.86 55.83,74.3 56.58,75.05 56.58,77.74 57.59,78.74 57.59,81.56 58.17,82.14 59.29,82.14 64.77,87.62 68.07,87.62 75.9,95.45 94.32,95.45 96.36,97.49 96.36,98.25 103.01,104.9 103.01,105.42 105.22,107.63 105.22,108.89 105.91,109.58 109.22,109.58 110.27,108.53 110.74,108.53 111.61,107.67 v2(111.73,107.67) ; 199.12,95.48 198.67,95.03 v2(198.67,94.07) ; 199.12,95.48 199.12,96.26 198.91,96.48 188.28,96.48 187.49,95.68 184.58,95.68 182.45,93.55 181.17,93.55 180.72,93.1 168.94,93.1 166.58,95.46 157.9,95.46 156.76,96.59 152.98,96.59 152.29,97.28 149.12,97.28 148.24,98.16 148.24,99.48 147.22,100.5 144.32,100.5 143.25,99.43 143.25,98.48 142.9,98.13 142.9,97.35 142.56,97 135.92,97 135.5,96.58 131.5,96.58 130.01,98.07 130.01,99.6 127.93,101.69 119.74,101.69 116.65,98.6 v2(116.27,98.6) ; 199.12,95.48 200.41,95.48 202.65,93.24 217.25,93.24 217.6,93.59 219.39,93.59 v2(219.81,93.17)
  IN4 w0.084: v2(12.56,41.95) 12.73,42.11 16,42.11 16.08,42.2 19.84,42.2 19.93,42.29 21.99,42.29 22.82,43.13 24.73,43.13 25.68,44.08 27.94,44.08 28.87,45 30.45,45 31.76,46.31 33.23,46.31 36.52,49.6 43.28,49.6 v2(43.97,50.29)
  BOTTOM w0.102: Q28.2 v2(231.95,107.23) ; v2(198.67,94.07) 199.1,94.07 199.57,93.6 Q25.2
MASK_SATA_LED#: length 233.1
  TOP w0.102: Q24.5 199.75,94.77 200.08,94.44 v2(200.08,93.98) ; U37.B9 20.18,30.31 v2(20.42,30.56)
  IN3 w0.122: v2(20.42,30.56) 20.8,30.56 21.34,30.01 23.44,30.01 23.97,30.54 27.91,30.54 29.78,32.42 31.73,32.42 32.23,32.92 35.74,32.92 39.08,36.26 44.58,36.26 49.05,40.73 49.05,42.03 49.73,42.71 56.19,42.71 57.54,44.06 57.54,46.11 61.28,49.84 61.28,61.87 62.78,63.38 63.66,63.38 64.79,64.5 64.79,74.94 69.53,79.68 70.49,79.68 73.65,82.84 73.99,82.84 75.01,83.85 75.01,84.74 76.02,85.75 82.05,85.75 85.09,88.79 88.95,88.79 90.43,90.28 92.75,90.28 94.05,91.58 96.02,91.58 98.46,94.02 101.23,94.02 101.77,94.56 102.75,94.56 104.19,95.99 112.08,95.99 112.55,96.46 129.11,96.46 130.73,94.84 136.22,94.84 136.64,95.25 149.14,95.25 149.42,94.98 152.02,94.98 153.84,93.16 153.84,91.36 154.97,90.22 159.11,90.22 159.84,90.95 179.02,90.95 179.55,90.41 179.55,89.66 179.74,89.48 181.73,89.48 182.39,90.13 186.46,90.13 190.33,94 197,94 197.91,93.09 199.11,93.09 200,93.98 v2(200.08,93.98)
MCARD_MISC_PWREN: length 5.8
  TOP w0.102: v2(17.17,37.85) 17.17,37.86 16.01,37.86 15.86,38.02 U37.B53
  BOTTOM w0.102: v2(17.17,37.85) 16.1,37.85 15.89,38.06 15.89,39.59 T97.1
MCARD_PCIE_SATA#: length 195.6
  TOP w0.102: U37.B3 17.18,30.31 17.45,30.58 17.45,30.84 v2(17.87,31.25)
  IN1 w0.084: v2(17.87,31.25) 17.46,30.84 17.46,30.48 18.09,29.85 18.09,26.32 18.94,25.47 v2(18.94,25.12)
  IN2 w0.122: v2(155.05,71.48) 158.14,68.39 158.14,66.2 161.36,62.99 161.36,60.43 160.91,59.98 160.91,50.58 160.4,50.06 145.92,35.58 62.7,35.58 61.24,34.12 56.71,34.12 56.03,34.81 52.75,34.81 49.97,32.03 49.97,31.61 47.54,29.18 45.6,29.18 43.09,26.67 37.03,26.67 36.66,26.3 33.09,26.3 31.18,24.39 31.18,24.14 29.7,22.65 25.1,22.65 23.05,24.7 19.24,24.7 18.94,25 v2(18.94,25.12)
  BOTTOM w0.076: 153.85,70.84 153.71,70.7 152.17,70.7 151.81,70.35 UC1.AC1
  BOTTOM w0.102: 153.85,70.84 154.08,71.07 154.88,71.07 155.05,71.25 v2(155.05,71.48) 155.71,72.14 v1(156.05,72.14) 158.06,72.14 RC12.1
MCARD_WWAN_PWREN: length 209.4
  TOP w0.102: v2(20.87,38.33) 20.68,38.52 U37.B42 ; U22.5 199.87,37.61 199.81,37.55 199.2,37.55 199.01,37.74 197.09,37.74 v1(196.45,37.1) v2(195.62,36.27) ; R50.2 v2(27.93,38.52)
  IN3 w0.122: v2(131.22,28.97) 131.34,28.97 131.78,29.4 132.07,29.4 133.53,30.86 133.53,32.2 137.41,36.07 177.74,36.07 185.53,36.07 186.34,35.26 187.83,35.26 188.09,35.52 189.78,35.52 190.77,36.51 195.37,36.51 v2(195.62,36.27) ; v2(20.87,38.33) 20.87,38.22 21.32,37.77 21.32,36.45 21.76,36.02 22.44,36.02 22.71,36.29 23.39,36.29 23.77,36.68 24.77,36.68 26.78,38.7 27.75,38.7 v2(27.93,38.52)
  BOTTOM w0.102: v2(27.93,38.52) 29.19,38.52 30.16,39.48 31.66,39.48 36.99,44.81 36.99,47.57 37.95,48.53 39.16,48.53 39.47,48.83 41.81,48.83 42.86,49.88 44.29,49.88 44.41,50 44.41,50.37 44.58,50.53 45.8,50.53 46.89,49.44 47.52,49.44 49.22,47.74 50.06,47.74 52.53,45.27 56.93,45.27 58.03,44.18 65.36,44.18 66.06,43.48 124.15,43.48 129.78,37.85 129.78,33.29 130.09,32.98 130.09,30.77 130.94,29.92 130.94,29.25 v2(131.22,28.97)
MCP_TESTLOW1: length 9.3
  BOTTOM w0.076: 128.81,85.57 128.81,83.86 129.96,82.71 130.02,82.54 130.02,82.43 129.97,82.31 129.96,82.28 129.96,82.09 130,81.94 130.1,81.79 UC1.C35
  BOTTOM w0.102: RC46.1 129.7,89.38 129.7,87.46 129.07,86.83 v1(129.07,86.4) 129.07,85.88 128.81,85.61 128.81,85.57
MCP_TESTLOW2: length 9.9
  BOTTOM w0.076: UC1.C34 130.71,81.63 130.54,81.81 130.36,81.81 130.16,82.01 130.13,82.12 130.13,82.25 130.15,82.31 130.16,82.32 130.19,82.4 130.19,82.57 130.1,82.8 130.1,82.9 129.04,83.97 129.04,84.9 v1(129.19,85.06) 129.71,85.57
  BOTTOM w0.102: 129.71,85.57 129.71,87.08 129.97,87.35 129.97,89.37 RC47.1
MCP_TESTLOW3: length 11.4
  TOP w0.102: v2(146.48,66.42) 146.58,66.42 147.31,65.7 147.31,64.86 147.55,64.61 v1(147.55,63.47) 147.55,62.31 146.95,61.72 146.95,58.27 147.12,58.1 147.12,57.6 146.31,56.79 RC50.1
  BOTTOM w0.076: UC1.AK8 146.91,66.42 v2(146.48,66.42)
MCP_TESTLOW4: length 22.7
  TOP w0.102: v2(163.42,62.41) 163.42,62.36 v1(163.83,61.95)
  IN4 w0.084: v2(163.42,62.41) 163.42,62.56 160.17,65.81 155.61,65.81 154.98,65.18 152.88,65.18 151.65,66.41 150.8,66.41 150.42,66.79 148.51,66.79 148.37,66.93 147.37,66.93 146.99,66.55 146.99,66.07 v2(146.51,65.58)
  BOTTOM w0.076: UC1.AL8 146.64,65.71 v2(146.51,65.58)
  BOTTOM w0.102: RC52.1 163.84,61.61 163.42,62.03 v2(163.42,62.41)
MDP_AUX: length 72.2
  TOP w0.089: C174.2 227.08,88.69 227.08,88.52 v2(226.67,88.11) ; U19.23 168.64,84.45 168.68,84.4 168.78,84.4 168.82,84.36 168.82,84.22 168.72,84.13 168.33,84.13 168.24,84.21 167.39,84.21 v2(167.21,84.39)
  IN1 w0.084: v2(226.67,88.11) 226.76,88.11 226.89,87.99 226.89,87.74 226.75,87.6 219.1,87.6 218.79,87.3 214.45,87.3 211.2,84.05 210.89,84.05 210.46,83.62 210.12,83.62 206.16,79.66 205.34,79.66 202.42,76.75 193.08,76.75 192.19,77.63 188.22,77.63 184.42,81.43 177.61,81.43 176.82,82.22 172.17,82.22 171.93,81.99 171.18,81.99 168.93,84.24 167.36,84.24 v2(167.21,84.39)
MDP_AUX#: length 72.4
  TOP w0.089: U19.24 169.14,84.09 168.85,83.81 168.19,83.81 168.11,83.89 167.46,83.89 v2(167.37,83.81) ; v2(227.27,88.11) 227.27,88.1 226.61,87.44 C175.2
  IN1 w0.084: v2(227.27,88.11) 227.27,87.59 226.9,87.22 219.25,87.22 218.95,86.92 214.61,86.92 211.36,83.67 211.05,83.67 210.62,83.24 210.28,83.24 206.32,79.28 205.5,79.28 202.58,76.36 192.92,76.36 192.03,77.25 188.06,77.25 184.26,81.05 177.46,81.05 176.66,81.84 172.32,81.84 172.09,81.61 171.02,81.61 168.77,83.86 167.42,83.86 v2(167.37,83.81)
MDP_AUX#_C: length 51.3
  TOP w0.089: v2(236.8,87.03) 236.77,86.99 R163.2 236.04,85.89 236.02,85.91 U49.8 233.78,85.91 233.13,86.56 U49.6
  IN1 w0.084: v2(236.8,87.03) 236.8,87.4 237,87.6 237.65,87.6 237.85,87.39 239.03,87.39 243.45,82.97 244.97,82.97 245.99,81.96 247.61,81.96 247.89,82.23 247.89,83.07 249.44,84.62 258.35,84.62 258.63,84.9 264.92,84.9 265.65,85.64 269.62,85.64 270.52,86.53 270.52,86.81 v2(270.74,87.03)
  BOTTOM w0.089: v2(270.74,87.03) 270.66,87.11 270.66,88.42 270.8,88.55 JMDP1.18
MDP_AUX_C: length 54.1
  TOP w0.089: v2(231.19,88.43) 231.11,88.51 U49.3 ; U49.11 R165.2 236.77,88.18 v2(237.08,88.49)
  IN1 w0.084: v2(231.19,88.43) 231.7,88.94 234.17,88.94 234.29,88.81 234.29,88.59 234.42,88.47 234.59,88.47 234.71,88.59 234.71,88.75 234.84,88.87 235.01,88.87 235.13,88.75 235.13,88.62 235.26,88.49 v2(237.08,88.49) 237.08,88.04 237.31,87.81 237.73,87.81 237.94,87.6 239.12,87.6 243.54,83.18 245.06,83.18 246.08,82.17 247.52,82.17 247.68,82.32 247.68,83.16 249.35,84.84 258.27,84.84 258.55,85.11 264.83,85.11 265.56,85.85 269.53,85.85 270.31,86.62 270.31,86.78 v2(270.05,87.03)
  BOTTOM w0.089: 271.04,89.1 270.45,88.51 270.45,87.43 v2(270.05,87.03)
  BOTTOM w0.102: 271.04,89.1 271.09,89.15 JMDP1.16
MDP_CA_DET: length 68.7
  TOP w0.102: U49.1 230.63,89.81 v2(231.22,90.4) ; U49.4 228.37,87.86 v2(227.79,88.44) ; v2(238.29,88.24) 237.8,88.73 R167.1 v1(239.04,89.37)
  IN1 w0.084: v2(273.11,94.41) 273.08,94.41 271.35,92.68 271.35,90.33 269.25,88.24 263.8,88.24 261.39,85.84 249.44,85.84 247.16,83.55 247.16,83.05 246.91,82.79 246.41,82.79 245.34,83.87 243.76,83.87 239.98,87.65 239.98,88.32 239.5,88.8 238.46,88.8 238.29,88.63 v2(238.29,88.24) 238,88.53 237.99,88.53 236.57,89.95 231.61,89.95 231.22,90.35 v2(231.22,90.4) 229.26,88.44 v2(227.79,88.44)
  BOTTOM w0.102: v2(273.11,94.41) 273.11,93.15 272.71,92.75 JMDP1.4 ; v2(231.22,90.4) 231.6,90.78 232.87,90.78 233.3,90.35 Q31.2
MDP_CA_DET#: length 13.3
  TOP w0.102: v2(236.21,87.05) 236.04,87.21 U49.10 ; v2(232.46,90.35) 233.65,89.16 U49.13 235.63,89.16 235.84,89.37 R67.2
  BOTTOM w0.102: Q31.1 231.81,89.7 v2(232.46,90.35) 233.15,89.66 234.47,89.66 236.24,87.89 236.24,87.08 v2(236.21,87.05)
MDP_HPD: length 135.4
  TOP w0.102: v2(168.38,89.71) 168.38,89.39 168.64,89.13 U19.16
  IN3 w0.122: v2(168.38,89.71) 168.38,89.33 169.04,88.67 174.75,88.67 176.37,87.05 184.84,87.05 186.85,89.06 190.17,89.06 192.77,91.66 207.41,91.66 209.37,89.7 210.56,89.7 210.86,89.41 226.32,89.41 226.57,89.66 233.88,89.66 234.14,89.91 239.37,89.91 240.37,88.91 240.37,87.83 242.79,85.41 260.28,85.41 262.18,83.51 265.06,83.51 267.82,80.76 267.82,77.86 v2(267.79,77.83)
  IN4 w0.084: v2(271.77,93.95) 271.58,93.76 271.58,91.17 266.98,86.58 266.98,82.42 267.79,81.61 v2(267.79,77.83)
  BOTTOM w0.102: v2(168.38,89.71) 168.38,90.04 v1(168.06,90.36) 167.2,90.36 R164.2 ; v2(271.77,93.95) 271.04,93.95 270.82,93.73 270.82,93.57 271.04,93.35 JMDP1.2
MDP_LANE_N0: length 2.2
  TOP w0.089: U19.42 177.28,87.46 177.33,87.41 177.6,87.41 177.85,87.67 178.22,87.67 C163.1
MDP_LANE_N0_C: length 105.8
  TOP w0.089: C163.2 179.58,87.85 179.85,87.85 180.12,88.12 v2(180.12,88.25)
  IN2 w0.102: JMDP1.5 274.2,92.84 274.2,93.49 273.88,93.81 273.16,93.81 268.74,89.39 262.28,89.39 261.54,88.66 244.66,88.66 240,93.32 228.38,93.32 227.14,94.55 224.19,94.55 223.82,94.18 221.29,94.18 220.31,93.2 220.31,92.38 219.85,91.92 216.69,91.92 216.44,92.18 212.69,92.18 212.42,92.44 210.28,92.44 210.06,92.66 206.53,92.66 206.37,92.49 196.05,92.49 195.91,92.63 188.29,92.63 187.9,92.24 186.03,92.24 185.6,91.81 185.6,91.46 185.28,91.15 182.48,91.15 180.92,89.59 180.58,89.59 180.12,89.12 v2(180.12,88.25)
MDP_LANE_N1: length 2
  TOP w0.089: C165.1 177.91,85.9 177.78,85.9 177.72,85.96 177.72,86.14 177.49,86.37 177.22,86.37 177.12,86.46 U19.40
MDP_LANE_N1_C: length 106.7
  TOP w0.089: v2(180.25,84.77) 180.11,84.9 180.11,85.6 179.84,85.87 179.34,85.87 C165.2
  IN2 w0.102: v2(180.25,84.77) 180.08,84.94 180.08,85.59 182.64,88.15 182.64,89.1 183.15,89.61 186.13,89.61 186.55,90.03 188.27,90.03 188.65,90.41 189.36,90.41 190.59,91.64 194.92,91.64 195.14,91.41 206.69,91.41 206.93,91.66 209.44,91.66 210.06,91.03 210.71,91.03 211.16,90.58 213.41,90.58 213.7,90.87 215.36,90.87 215.45,90.78 220.21,90.78 221.92,92.49 221.92,92.81 222.3,93.19 226.24,93.19 227.13,92.3 239.45,92.3 244.08,87.67 263.77,87.67 264.34,88.24 269.08,88.24 271.66,90.82 273.2,90.82 273.49,90.53 274.41,90.53 JMDP1.11
