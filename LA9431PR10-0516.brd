# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DOCK_DCIN_IS-: length 208.9
  TOP w0.102: PQ703.4 45.32,14.23 44.21,15.34 44.06,15.34 42.79,16.62 42.79,18.18 42.33,18.64 42.33,19.36 42.09,19.6 42.09,21.13 43.62,22.67 44.66,22.67 47.8,25.81 47.8,28.23 50.32,30.74 50.32,32.98 49.6,33.69 49.1,33.69 46.72,36.06 46.72,37.71 49.37,40.35 49.37,41.09 49.6,41.32 49.6,44.6 48.5,45.69 48.5,46.77 49.29,47.56 50.69,47.56 51.05,47.92 51.05,48.4 v2(51.29,48.64)
  IN2 w0.122: v2(51.29,48.64) 51.14,48.79 51.14,49.44 50.38,50.2 46.86,50.2 46.24,50.82 45.63,50.82 45.25,50.43 45.25,50.31 v2(45.06,50.11)
  IN4 w0.084: v2(45.06,50.11) 45.24,50.3 45.24,50.47 45.63,50.86 48.19,50.86 51.86,54.53 51.86,55.61 53.72,57.46 53.72,60.13 51.61,62.25 51.61,62.62 49.25,64.98 49.25,69.92 49.9,70.57 49.9,77.36 57.81,85.27 60.79,85.27 67.74,92.22 81.25,92.22 83.76,94.74 88.06,94.74 88.67,94.13 96.77,94.13 99.66,97.02 99.66,103.44 106.52,110.29 113.13,110.29 114.63,111.79 148.38,111.79 148.87,111.3 148.87,110.62 v2(149.06,110.44)
  BOTTOM w0.102: JDOCK1.136 148.95,109.6 148.88,109.67 148.88,110.26 v2(149.06,110.44)
DOCK_DET#: length 430.6
  TOP w0.102: v2(20.88,37.55) 20.89,37.55 21.32,37.99 21.32,38.58 21.18,38.73 U37.B41 ; v2(150.93,110.59) 150.56,110.96 149.77,110.96 149.57,110.76 149.57,110.04 149.21,109.69 148.41,109.69 147.96,109.23 R272.1 148.79,109 D19.2
  TOP w0.254: PQ817.2 144.88,11.29 PR852.1 146.37,12.6 v1(144.91,14.05) 144.41,14.55 v2(137.62,14.55) ; PU808.2 208.95,6.45 209.33,6.83 v2(209.55,6.83)
  IN1 w0.084: v2(137.62,14.55) 136.94,15.23 134.33,15.23 133.5,14.39 124.05,14.39 120.91,17.53 82.76,17.53 81.26,19.03 81.26,23.33 80.78,23.81 63.44,23.81 62.96,23.32 57.28,23.32 56.87,22.92 53.63,22.92 51.58,20.86 51.58,18.55 47.85,14.82 47.85,13.55 46.55,12.25 46.55,10.76 45.58,9.79 45.58,8.78 45.15,8.35 45.15,7.11 44.54,6.5 40.76,6.5 40.29,6.02 38.25,6.02 37.49,5.26 34.94,5.26 34.21,5.99 32.17,5.99 31.34,6.82 29.65,6.82 29.08,6.25 24.29,6.25 23.85,6.69 22.57,6.69 21.98,7.28 21.98,8.2 21.02,9.17 19.88,9.17 19.38,9.67 19.38,13.94 19.25,14.07 19.25,23.61 20.57,24.93 20.57,26.07 19.76,26.89 19.76,27.15 19.11,27.8 19.11,36.81 19.29,36.99 20.32,36.99 v2(20.88,37.55)
  IN1 w0.254: v2(209.55,6.83) 209.55,4.09 208.08,2.62 205.36,2.62 204.28,1.54 201.94,1.54 201.16,2.32 201.16,2.84 v2(201.27,2.96)
  IN2 w0.122: v2(161.53,100.2) 161.53,96.06 162.11,95.49 166.46,95.49 171.73,90.21 171.73,88.54 170.97,87.78 170.97,85.93 169.71,84.67 169.71,83.68 170.65,82.74 170.65,80.94 169.27,79.55 168.56,79.55 168.13,79.13 168.13,77.59 168.39,77.33 168.39,75.05 168.35,75.01 168.35,73.51 168.67,73.19 168.67,68.59 169.84,67.42 169.84,66.21 169.04,65.41 169.04,62.49 169.59,61.94 169.59,58.76 170.69,57.66 170.69,54.74 171.25,54.18 171.25,46.94 v2(163.64,39.33)
  IN3 w0.122: v2(150.93,110.59) 151.6,109.92 158.07,109.92 159.32,108.67 159.32,102.42 v2(161.53,100.2) ; v2(137.62,14.55) 138.34,15.28 140.09,15.28 141.44,16.63 146.34,16.63 147.12,15.85 163.05,15.85 165.01,13.88 166.76,13.88 170.85,9.79 176.07,9.79 177.21,10.93 178.06,10.93 183.17,5.83 195.48,5.83 197.27,4.04 200.45,4.04 201.27,3.21 v2(201.27,2.96)
  BOTTOM w0.102: v2(163.64,39.33) 161.65,37.34 140.86,37.34 138.89,35.36 138.89,31.8 135.13,28.05 135.13,24.08 136.45,22.76 136.45,19.38 135.85,18.78 135.85,16.58 137.62,14.81 v2(137.62,14.55) ; v2(20.88,37.55) 21.32,38 21.32,38.86 22.14,39.67 25.28,39.67 26.75,41.13 PR856.1
  BOTTOM w0.254: PR853.1 201.6,3.29 v2(201.27,2.96)
DOCK_DET_R#: length 5
  TOP w0.102: v1(151.63,110.11) 151.41,109.89 v2(150.86,109.89) 150.2,109.23 D19.1
  BOTTOM w0.102: JDOCK1.142 150.45,109.61 150.74,109.89 v2(150.86,109.89) 150.95,109.81 JDOCK1.144
DOCK_HP_DET: length 392.5
  TOP w0.102: v2(19.52,27.95) 19.43,28.04 U37.A7 ; v2(280.84,26.75) 281.09,26.49 281.09,25.34 281.51,24.92 Q21.2 282.05,24.92 282.37,24.6 R158.2
  IN3 w0.122: v2(280.84,26.75) 280.84,27.01 280.34,27.51 280.34,27.65 277.44,30.55 277.44,32.4 275.76,34.09 275.76,38.44 273.35,40.84 273.35,44.09 272.21,45.24 272.21,46.73 267.3,51.63 267.3,71.33 266.45,72.19 260.28,72.19 258.69,73.79 256.79,73.79 255.59,74.99 248.06,74.99 247.06,76 246.17,76 241.7,80.47 239.25,80.47 238.82,80.89 224.62,80.89 223.39,79.66 214.49,79.66 208.98,74.16 208.98,73.45 208.35,72.82 207.79,72.82 206.94,71.97 204.62,71.97 203.49,70.84 203.49,69.84 204.32,69.01 204.32,68.3 204.71,67.91 204.71,64.81 203.88,63.97 203.88,56.48 204.62,55.73 204.62,51.64 205.55,50.71 205.55,46.69 206.16,46.08 206.16,41.87 203.46,39.18 202.53,39.18 201.98,38.63 201.98,36.81 197.63,32.47 196.94,32.47 195.07,30.6 193.89,30.6 193.27,31.22 193.27,32.17 193,32.44 189.46,32.44 188.62,31.6 187.09,31.6 186.05,32.64 185.71,32.64 184.63,33.72 139.85,33.72 133.93,27.8 133.93,27.3 132.45,25.81 132.45,25.32 131.79,24.66 130.96,24.66 v2(130.63,24.34)
  BOTTOM w0.102: v2(130.63,24.34) 130.45,24.34 130.19,24.6 130.19,25.48 130.24,25.53 130.24,28.75 129.17,29.82 129.17,32.52 128.83,32.86 128.83,36.94 126.69,39.08 120.33,39.08 120.08,38.83 62.27,38.83 61.12,39.98 56.01,39.98 55.16,40.83 52.81,40.83 52.46,41.18 50.18,41.18 49.58,41.78 49.58,43.72 46.47,46.83 42,46.83 36.5,41.33 v1(35.82,41.33) 35.82,40.04 31.31,35.53 30.58,35.53 28.77,33.72 28.77,27.2 29.29,26.68 29.29,26.14 29.05,25.9 28.8,25.9 28.14,25.23 25.66,25.23 24.14,26.75 20.33,26.75 19.72,27.36 19.72,27.74 19.52,27.93 v2(19.52,27.95)
DOCK_LOM_ACTLED_YEL#: length 112.1
  IN3 w0.122: v2(140.26,111.15) 140.69,111.59 157.12,111.59 159.82,108.89 159.82,106.34 160.61,105.55 160.61,103.24 161.27,102.59 166.11,102.59 172.53,96.16 179.46,96.16 184.1,100.79 196.67,100.79 197.51,101.62 200.18,101.62 201.63,100.18 206.36,100.18 206.78,99.76 206.78,97.25 207.25,96.78 211.89,96.78 212.11,97 216.97,97 217.17,96.8 223.77,96.8 224.99,95.58 226.21,95.58 228.01,93.79 v2(228.49,93.79)
  BOTTOM w0.102: U23.19 226.93,92.82 227.32,92.43 228.46,92.43 228.71,92.68 v1(228.71,92.86) 228.71,93.56 v2(228.49,93.79) ; v2(140.26,111.15) 139.99,110.88 139.99,110.02 139.95,109.98 JDOCK1.100
DOCK_LOM_SPD10LED_GRN#: length 140.1
  TOP w0.102: v1(219.76,92.62) 219.7,92.56 v2(219.21,92.56)
  IN2 w0.122: v2(219.21,92.56) 219.4,92.75 219.4,94.1 220.66,95.37 221.4,95.37 221.78,95.74 221.78,96.01 222.18,96.41 223.03,96.41 225.06,98.45 225.06,102.25 226.43,103.61 v2(226.43,104.69)
  IN3 w0.122: v2(114.05,97.83) 114.05,97.82 114.66,97.21 129.47,97.21 131.09,95.58 135.91,95.58 136.33,96 143.69,96 145.13,97.44 145.13,97.91 144.59,98.45 144.59,99.54 144.79,99.73 145.16,99.73 148.69,96.2 148.92,96.2 149.64,95.48 152.23,95.48 156.51,91.2 179.12,91.2 179.83,90.48 179.83,89.89 180,89.72 181.57,89.72 182.23,90.38 186.34,90.38 190.21,94.25 197.11,94.25 197.73,93.62 198.82,93.62 199.11,93.91 199.11,94.63 199.59,95.11 200.43,95.11 202.55,92.99 216.13,92.99 216.8,92.32 218.97,92.32 v2(219.21,92.56)
  BOTTOM w0.102: JDOCK1.3 113.95,99.66 114.05,99.57 114.18,99.57 114.4,99.35 114.4,98.77 114.05,98.41 v2(114.05,97.83) ; U23.40 v2(226.43,104.69)
DOCK_LOM_SPD100LED_ORG#: length 128.8
  IN3 w0.122: v2(215.04,96.11) 214.87,96.28 205.45,96.28 204.3,97.42 201.96,97.42 199.79,99.59 195.97,99.59 195.34,98.96 185.37,98.96 181.79,95.38 180.45,95.38 179.92,94.85 169.72,94.85 167,97.57 161.88,97.57 160.9,98.54 153.94,98.54 148.35,104.13 148.35,105.76 146.76,107.36 124.16,107.36 122.38,109.14 114.4,109.14 v2(113.65,109.89)
  BOTTOM w0.102: JDOCK1.4 113.95,109.6 v2(113.65,109.89) ; U23.20 226.43,92.69 226.11,92.37 223.39,92.37 v1(222.57,93.19) 222.27,93.19 218.59,96.88 215.44,96.88 215.04,96.47 v2(215.04,96.11)
DOCK_LOM_TRD0+: length 117.7
  IN1 w0.084: v2(223.87,101.63) 223.93,101.57 225.79,101.57 227.13,100.24 227.13,94.6 224.38,91.85 221.14,91.85 220.41,91.12 216.59,91.12 216.13,90.66 215.39,90.66 214.82,91.24 212.83,91.24 211.15,89.56 206.76,89.56 205.82,90.5 205.82,91.61 201.56,95.87 200.05,95.87 199.82,96.1 196.39,96.1 194.64,97.85 188.67,97.85 186.99,96.16 184.38,96.16 181.26,93.04 167.84,93.04 165.79,95.09 158.14,95.09 156.83,96.39 152.92,96.39 149.13,100.18 148.37,100.18 144.5,104.05 144.5,105.7 141,109.2 141,110.98 v2(140.89,111.1)
  BOTTOM w0.089: v2(140.89,111.1) 140.99,110.99 140.99,109.61 140.88,109.5 JDOCK1.104 ; v2(223.87,101.63) 224,101.5 224.2,101.5 224.29,101.59 U23.36
DOCK_LOM_TRD0-: length 115.8
  IN1 w0.084: v2(141.47,111.1) 141.39,111.01 141.39,109.36 144.88,105.86 144.88,104.21 148.53,100.56 149.29,100.56 153.08,96.78 156.99,96.78 158.3,95.47 165.95,95.47 168,93.42 181.1,93.42 184.23,96.54 186.83,96.54 188.51,98.23 194.8,98.23 196.54,96.49 199.98,96.49 200.21,96.25 201.71,96.25 206.2,91.77 206.2,90.66 206.91,89.94 210.99,89.94 212.67,91.62 214.97,91.62 215.54,91.05 215.97,91.05 216.43,91.5 220.26,91.5 220.98,92.23 224.22,92.23 226.75,94.75 226.75,100.08 225.64,101.19 224.01,101.19 v2(223.87,101.05)
  BOTTOM w0.089: U23.35 224.29,101.09 224.2,101.18 224,101.18 v2(223.87,101.05) ; v2(141.47,111.1) 141.31,110.94 141.31,109.61 141.38,109.54 JDOCK1.106
DOCK_LOM_TRD1+: length 107.3
  IN1 w0.084: v2(142.21,110.91) 142.23,110.89 142.23,110.88 142.23,109.35 146.08,105.51 146.08,103.85 148.78,101.15 149.54,101.15 153.32,97.37 157.24,97.37 158.54,96.06 166.54,96.06 168.53,94.07 180.91,94.07 185.22,98.37 187.82,98.37 188.27,98.82 195.04,98.82 196.79,97.08 200.22,97.08 200.46,96.84 201.96,96.84 202.4,96.4 203.79,96.4 207.26,92.92 207.58,92.92 217.17,92.92 217.87,93.62 224.36,93.62 225.6,94.86 225.6,99.07 225.13,99.54 223.96,99.54 v2(223.87,99.63)
  BOTTOM w0.089: v2(142.21,110.91) 142.29,110.83 142.29,109.74 142.45,109.58 JDOCK1.110 ; v2(223.87,99.63) 224,99.5 224.2,99.5 224.29,99.59 U23.32
DOCK_LOM_TRD1-: length 105.6
  IN1 w0.084: v2(223.87,99.05) 223.98,99.16 224.97,99.16 225.22,98.91 225.22,95.02 224.21,94 217.71,94 217.01,93.31 207.58,93.31 207.42,93.31 203.94,96.78 202.56,96.78 202.54,96.8 202.12,97.22 200.62,97.22 200.38,97.46 196.95,97.46 195.2,99.2 188.11,99.2 187.66,98.75 185.06,98.75 180.75,94.45 168.69,94.45 166.69,96.44 158.7,96.44 157.39,97.75 153.48,97.75 149.69,101.53 148.94,101.53 146.46,104.01 146.46,105.66 142.61,109.51 142.61,110.72 v2(142.8,110.91)
  BOTTOM w0.089: v2(142.8,110.91) 142.61,110.72 142.61,109.77 142.95,109.42 JDOCK1.112 ; v2(223.87,99.05) 224,99.18 224.2,99.18 224.29,99.09 U23.31
DOCK_LOM_TRD2+: length 98.3
  IN1 w0.084: v2(144.73,110.58) 144.6,110.72 144.29,110.72 143.94,110.37 143.94,109.58 144.39,109.13 144.58,109.13 148.13,105.57 148.13,103.73 149.36,102.51 150.1,102.51 153.88,98.72 168.38,98.72 171.69,95.42 180.35,95.42 184.65,99.72 187.26,99.72 187.71,100.18 195.65,100.18 197.36,98.46 200.83,98.46 201.09,98.2 202.52,98.2 202.96,97.76 204.35,97.76 206.46,95.65 213.4,95.65 214.01,95.03 220.37,95.03 220.65,95.32 220.65,95.67 v2(220.52,95.8)
  BOTTOM w0.089: v2(144.73,110.58) 144.87,110.72 145.27,110.72 145.47,110.52 145.47,109.6 145.38,109.51 JDOCK1.122 ; U23.27 224.27,97.09 224.18,97 223.32,97 223.06,96.75 221.05,96.75 220.71,96.41 220.71,95.99 v2(220.52,95.8)
DOCK_LOM_TRD2-: length 100.1
  IN1 w0.084: v2(144.73,111.17) 144.66,111.1 144.13,111.1 143.56,110.53 143.56,109.42 144.23,108.75 144.42,108.75 147.75,105.42 147.75,103.58 149.2,102.13 149.94,102.13 153.72,98.34 168.23,98.34 171.53,95.04 180.51,95.04 184.81,99.34 187.42,99.34 187.87,99.79 195.49,99.79 197.21,98.08 200.67,98.08 200.93,97.82 202.36,97.82 202.8,97.38 204.19,97.38 206.3,95.27 206.61,95.27 206.61,95.27 213.24,95.27 213.86,94.65 220.52,94.65 221.03,95.16 221.03,95.67 v2(221.16,95.8)
  BOTTOM w0.089: U23.26 224.27,96.59 224.17,96.68 223.45,96.68 223.19,96.43 221.18,96.43 221.03,96.28 221.03,95.92 v2(221.16,95.8) ; JDOCK1.124 145.88,109.51 145.78,109.61 145.78,110.65 145.4,111.04 144.87,111.04 v2(144.73,111.17)
DOCK_LOM_TRD3+: length 96.3
  IN1 w0.084: v2(223.7,95.23) 223.56,95.1 223.28,95.1 223.19,95.19 223.19,96.33 222.84,96.68 220.27,96.68 219.82,97.13 209.41,97.13 208.9,96.62 207.34,96.62 206.93,97.03 206.93,98.3 206.08,99.15 204.91,99.15 204.49,98.73 203.37,98.73 202.53,99.57 199.89,99.57 199.36,100.09 197.26,100.09 196.2,101.15 184.28,101.15 179.53,96.39 172.59,96.39 169.28,99.69 154.29,99.69 150.5,103.48 149.78,103.48 149.15,104.11 149.15,106.02 145.98,109.19 145.98,110.05 146.35,110.41 146.6,110.41 146.61,110.42 v2(146.63,110.4)
  BOTTOM w0.089: JDOCK1.128 146.95,109.47 147.06,109.58 147.06,110.42 146.95,110.54 146.77,110.54 v2(146.63,110.4) ; U23.23 224.26,95.09 224.21,95.03 223.89,95.03 v2(223.7,95.23)
DOCK_LOM_TRD3-: length 98.2
  IN1 w0.084: v2(146.63,110.98) 146.44,110.79 146.19,110.79 145.6,110.21 145.6,109.04 148.77,105.86 148.77,103.95 149.63,103.1 150.34,103.1 154.13,99.31 169.13,99.31 172.43,96.01 179.69,96.01 184.44,100.77 196.04,100.77 197.1,99.71 199.21,99.71 199.73,99.19 202.37,99.19 203.21,98.35 204.65,98.35 205.07,98.77 205.93,98.77 206.55,98.14 206.55,96.87 207.18,96.24 209.06,96.24 209.57,96.75 219.67,96.75 220.11,96.3 222.68,96.3 222.81,96.18 222.81,95.03 223.13,94.72 223.63,94.72 v2(223.7,94.65)
  BOTTOM w0.089: v2(146.63,110.98) 146.76,110.86 147.1,110.86 147.38,110.58 147.38,109.58 147.45,109.51 JDOCK1.130 ; v2(223.7,94.65) 223.7,94.66 223.76,94.72 223.76,94.72 224.21,94.72 224.33,94.59 U23.22
DOCK_MIC_DET: length 416.8
  TOP w0.102: v2(279.49,27.6) 279.36,27.46 279.36,25.09 279.54,24.92 Q21.5 280.2,24.92 280.58,24.54 280.58,24.21 281.47,23.32 R159.2 ; v2(129.91,18.85) v1(129.91,19.52) ; U37.B8 19.68,30.12 19.91,30.35 19.91,30.92 19.66,31.18 v2(19.51,31.18)
  IN3 w0.122: v2(279.49,27.6) 279.49,28.15 277.19,30.45 277.19,32.3 274.66,34.83 274.66,38.58 273.1,40.14 273.1,43.99 270.82,46.28 270.73,46.28 267.06,49.95 267.06,71.23 266.34,71.94 260.18,71.94 258.75,73.38 256.85,73.38 255.48,74.74 247.96,74.74 246.95,75.75 246.07,75.75 241.6,80.22 239.15,80.22 238.72,80.64 224.72,80.64 223.49,79.41 214.59,79.41 209.23,74.05 209.23,73.35 208.45,72.57 207.9,72.57 207.05,71.72 204.72,71.72 203.74,70.74 203.74,69.94 204.57,69.11 204.57,68.4 204.96,68.01 204.96,64.7 204.12,63.87 204.12,56.58 204.87,55.84 204.87,51.78 205.8,50.86 205.8,46.8 206.41,46.19 206.41,41.77 203.57,38.93 202.76,38.93 202.22,38.39 202.22,36.71 201.27,35.75 201.27,30.48 205.26,26.49 205.26,22.38 203.77,20.89 203.77,17.11 202.75,16.09 200.54,16.09 199.63,17.01 198.63,17.01 197.25,15.63 194.74,15.63 193.9,14.78 192.5,14.78 188.77,18.52 178.26,18.52 177.88,18.14 139.54,18.14 139.34,17.93 133.71,17.93 133.5,18.14 132.88,18.14 132.33,18.69 130.07,18.69 v2(129.91,18.85)
  BOTTOM w0.102: v2(129.91,18.85) 130.9,19.85 130.9,23.22 129.9,24.23 129.9,25.09 129.38,25.62 129.38,28.97 128.71,29.63 128.71,32.33 128.37,32.67 128.37,36.75 126.5,38.62 120.52,38.62 120.27,38.37 62.08,38.37 61.53,38.92 59.54,38.92 59.22,39.24 56.1,39.24 54.97,40.37 52.62,40.37 52.35,40.64 48.56,40.64 46.16,38.25 43.55,38.25 41.74,36.44 34.95,36.44 34.43,35.92 32.45,35.92 31.61,35.08 30.77,35.08 29.22,33.53 29.22,27.39 29.75,26.86 29.75,25.95 29.24,25.44 28.99,25.44 28.33,24.78 25.47,24.78 23.95,26.29 20.42,26.29 20.37,26.24 18.28,26.24 17.88,26.63 17.88,29.36 18.95,30.42 18.95,30.62 v2(19.51,31.18)
DOCK_POR_RST#: length 197.1
  TOP w0.102: U38.A21 31.14,12.83 31.36,12.61 31.36,12.15 R369.2 31.99,11.53 32.75,10.77 33.9,10.77 34.21,10.45 34.91,10.45 v2(35.24,10.78) C357.1
  IN1 w0.084: v2(56.41,66.78) 56.41,64.11 57.66,62.86 57.66,58.94 57.1,58.38 57.1,50.05 48.95,41.89 48.95,41.14 46.9,39.09 46.9,32.14 45.81,31.05 45.81,27.41 44.98,26.58 44.98,24.3 44.49,23.81 42.35,23.81 42.19,23.65 42.19,22.21 41.98,22 41.98,18.23 39.37,15.62 39.37,14.59 36.64,11.86 36.64,11.38 36.04,10.78 v2(35.24,10.78)
  IN2 w0.122: v2(58.5,82.93) 58.76,82.67 58.76,72.91 55.89,70.04 55.89,68.82 56.41,68.3 v2(56.41,66.78)
  IN4 w0.084: v2(58.5,82.93) 59.14,82.93 68.01,91.8 81.42,91.8 83.94,94.32 87.87,94.32 88.48,93.71 98.18,93.71 102.38,97.92 111.48,97.92 116.21,102.65 128.25,102.65 132.32,106.71 142.79,106.71 144.67,108.6 148.86,108.6 v2(150.11,109.85)
  BOTTOM w0.102: v2(150.11,109.85) 149.95,109.69 JDOCK1.140
DOCK_PSID: length 82.8
  TOP w0.102: v1(79.6,92.14) 79.59,92.15 v2(79.59,92.91)
  TOP w0.254: PU111.1 79.6,92.92 v2(79.59,92.91)
  IN3 w0.122: v2(79.59,92.91) 79.59,92.71 81.02,91.28 86.81,91.28 89.6,94.07 94.99,94.07 97.43,96.51 100.2,96.51 103.04,99.34 109.83,99.34 110.16,99.68 112.25,99.68 116.05,103.48 122.85,103.48 125.14,105.77 127.43,105.77 130.75,102.45 147.21,102.45 148.95,100.71 v2(148.95,99.26)
  BOTTOM w0.102: JDOCK1.135 148.95,99.27 v2(148.95,99.26)
DOCK_PWR_BTN#: length 247.5
  TOP w0.102: C342.1 R330.2 14.02,3.01 17.51,3.01 v1(17.68,3.17) 18.15,3.64 v2(18.15,4.1)
  IN1 w0.084: v2(8.22,39.71) 8.22,39.19 9.74,37.66 9.74,36.73 9.54,36.53 9.05,36.53 8.47,35.95 8.47,34.76 9.25,33.98 9.65,33.98 9.81,33.83 9.81,32.32 9.2,31.71 9.2,22.97 11.08,21.09 11.08,8.3 11.3,8.08 11.3,4.98 12.47,3.82 13.12,3.82 14.82,5.52 15.7,5.52 16.37,4.85 16.37,4.05 16.69,3.73 17.78,3.73 v2(18.15,4.1)
  IN4 w0.084: v2(8.22,39.71) 9.09,39.71 9.37,39.99 9.37,41.26 9.77,41.66 10.27,41.66 10.52,41.41 12.94,41.41 13.43,41.9 16.52,41.9 16.62,41.8 18.35,41.8 18.54,41.99 19.93,41.99 20.02,42.08 22.07,42.08 22.91,42.92 24.82,42.92 25.77,43.87 28.03,43.87 28.96,44.79 30.54,44.79 31.85,46.1 33.31,46.1 36.6,49.39 48.94,49.39 50.99,51.44 50.99,52.08 51.53,52.63 51.53,52.83 52.3,53.6 52.3,55.44 54.14,57.28 54.14,60.31 52.49,61.96 52.49,62.97 49.75,65.71 49.75,69.69 51.45,71.39 51.45,78.3 55.6,82.46 58.97,82.46 66.05,89.54 74.33,89.54 75.96,91.17 86.7,91.17 88.97,93.44 99.42,93.44 103.69,97.71 111.57,97.71 116.3,102.44 128.34,102.44 132.41,106.5 146.05,106.5 146.05,106.43 v2(147.29,105.18)
  BOTTOM w0.102: v2(147.29,105.18) 148.95,103.53 149.68,103.53 149.95,103.26 JDOCK1.139
DOCK_PWR_SW#: length 18.3
  TOP w0.102: v2(17.39,9.8) 17.39,9.94 18.78,11.33 U38.A63 ; v2(15.16,3.82) 14.81,3.47 R330.1 C344.1 14.02,4.81 11.39,4.81 R328.2
  BOTTOM w0.102: v2(17.39,9.8) 17.06,9.8 15.31,8.05 14.29,8.05 13.86,7.62 13.41,7.62 13.08,7.29 13.08,6.55 14.03,5.6 14.03,4.36 14.57,3.82 v2(15.16,3.82)
DOCK_SMB_ALERT#: length 352.3
  TOP w0.102: v2(9.3,36.93) 9.3,36.4 9.6,36.09 R292.2 ; U37.A51 14.42,37.27 14.08,36.93 13.74,36.93 v2(13.5,37.17)
  TOP w0.254: PQ1.3 153.85,12.51 152.86,13.5 147.23,13.5 145.68,15.05 137.43,15.05 v2(136.93,14.55) 136.02,15.47 134.04,15.47 132.77,14.2 v1(130.84,14.2) 130.23,14.2 129.56,13.53 PD819.2
  IN1 w0.084: v2(9.3,36.93) 8.83,36.93 8.26,36.35 8.26,32.16 8.77,31.64 8.77,22.47 8.6,22.3 8.6,21.12 8.93,20.79 8.93,8.72 10.21,7.44 10.21,5.48 11.5,4.19 11.5,4.1 12.6,3 41.85,3 43.36,4.5 45.83,4.5 48.01,6.68 48.01,10.03 48.21,10.24 48.21,11.61 50.22,13.61 50.22,15.1 52.57,17.46 54.11,17.46 55.6,18.95 56.65,18.95 57.07,18.52 70.51,18.52 72.27,16.76 77.44,16.76 78.54,15.65 81.15,15.65 82.19,16.69 84.79,16.69 85.95,15.53 86.67,15.53 87.15,15.04 95.06,15.04 96.7,16.69 117.6,16.69 118.42,15.87 120.16,15.87 121.86,14.17 133.57,14.17 134.42,15.02 136.47,15.02 v2(136.93,14.55)
  IN2 w0.122: v2(163.03,39.33) 171,47.3 171,54.08 170.44,54.64 170.44,57.56 169.34,58.66 169.34,61.84 168.79,62.38 168.79,65.52 169.59,66.31 169.59,67.32 168.42,68.49 168.42,73.09 168.1,73.41 168.1,75.12 168.14,75.16 168.14,77.23 167.88,77.49 167.88,79.23 168.45,79.8 169.17,79.8 170.39,81.03 170.39,82.65 169.46,83.58 169.46,85.02 170.54,86.1 170.54,87.96 171.48,88.9 171.48,90.11 166.61,94.99 153.45,94.99 v2(152.02,96.42) ; v2(13.5,37.17) 10.97,37.17 10.72,36.93 v2(9.3,36.93)
  BOTTOM w0.102: v2(136.93,14.55) 136.93,15.17 135.62,16.48 135.62,18.88 136.22,19.48 136.22,22.67 134.9,23.99 134.9,28.14 138.66,31.9 138.66,35.46 140.77,37.57 161.26,37.57 v2(163.03,39.33) ; JDOCK1.133 148.45,97.38 149.03,96.8 151.64,96.8 v2(152.02,96.42)
DOCK_SMB_CLK: length 231.5
  TOP w0.102: U38.B4 22.2,9.99 v2(22.2,10.65) ; v2(18.47,6.45) 18.47,6.22 18.92,5.77 18.92,5.17 v1(19.07,5.02) 19.55,4.55 19.55,4.34 R361.2
  IN1 w0.084: v2(18.47,6.45) 18.47,7.08 16.24,9.3 16.24,17.35 15.6,17.99 14.4,17.99 13.3,19.08 13.3,19.86 14,20.56 14,21.85 12.53,23.33 12.53,28.92 15.07,31.45 15.07,37.11 14.71,37.47 14.71,37.52 14.01,38.21 14.01,38.6 13.85,38.76 13.73,38.76 13.55,38.58 v2(13.55,38.59)
  IN4 w0.084: v2(146.96,99.16) 147.13,99.33 147.13,99.82 145.14,101.82 121.33,101.82 114.76,95.25 103.73,95.25 101.5,93.01 89.15,93.01 86.88,90.75 76.13,90.75 74.5,89.12 66.22,89.12 59.14,82.03 55.77,82.03 51.87,78.13 51.87,71.21 50.17,69.52 50.17,65.88 53.58,62.47 53.58,61.8 54.56,60.82 54.56,57.11 52.76,55.31 52.76,53.46 51.97,52.67 51.97,52.47 51.41,51.91 51.41,51.27 46.75,46.61 39.65,46.61 38.85,45.81 34.82,45.81 33.84,44.84 32.37,44.84 31.06,43.53 29.48,43.53 27.05,41.1 25.23,41.1 24.25,40.12 16.09,40.12 14.74,38.77 13.74,38.77 13.55,38.58 v2(13.55,38.59)
  BOTTOM w0.102: v2(18.47,6.45) 18.56,6.35 21.41,6.35 22.2,7.14 v2(22.2,10.65) ; JDOCK1.127 146.95,99.61 147.09,99.47 147.09,99.29 v2(146.96,99.16)
DOCK_SMB_DAT: length 225.2
  TOP w0.102: U38.A3 21.94,8.74 v2(21.21,8.01) 21.21,7.98 20.94,7.71 R359.2
  IN1 w0.084: v2(13.55,39.18) 13.55,39.16 13.74,38.97 13.94,38.97 14.22,38.68 14.22,38.3 14.92,37.6 14.92,37.56 15.28,37.2 15.28,31.36 12.74,28.83 12.74,23.41 14.22,21.94 14.22,20.48 13.51,19.77 13.51,19.17 14.48,18.2 15.69,18.2 16.5,17.39 16.5,9.35 18.76,7.09 20.28,7.09 v2(21.21,8.01)
  IN4 w0.084: v2(147.55,99.16) 147.35,99.36 147.35,99.91 145.22,102.03 121.24,102.03 114.67,95.46 103.65,95.46 101.41,93.23 89.06,93.23 86.79,90.96 76.05,90.96 74.41,89.33 66.13,89.33 59.05,82.25 55.69,82.25 51.66,78.21 51.66,71.3 49.96,69.6 49.96,65.79 53.37,62.38 53.37,61.71 54.35,60.73 54.35,57.2 52.55,55.39 52.55,53.55 51.76,52.76 51.76,52.56 51.2,52 51.2,51.35 46.66,46.82 39.56,46.82 38.77,46.02 34.73,46.02 33.75,45.05 32.28,45.05 30.98,43.74 29.39,43.74 26.96,41.31 25.15,41.31 24.17,40.33 16,40.33 14.65,38.98 13.74,38.98 13.55,39.16 v2(13.55,39.18)
  BOTTOM w0.102: JDOCK1.129 147.45,99.6 147.32,99.47 147.32,99.39 v2(147.55,99.16)
DOCK_USB3RN3: length 42.1
  TOP w0.102: v2(134.93,110.31) 135.13,110.51 135.13,110.92 135.39,111.19 139.64,111.19 140.01,110.82 140.01,109.98 141.17,108.81 141.17,107.97 141.81,107.34 147.28,107.34 147.31,107.37 148.04,107.37 148.07,107.34 149.38,107.34 151.56,105.16 151.56,104.01 151.08,103.53 151.08,102.69 154.15,99.62 163.73,99.62 164.13,100.02 164.13,101.4 163.94,101.58 U33.22
  BOTTOM w0.102: v2(134.93,110.31) 135.15,110.09 135.15,109.8 134.95,109.6 JDOCK1.84
DOCK_USB3RP3: length 41.9
  TOP w0.102: v2(135.52,110.31) 135.34,110.49 135.34,110.83 135.48,110.97 139.55,110.97 139.79,110.73 139.79,109.89 140.96,108.72 140.96,107.89 141.72,107.12 v3(147.64,107.12) 149.29,107.12 151.35,105.07 151.35,104.1 150.86,103.62 150.86,102.6 154.06,99.4 163.82,99.4 164.34,99.93 U33.23
  BOTTOM w0.102: JDOCK1.86 135.45,109.6 135.37,109.68 135.37,110.17 v2(135.52,110.31)
DOCK_USB3TN3: length 40.4
  TOP w0.102: U33.24 164.74,101.76 164.83,101.68 164.83,99.4 164.34,98.91 163.78,98.91 163.77,98.92 163.23,98.92 163.22,98.91 153.59,98.91 148.91,103.59 148.91,105.83 148.12,106.62 140.02,106.62 139.55,107.09 139.55,109.19 138.51,110.24 138.15,110.24 v2(137.87,110.51)
  BOTTOM w0.102: v2(137.87,110.51) 137.01,110.51 136.45,109.96 JDOCK1.90
DOCK_USB3TP3: length 40.5
  TOP w0.102: v2(137.87,109.93) 137.96,110.02 138.42,110.02 139.33,109.1 139.33,107 139.93,106.4 148.03,106.4 148.69,105.74 148.69,103.5 153.51,98.69 v3(163.5,98.69) 164.43,98.69 165.05,99.31 165.05,101.64 165.14,101.74 U33.25
  BOTTOM w0.102: JDOCK1.92 136.95,109.43 136.75,109.64 136.75,109.95 137.1,110.3 137.5,110.3 v2(137.87,109.93)
DOCK_USBP0+: length 57.2
  TOP w0.102: R269.1 124.5,95.7 L43.1 123.65,95.7 123.39,95.97 122.9,95.97 122.88,95.95 122.28,95.95 122.26,95.97 121.69,95.97 121.33,95.61 121.33,95.27 v2(121.7,94.91) ; v2(77.16,84.35) 77.04,84.24 77.04,84.02 77.27,83.79 U36.3
  IN2 w0.132: v2(77.16,84.35) 77.01,84.5 77.01,84.75 79.49,87.23 82.28,87.23 85.62,90.57 88.36,90.57 88.36,90.57 92.49,90.57 93.66,91.74 97.59,91.74 101.49,95.65 111.36,95.65 111.84,95.17 111.84,94.24 112.43,93.65 121.03,93.65 121.36,93.98 121.36,94.56 121.7,94.89 v2(121.7,94.91)
DOCK_USBP0-: length 57.3
  TOP w0.102: R270.1 124.5,96.55 L43.4 123.68,96.55 123.31,96.18 v3(122.56,96.18) 121.6,96.18 121.11,95.7 v2(121.11,94.91) ; U36.4 76.77,83.81 76.82,83.86 76.82,84.11 v2(76.57,84.35)
  IN2 w0.132: v2(76.57,84.35) 76.77,84.55 76.77,84.86 79.39,87.48 82.18,87.48 85.51,90.81 88.26,90.81 88.26,90.82 92.39,90.82 93.56,91.99 97.48,91.99 101.39,95.89 111.47,95.89 112.08,95.28 112.08,94.34 112.53,93.9 120.93,93.9 121.11,94.08 v2(121.11,94.91)
DOCK_USBP0_D+: length 23.8
  TOP w0.102: R269.2 125.58,95.7 L43.2 126.39,95.7 126.51,95.83 126.51,95.99 126.61,96.09 127.14,96.09 127.81,96.76 127.81,97.28 127.84,97.31 127.84,98.07 127.81,98.09 127.81,108.75 126.86,109.7 126.86,110.72 127.18,111.04 130.46,111.04 130.65,110.85 130.65,110.74 v2(130.41,110.51)
  BOTTOM w0.102: JDOCK1.66 130.45,109.6 130.65,109.8 130.65,110.27 v2(130.41,110.51)
DOCK_USBP0_D-: length 23.9
  TOP w0.102: v2(130.99,110.51) 130.86,110.64 130.86,110.94 130.55,111.25 127.09,111.25 126.64,110.81 126.64,109.61 127.6,108.66 v3(127.6,97.69) 127.6,96.85 127.05,96.3 126.67,96.3 126.42,96.55 L43.3 125.58,96.55 R270.2
  BOTTOM w0.102: v2(130.99,110.51) 130.86,110.37 130.86,109.69 130.95,109.6 JDOCK1.68
DOCK_USBP5+: length 43.1
  TOP w0.102: U33.15 160.33,103.33 160.23,103.43 159.63,103.43 158.81,104.24 158.81,109.28 158.68,109.41 154.64,109.41 154.48,109.58 152.2,109.58 150.64,108.01 146.29,108.01 145.63,108.67 145.63,110.1 145.24,110.49 145.24,111.43 144.97,111.7 136.6,111.7 136.58,111.67 135.84,111.67 135.81,111.7 133.85,111.7 133.66,111.51 133.66,109.78 133.12,109.24 132.51,109.24 131.91,109.85 v2(131.91,110.53)
  BOTTOM w0.102: JDOCK1.72 131.95,109.48 131.97,109.5 131.97,110.47 v2(131.91,110.53)
DOCK_USBP5-: length 43
  TOP w0.102: U33.14 160.33,103.73 160.24,103.64 159.72,103.64 159.03,104.33 159.03,109.37 158.77,109.63 154.73,109.63 154.57,109.79 152.11,109.79 150.55,108.23 146.38,108.23 145.85,108.76 145.85,110.18 145.45,110.58 145.45,111.52 145.06,111.91 v3(136.18,111.91) 133.76,111.91 133.44,111.6 133.44,109.87 133.03,109.46 132.6,109.46 132.12,109.94 132.12,110.16 v2(132.49,110.53)
  BOTTOM w0.102: v2(132.49,110.53) 132.18,110.22 132.18,109.87 132.45,109.6 JDOCK1.74
DOCKED: length 338.2
  TOP w0.102: U19.2 175.64,89.11 v2(175.46,89.29) ; U33.10 162.34,105.71 161.98,106.08 v2(161.98,106.21) ; v2(167.56,105.57) 167.56,104.69 167.41,104.53 U33.32 ; U19.5 174.14,89.13 v2(174.31,89.3) ; U37.A38 21.43,40.31 21.76,40.64 v2(21.76,41.27) ; v2(230.14,95.38) 229.6,94.84 v1(229.6,94.79) 229.6,91.63 228.05,90.08 v2(227.29,90.08)
  IN1 w0.084: v2(161.98,106.21) 161.98,106.02 162.42,105.57 v2(167.56,105.57)
  IN2 w0.122: v2(181.84,69.7) 181.84,71.05 180.99,71.9 180.99,77.01 179.28,78.72 176.91,78.72 175.99,79.63 175.99,80.59 176.58,81.18 176.58,82.22 177.47,83.11 177.47,83.5 176.75,84.23 176.75,88 v2(175.46,89.29) 175.46,89.64 174.96,90.14 174.96,91.8 169.3,97.46 169.3,100.6 168.2,101.7 168.2,102.78 167.56,103.42 v2(167.56,105.57) 165.46,107.68 162.74,107.68 162.67,107.61 160.5,107.61 158.33,109.78 154.91,109.78 154.48,110.21 151.94,110.21 150.44,108.71 142.52,108.71 141.16,107.35 131.4,107.35 130.95,106.91 119.47,106.91 117.9,105.33 117.9,104.4 115.35,101.85 114.42,101.85 112.38,99.82 112.38,99.19 111.45,98.26 107.32,98.26 104.33,101.25 99.47,101.25 96.16,97.95 96.16,96.95 94.64,95.42 83.9,95.42 83.08,94.61 81.28,92.81 78.77,90.3 77.13,90.3 75.14,88.31 70.32,88.31 66.05,84.04 58.32,84.04 55.26,80.99 55.26,74.57 54.5,73.8 54.5,68.3 53.35,67.15 53.35,61.5 54.38,60.48 54.38,55.87 54.03,55.52 54.03,54.43 50.18,50.58 46.82,50.58 46.34,51.06 43.78,51.06 40.13,47.41 37.11,47.41 35.81,46.12 31.8,46.12 27.51,41.83 25,41.83 24.56,42.27 22.75,42.27 v2(21.76,41.27)
  IN3 w0.122: v2(174.31,89.3) 175.45,89.3 v2(175.46,89.29) 175.47,89.29 177.46,87.3 181.19,87.3 183.2,89.31 188.3,89.31 190.64,91.66 192.12,91.66 192.38,91.91 207.51,91.91 209.48,89.95 210.67,89.95 210.96,89.66 226.22,89.66 226.47,89.91 227.12,89.91 v2(227.29,90.08)
  BOTTOM w0.102: U23.13 229.48,96.59 229.92,96.14 229.92,95.59 v2(230.14,95.38) ; U31.3 196.92,71 196.82,70.9 196.82,70.05 196.58,69.81 195.95,69.81 195.83,69.93 ; 195.83,69.93 195.83,69.93 195.83,70.73 196.12,71.02 U31.5 ; 195.83,69.93 190.65,69.93 190.17,70.41 183.68,70.41 182.69,69.42 182.12,69.42 v2(181.84,69.7)
DOCKED_LIO_EN: length 105.1
  TOP w0.102: U37.B52 15.23,38.52 14.9,38.84 14.9,39.33 14.64,39.59 v2(14.64,39.6) ; v2(58.02,81.4) v1(58.41,81.01) 58.62,80.8 61.72,80.8 62.91,79.6 64.57,79.6 65.75,78.42 69.22,78.42 69.69,78.89 74.83,78.89 76.52,80.58 78.14,80.58 78.27,80.71 U36.9
  IN2 w0.122: v2(58.02,81.4) 57.85,81.23 57.85,72.35 55.61,70.11 55.61,68.36 53.85,66.6 53.85,61.71 54.87,60.68 54.87,55.51 54.56,55.19 54.56,50.91 51.63,47.98 50.19,47.98 48.73,49.44 43.05,49.44 37.73,44.12 35.08,44.12 33.82,45.37 32.15,45.37 27.81,41.04 25.45,41.04 24.31,39.89 14.94,39.89 v2(14.64,39.6)
DP12412_AUX: length 31
  TOP w0.102: U19.20 167.06,86.46 166.93,86.59 166.29,86.59 v3(166,86.3) 164.82,85.12 164.67,85.12 v2(164.31,84.75) ; C19.1 186.9,79.5 185.53,79.5 185.31,79.29 185.15,79.29 184.94,79.07 184.86,78.98 184.86,78.88 v2(184.63,78.65)
  IN1 w0.091: v2(164.31,84.75) 164.38,84.83 164.57,84.83 164.72,84.68 164.86,84.68 164.96,84.58 164.96,84.44 165.28,84.11 165.28,83.38 165.68,82.99 168.71,82.99 170.87,80.83 176.7,80.83 177.12,80.41 183.36,80.41 184.71,79.05 184.71,78.73 v2(184.63,78.65)
DP12412_AUX#: length 31.1
  TOP w0.102: C20.1 186.75,79.29 185.62,79.29 185.4,79.07 185.24,79.07 185.1,78.92 185.07,78.89 185.07,78.79 v2(185.21,78.65) ; v2(164.31,85.33) 164.73,85.33 165.59,86.2 165.59,86.24 166.05,86.7 166.1,86.7 166.2,86.8 166.9,86.8 167.06,86.97 U19.19
  IN1 w0.091: v2(164.31,85.33) 164.79,84.85 164.94,84.85 165.13,84.65 165.13,84.51 165.46,84.18 165.46,83.45 165.75,83.16 168.78,83.16 170.94,81 176.77,81 177.19,80.58 183.43,80.58 184.88,79.13 184.88,78.98 v2(185.21,78.65)
DP12412_AUX#_C: length 4.6
  TOP w0.102: C20.2 188.42,79.22 v3(189.22,79.22) 190.04,79.22 190.71,79.89 191.51,79.89 191.87,80.25 U6.H2
DP12412_AUX_C: length 4.6
  TOP w0.102: C19.2 188.4,79.44 188.8,79.44 188.81,79.45 189.65,79.45 189.66,79.44 189.95,79.44 190.62,80.11 190.87,80.11 191.37,80.61 191.54,80.61 191.65,80.5 191.65,80.38 191.52,80.25 U6.H1
DP12412_HPD: length 34.9
  TOP w0.102: v2(168.96,89.57) 169.14,89.4 U19.15 ; v2(189.54,78.71) 190.3,78.71 191.18,79.6 U6.J1
  IN1 w0.084: v2(168.96,89.57) 168.96,89.83 169.6,90.46 173.72,90.46 175.3,88.89 177.22,88.89 177.84,89.51 182.94,89.51 v2(183.99,88.45)
  IN4 w0.084: v2(189.54,78.71) 190.14,79.32 190.14,85.65 187.83,87.96 184.49,87.96 v2(183.99,88.45)
DP12412_N0: length 17.4
  TOP w0.102: C156.1 187.17,81.24 187.07,81.14 186.59,81.14 v2(186.31,81.42) ; v2(173.78,82.79) 173.71,82.79 173.63,82.87 173.63,84.34 173.64,84.34 U19.33
  IN4 w0.091: v2(173.78,82.79) 173.58,82.59 173.58,82.49 173.73,82.35 176.55,82.35 177.64,81.25 186.14,81.25 v2(186.31,81.42)
DP12412_N0_C: length 4.5
  TOP w0.102: C156.2 188.28,81.38 188.55,81.38 188.85,81.08 188.92,81.08 188.93,81.09 189.65,81.09 189.66,81.08 190.77,81.08 190.94,81.25 191.75,81.25 U6.G2
DP12412_N1: length 17.5
  TOP w0.102: v2(172.68,83.82) 172.49,84.01 172.49,84.18 172.64,84.32 U19.31 ; C158.1 186.84,83.01 186.64,83.01 v2(186.48,83.17)
  IN4 w0.091: v2(186.48,83.17) 186.31,83 181.21,83 180.61,82.4 178.93,82.4 178.33,83 174.49,83 174.06,83.44 172.88,83.44 172.82,83.38 172.52,83.38 172.47,83.43 172.47,83.62 v2(172.68,83.82)
DP12412_N1_C: length 5.1
  TOP w0.102: C158.2 188.33,83.11 188.56,83.11 189.05,82.61 v3(189.05,82.36) 189.05,82.07 189.28,81.84 191.71,81.84 192,81.55 U6.F2
DP12412_N2: length 22
  TOP w0.102: C160.1 186.85,84.79 186.51,84.79 v2(186.32,84.98) ; v2(171.57,82.99) 171.5,83.06 171.5,83.48 171.56,83.54 171.56,84.25 171.64,84.32 U19.29
  IN4 w0.091: v2(171.57,82.99) 171.53,83.04 171.53,83.97 171.85,84.29 176.62,84.29 177.44,83.47 185.92,83.47 186.14,83.7 186.62,83.7 187.2,84.27 187.2,84.58 187.01,84.77 186.53,84.77 v2(186.32,84.98)
DP12412_N2_C: length 5.7
  TOP w0.102: U6.E2 192,82.2 191.65,82.56 190.14,82.56 189.09,83.6 v3(189.09,83.92) 189.09,84.43 188.63,84.89 188.34,84.89 C160.2
DP12412_N3: length 23
  TOP w0.102: v2(170.87,83.88) 170.64,84.12 U19.27 ; C162.1 186.84,86.58 186.41,86.58 v2(186.31,86.68)
  IN4 w0.091: v2(170.87,83.88) 170.66,84.09 170.66,84.48 171.12,84.94 174.98,84.94 175.26,85.21 180.62,85.21 181.72,84.12 185.57,84.12 185.84,84.39 185.84,85.2 186.03,85.4 186.84,85.4 187.22,85.78 187.22,86.26 186.97,86.51 186.48,86.51 v2(186.31,86.68)
DP12412_N3_C: length 7.1
  TOP w0.102: C162.2 188.33,86.66 v3(189.09,86.66) 189.46,86.66 189.93,86.19 189.93,85.68 189.95,85.67 189.95,84.82 189.93,84.81 189.93,83.89 190.67,83.16 191.69,83.16 192,82.85 U6.D2
DP12412_P0: length 17.3
  TOP w0.102: C155.1 186.93,80.92 186.4,80.92 v2(186.31,80.83) ; U19.32 173.14,84.31 173.31,84.14 173.31,82.91 v2(173.2,82.79)
  IN4 w0.091: v2(173.2,82.79) 173.41,82.58 173.41,82.42 173.65,82.17 176.47,82.17 177.57,81.08 186.07,81.08 v2(186.31,80.83)
DP12412_P0_C: length 4.3
  TOP w0.102: C155.2 187.88,80.89 187.88,81.05 187.95,81.11 188.51,81.11 188.76,80.86 v3(189.28,80.86) 190.86,80.86 191.03,81.04 191.32,81.04 U6.G1
DP12412_P1: length 17.8
  TOP w0.102: v2(172.09,83.82) 172.28,84.01 172.28,84.18 172.14,84.32 U19.30 ; v2(186.48,82.59) 186.69,82.8 186.84,82.8 C157.1
  IN4 w0.091: v2(172.09,83.82) 172.3,83.62 172.3,83.36 172.45,83.21 172.89,83.21 172.95,83.27 173.99,83.27 174.42,82.83 178.25,82.83 178.86,82.22 180.68,82.22 181.28,82.83 186.24,82.83 v2(186.48,82.59)
DP12412_P1_C: length 4.9
  TOP w0.102: C157.2 187.88,82.66 187.88,82.84 187.93,82.89 188.47,82.89 188.82,82.54 188.82,81.99 189.19,81.63 191.38,81.63 U6.F1
DP12412_P2: length 22
  TOP w0.102: v2(186.32,84.39) 186.51,84.58 186.85,84.58 C159.1 ; v2(170.99,82.99) 171.29,83.29 171.29,83.57 171.35,83.63 171.35,84.11 171.14,84.32 U19.28
  IN4 w0.091: v2(170.99,82.99) 171.35,83.36 171.35,84.04 171.78,84.47 176.7,84.47 177.52,83.65 185.84,83.65 186.07,83.87 186.55,83.87 187.03,84.35 187.03,84.51 186.94,84.6 186.53,84.6 v2(186.32,84.39)
DP12412_P2_C: length 5.6
  TOP w0.102: C159.2 187.85,84.49 187.85,84.58 187.93,84.67 188.54,84.67 188.87,84.34 188.87,84.21 188.86,84.2 188.86,83.64 188.87,83.63 188.87,83.51 190.05,82.34 191.31,82.34 U6.E1
DP12412_P3: length 22.8
  TOP w0.102: U19.26 170.14,84.52 170.42,84.24 170.42,84.02 v2(170.28,83.88) ; C161.1 186.88,86.31 186.53,86.31 v2(186.31,86.09)
  IN4 w0.091: v2(170.28,83.88) 170.49,84.09 170.49,84.55 171.05,85.11 174.91,85.11 175.18,85.39 180.69,85.39 181.79,84.29 185.5,84.29 185.67,84.46 185.67,85.28 185.96,85.57 186.77,85.57 187.05,85.85 187.05,86.19 186.95,86.28 186.5,86.28 v2(186.31,86.09)
DP12412_P3_C: length 7
  TOP w0.102: C161.2 187.83,86.27 187.83,86.37 187.91,86.45 188.53,86.45 188.54,86.44 189.36,86.44 189.37,86.45 189.72,86.1 v3(189.72,85.19) 189.72,83.8 190.58,82.94 191.03,82.94 191.21,82.76 191.37,82.76 U6.D1
DP_HDMI_HPD: length 6.2
  TOP w0.102: v2(17.86,30.64) 17.86,30.54 17.68,30.37 U37.B4 ; T115.1 14.47,27.87 v2(14.82,27.87)
  BOTTOM w0.102: v2(14.82,27.87) 15.18,28.23 16.22,28.23 17.86,29.86 v2(17.86,30.64)
DPB_CA_DET: length 139.3
  TOP w0.089: U6.M14 200.56,77.65 v4(200.58,77.67)
  TOP w0.102: v2(207.06,88.32) 206.87,88.12 206.87,87.71 206.15,86.98 204.71,86.98 204.52,86.79 203.61,86.79 v1(203.03,86.22) 202.04,85.23 v2(202.04,84.82) ; v2(114.29,109.91) 114.29,108.75 R120.2
  IN1 w0.084: v2(202.04,84.82) 202.04,82.71 v2(202.13,82.63)
  IN3 w0.122: v2(114.29,109.91) 114.29,109.84 114.74,109.39 125.11,109.39 125.48,109.75 126.87,109.75 127.76,108.86 137.06,108.86 137.69,109.5 138.74,109.5 139.62,108.61 145.85,108.61 148.6,105.86 148.6,104.23 154.04,98.79 161.01,98.79 161.98,97.82 167.1,97.82 169.79,95.14 179.86,95.14 180.34,95.62 181.68,95.62 185.27,99.21 195.23,99.21 195.87,99.85 199.88,99.85 202.06,97.67 204.41,97.67 205.17,96.9 205.96,96.9 v2(206.03,96.98)
  IN4 w0.084: v2(207.06,88.32) 207.06,88.85 206.43,89.49 206.43,96.58 206.03,96.98 v2(206.03,96.98)
  BOTTOM w0.089: v4(200.58,77.67) 200.84,77.67 201.09,77.42
  BOTTOM w0.102: v2(207.06,88.32) 207.06,88.68 207.97,89.59 209.7,89.59 210.09,89.98 Q10.2 ; U11.1 202.33,82.87 202.13,82.68 v2(202.13,82.63) 202.13,81.13 202.77,80.49 202.77,78.31 201.83,77.37 201.14,77.37 201.09,77.42 ; v2(114.29,109.91) 114.45,109.74 JDOCK1.6 ; U11.4 v2(202.04,84.82)
DPB_CA_DET#: length 7.5
  BOTTOM w0.102: 210.11,85.38 210.02,85.47 U11.10 ; 210.11,85.38 210.11,83.79 209.84,83.52 U11.13 ; 210.11,85.38 210.11,85.65 R60.2 210.36,86.54 210.36,87.03 v1(210.69,87.36) 210.74,87.41 Q10.1
DPB_DOCK_AUX: length 110.5
  IN1 w0.084: v2(205.38,84.96) 205.38,85.09 205.27,85.2 204.43,85.2 203,86.64 203,90.74 200.76,92.97 197.77,92.97 197.25,93.5 196.27,93.5 195.34,94.43 193.62,94.43 192.68,95.37 192.68,95.63 192.26,96.06 189.37,96.06 188.85,95.55 188.85,94.76 187.18,93.09 185.37,93.09 183.64,91.36 167.08,91.36 165.12,93.32 156.24,93.32 154.81,94.75 150.15,94.75 145.1,99.8 142.26,99.8 139.72,102.34 130.62,102.34 126.95,106 124.5,106 121.53,108.97 121.53,110.26 v2(121.41,110.37)
  BOTTOM w0.089: U11.3 204.05,84.17 204.84,84.96 v2(205.38,84.96) 205.4,84.96 205.53,85.09 206.75,85.09 206.91,84.94 208.03,84.94 208.14,84.82 U11.11 ; v2(121.41,110.37) 121.54,110.24 121.54,109.69 121.45,109.6 JDOCK1.34
DPB_DOCK_AUX#: length 111.3
  IN1 w0.084: v2(121.99,110.37) 121.91,110.29 121.91,109.13 124.65,106.38 127.11,106.38 130.78,102.72 139.88,102.72 142.42,100.18 145.26,100.18 150.31,95.13 154.97,95.13 156.39,93.7 165.27,93.7 167.24,91.74 183.48,91.74 185.21,93.47 187.02,93.47 188.47,94.92 188.47,95.7 189.21,96.44 192.41,96.44 193.07,95.79 193.07,95.53 193.78,94.81 195.49,94.81 196.43,93.88 197.41,93.88 197.93,93.35 200.92,93.35 203.38,90.9 203.38,86.8 204.59,85.58 v2(205.38,85.58)
  BOTTOM w0.089: v2(121.99,110.37) 121.86,110.24 121.86,109.69 121.95,109.6 JDOCK1.36 ; U11.6 204.14,86.12 204.27,86 204.27,85.22 204.39,85.09 204.52,85.09 204.72,85.29 205.09,85.29 v2(205.38,85.58) 205.56,85.41 206.63,85.41 206.97,85.75 206.97,86.45 207.3,86.77 U11.8
DPB_DOCK_HPD: length 129.3
  TOP w0.102: v4(200.84,78.66) 200.55,78.95 U6.K14 ; v2(122.76,110.31) 123.38,109.69 C311.1 R271.1 123.38,107.25 v1(123.7,106.93)
  IN3 w0.122: v2(122.76,110.31) 122.99,110.54 126.44,110.54 127.87,109.11 133.32,109.11 133.91,109.7 133.91,110.72 134.18,110.98 138.44,110.98 138.68,110.74 138.68,109.91 139.73,108.86 145.95,108.86 148.85,105.97 148.85,104.34 154.14,99.04 161.11,99.04 162.08,98.07 167.21,98.07 169.89,95.39 179.75,95.39 180.24,95.87 181.53,95.87 185.12,99.46 195.13,99.46 195.77,100.1 200.15,100.1 201.09,99.16 202.26,99.16 203.5,97.92 205.84,97.92 v2(206.08,97.68)
  IN4 w0.084: v2(206.08,97.68) 206.08,97.68 209.3,94.46 209.3,88.74 208.02,87.46 208.02,83.81 207.51,83.3 206.93,83.3 205.41,81.78 205.41,80.91 202.62,78.12 202.12,78.12 201.78,78.46 201.78,78.74 201.63,78.89 201.07,78.89 v4(200.84,78.66)
  BOTTOM w0.102: v2(122.76,110.31) 122.76,110.18 122.95,109.99 JDOCK1.40
DPB_DOCK_LANE_N0: length 17
  TOP w0.089: R261.1 114.81,96.32 114.81,96.7 115.79,97.68 115.79,101.51 116.45,102.17 116.45,106.78 115.79,107.44 115.79,109.97 v2(115.99,110.17)
  BOTTOM w0.089: JDOCK1.12 115.95,109.6 115.86,109.69 115.86,110.04 v2(115.99,110.17)
DPB_DOCK_LANE_N1: length 16.6
  TOP w0.089: R256.1 116.64,96.27 116.64,97.87 117.29,98.53 v3(117.29,105.07) 117.29,110.12 v2(117.49,110.33)
  BOTTOM w0.089: v2(117.49,110.33) 117.36,110.19 117.36,109.69 117.45,109.6 JDOCK1.18
DPB_DOCK_LANE_N2: length 16.9
  TOP w0.089: R264.1 118.37,96.32 118.37,98.13 118.73,98.5 118.73,100.75 118.35,101.13 118.35,106.34 118.86,106.84 v3(118.86,107.29) 118.86,110.21 v2(118.99,110.34)
  BOTTOM w0.089: JDOCK1.24 118.95,109.6 118.86,109.69 118.86,110.2 v2(118.99,110.34)
DPB_DOCK_LANE_N3: length 17.1
  TOP w0.089: v2(120.49,110.33) 120.38,110.22 v3(120.38,106.21) 120.38,105.89 119.43,104.94 119.43,101.96 120.26,101.13 120.26,98.91 120.13,98.78 120.13,96.34 R267.1
  BOTTOM w0.089: JDOCK1.30 120.45,109.6 120.36,109.69 120.36,110.19 v2(120.49,110.33)
DPB_DOCK_LANE_P0: length 17
  TOP w0.089: v2(115.41,110.17) 115.47,110.11 115.47,107.31 116.13,106.65 v3(116.13,106.4) 116.13,102.3 115.47,101.64 115.47,97.81 114.5,96.83 114.5,96.32 R260.1
  BOTTOM w0.089: v2(115.41,110.17) 115.54,110.04 115.54,109.69 115.45,109.6 JDOCK1.10
DPB_DOCK_LANE_P1: length 16.6
  TOP w0.089: v2(116.91,110.33) 116.97,110.26 v3(116.97,108.18) 116.97,98.66 116.32,98.01 116.32,96.36 R254.1
  BOTTOM w0.089: v2(116.91,110.33) 117.04,110.19 117.04,109.69 116.95,109.6 JDOCK1.16
DPB_DOCK_LANE_P2: length 16.9
  TOP w0.089: v2(118.41,110.34) 118.54,110.2 v3(118.54,109.7) 118.54,106.98 118.03,106.47 118.03,101 118.42,100.62 118.42,98.63 118.05,98.27 118.05,96.32 R262.1
  BOTTOM w0.089: JDOCK1.22 118.45,109.6 118.54,109.69 118.54,110.2 v2(118.41,110.34)
DPB_DOCK_LANE_P3: length 17.1
  TOP w0.089: R258.1 119.81,96.3 119.81,98.91 119.94,99.04 119.94,101 119.11,101.82 119.11,105.07 120.07,106.02 v3(120.07,108.56) 120.07,110.17 v2(119.91,110.33)
  BOTTOM w0.089: JDOCK1.28 119.95,109.6 120.04,109.69 120.04,110.19 v2(119.91,110.33)
DPB_HPD: length 71
  TOP w0.102: Q121.3 200.03,96.54 199.81,96.76 R475.1 199.14,96.52 198.32,95.71 v2(198.32,95.67)
  IN2 w0.089: v2(146.98,83.28) 146.98,84.17 146.55,84.61 146.55,85.57
  IN2 w0.122: 146.55,85.57 146.55,86.48 148.34,88.27 148.34,89.78 148.76,90.2 148.76,90.9 151.18,93.32 v2(151.18,96.39)
  IN3 w0.122: v2(151.18,96.39) 151.65,96.86 152.17,96.86 155.66,93.37 158.45,93.37 159.88,91.94 181.82,91.94 185.17,95.29 187.82,95.29 188.69,96.16 194.68,96.16 194.88,95.96 198.04,95.96 v2(198.32,95.67)
  BOTTOM w0.076: v2(146.98,83.28) 147.03,83.23 147.03,82.69 146.74,82.4 UC1.C8
DPB_LANE_N0: length 121.5
  TOP w0.089: C296.1 114.77,93.01 114.77,92.71 114.29,92.23 113.88,92.23 v2(113.78,92.13) ; U6.E14 200.14,82.2 200.74,82.8 200.74,83.07 201.69,84.02 203.07,84.02 205.24,86.19 206.24,86.19 v2(206.5,85.93)
  IN4 w0.084: v2(113.78,92.13) 113.93,92.28 114.3,92.28 114.67,92.65 114.67,93.83 118.14,97.3 133.54,97.3 134.49,98.26 138.82,98.26 139.45,98.88 139.45,99.59 139.83,99.97 144.91,99.97 147.09,97.79 148.34,97.79 148.74,98.2 152.45,98.2 153.31,97.33 156.94,97.33 158.14,96.14 166.18,96.14 166.95,95.37 179.92,95.37 180.58,96.02 181.49,96.02 183.76,98.29 185.99,98.29 186.23,98.05 201.29,98.05 201.78,97.56 203.61,97.56 205.54,95.63 205.54,88.78 205.6,88.72 205.6,86.51 205.98,86.13 206.3,86.13 v2(206.5,85.93)
DPB_LANE_N0_C: length 1.1
  TOP w0.089: R261.2 114.8,94.82 114.8,94.56 C296.2
DPB_LANE_N1: length 120.8
  TOP w0.089: v2(115.29,92.12) 115.55,92.39 116.28,92.39 116.59,92.7 116.59,93.05 C303.1 ; v2(206.77,83.74) 206.64,83.87 206.29,83.87 205.74,83.32 204.97,83.32 204.79,83.15 202.08,83.15 200.76,81.83 200.59,81.83 200.17,81.41 200.05,81.41 U6.F14
  IN4 w0.084: v2(206.77,83.74) 206.65,83.86 206.36,83.86 205.78,83.29 205.02,83.29 204.2,84.1 204.2,86.33 204.74,86.87 204.74,87.58 204.29,88.02 204.29,95.57 203.16,96.71 201.31,96.71 200.82,97.2 185.83,97.2 185.62,97.41 184.07,97.41 181.84,95.17 180.93,95.17 180.27,94.52 166.56,94.52 165.79,95.29 157.53,95.29 156.34,96.49 152.96,96.49 152.52,96.93 143.56,96.93 142.63,97.85 139.97,97.85 139.5,97.38 134.99,97.38 134.06,96.46 119.04,96.46 116.51,93.93 116.51,92.75 116,92.24 115.4,92.24 v2(115.29,92.12)
DPB_LANE_N1_C: length 1.1
  TOP w0.089: C303.2 116.57,94.56 116.57,94.82 R256.2
DPB_LANE_N2: length 110
  TOP w0.089: C307.1 118.37,93.06 118.37,92.73 118.48,92.62 118.76,92.62 v2(118.84,92.71) ; v2(203.64,80.12) 203.46,80.3 203.06,80.3 202.61,80.75 201.83,80.75 201.58,80.99 200.64,80.99 200.55,80.9 U6.G14
  IN4 w0.084: v2(203.64,80.12) 203.78,80.25 204.05,80.25 204.66,80.86 204.66,82.75 203.73,83.69 203.73,93.62 200.8,96.55 183.88,96.55 182.03,94.71 181.12,94.71 180.47,94.06 164.1,94.06 163.65,94.51 156.54,94.51 155.52,95.53 151.46,95.53 150.66,96.33 142.46,96.33 141.88,96.91 135.33,96.91 134.09,95.67 123.38,95.67 121.54,93.83 120.97,93.83 119.76,92.62 118.93,92.62 v2(118.84,92.71)
DPB_LANE_N2_C: length 1.1
  TOP w0.089: C307.2 118.35,94.56 118.35,94.82 R264.2
DPB_LANE_N3: length 106.4
  TOP w0.089: C309.1 120.15,93.06 120.15,92.68 120.43,92.4 120.74,92.4 v2(120.87,92.53) ; v2(202.01,79.63) 201.81,79.83 201.33,79.83 200.91,80.25 200.08,80.25 U6.H14
  IN4 w0.084: v2(120.87,92.53) 122.25,92.53 122.48,92.76 124.01,92.76 125.56,94.31 133.93,94.31 135.68,96.06 141.48,96.06 142.56,94.99 150.8,94.99 151.11,94.68 155.17,94.68 156.19,93.67 163.24,93.67 163.7,93.21 180.82,93.21 181.47,93.86 182.38,93.86 184.23,95.71 188.18,95.71 188.84,95.05 198.37,95.05 198.68,95.35 200.78,95.35 202.81,93.32 202.81,86.65 201.57,85.41 201.57,82.19 203.05,80.72 203.05,80.16 202.64,79.76 202.13,79.76 v2(202.01,79.63)
DPB_LANE_N3_C: length 1.1
  TOP w0.089: R267.2 120.13,94.82 120.13,94.56 C309.2
DPB_LANE_P0: length 121.5
  TOP w0.089: v2(206.5,86.51) 206.5,86.51 205.11,86.51 v3(203.75,85.15) 202.94,84.34 201.56,84.34 200.42,83.2 200.42,82.93 200.01,82.52 199.76,82.52 199.44,82.2 U6.E13 ; C294.1 114.45,93.1 114.45,92.84 114.16,92.54 113.95,92.54 v2(113.78,92.72)
  IN4 w0.084: v2(206.5,86.51) 206.14,86.51 205.98,86.67 205.98,88.87 205.92,88.94 205.92,95.79 203.77,97.94 201.94,97.94 201.45,98.43 186.39,98.43 186.15,98.67 183.6,98.67 181.33,96.4 180.42,96.4 179.76,95.75 167.1,95.75 166.33,96.52 158.29,96.52 157.1,97.71 153.47,97.71 152.6,98.58 148.58,98.58 148.18,98.17 147.25,98.17 145.07,100.35 139.67,100.35 139.07,99.75 139.07,99.04 138.67,98.64 134.34,98.64 133.38,97.68 117.99,97.68 114.29,93.99 114.29,92.8 114.14,92.66 113.84,92.66 v2(113.78,92.72)
DPB_LANE_P0_C: length 1.1
  TOP w0.089: C294.2 114.48,94.52 114.48,94.85 R260.2
DPB_LANE_P1: length 120.8
  TOP w0.089: v2(115.29,92.71) 116.15,92.71 116.27,92.83 116.27,93.06 C298.1 ; v2(206.77,84.32) 206.64,84.19 206.15,84.19 205.61,83.64 204.83,83.64 204.66,83.46 v3(203.8,83.46) 201.95,83.46 200.63,82.14 200.46,82.14 200.18,81.87 199.77,81.87 199.46,81.55 U6.F13
  IN4 w0.084: v2(115.29,92.71) 115.37,92.62 115.84,92.62 116.13,92.91 116.13,94.09 118.88,96.84 133.9,96.84 134.83,97.76 139.34,97.76 139.81,98.23 142.79,98.23 143.71,97.31 152.68,97.31 153.12,96.87 156.5,96.87 157.69,95.67 165.95,95.67 166.72,94.9 180.12,94.9 180.77,95.56 181.68,95.56 183.92,97.79 185.78,97.79 185.99,97.58 200.97,97.58 201.46,97.09 203.31,97.09 204.67,95.73 204.67,88.18 205.12,87.74 205.12,86.71 204.58,86.18 204.58,84.26 205.17,83.67 205.63,83.67 206.2,84.24 206.69,84.24 v2(206.77,84.32)
DPB_LANE_P1_C: length 1.1
  TOP w0.089: R254.2 116.26,94.85 116.26,94.52 C298.2
DPB_LANE_P2: length 110.1
  TOP w0.089: U6.G13 199.46,80.9 199.59,81.03 199.77,81.22 200.42,81.22 200.51,81.3 201.72,81.3 201.96,81.06 202.74,81.06 203.19,80.62 203.56,80.62 v2(203.64,80.7) ; v2(118.84,92.12) 118.66,92.3 118.35,92.3 118.05,92.6 118.05,93.06 C305.1
  IN4 w0.084: v2(203.64,80.7) 203.71,80.63 203.89,80.63 204.28,81.02 204.28,82.6 203.35,83.53 203.35,93.47 200.65,96.17 184.03,96.17 182.19,94.33 181.28,94.33 180.62,93.67 163.94,93.67 163.49,94.13 156.38,94.13 155.37,95.15 151.3,95.15 150.5,95.95 142.3,95.95 141.72,96.53 135.49,96.53 134.25,95.29 123.54,95.29 121.69,93.45 121.13,93.45 119.92,92.24 118.96,92.24 v2(118.84,92.12)
DPB_LANE_P2_C: length 1.1
  TOP w0.089: R262.2 118.03,94.85 118.03,94.52 C305.2
DPB_LANE_P3: length 106.5
  TOP w0.089: C308.1 119.83,93.06 119.83,92.55 120.3,92.09 120.73,92.09 v2(120.87,91.95) ; U6.H13 199.45,80.25 199.77,80.57 199.95,80.57 201.04,80.57 201.46,80.15 201.94,80.15 v2(202.01,80.22)
  IN4 w0.084: v2(202.01,80.22) 202.09,80.14 202.48,80.14 202.67,80.32 202.67,80.56 201.19,82.04 201.19,85.57 202.43,86.81 202.43,93.16 200.62,94.97 198.84,94.97 198.53,94.67 188.68,94.67 188.02,95.33 184.38,95.33 182.54,93.48 181.63,93.48 180.97,92.83 163.54,92.83 163.08,93.28 156.03,93.28 155.01,94.3 150.95,94.3 150.65,94.6 142.4,94.6 141.32,95.68 135.84,95.68 134.09,93.93 125.72,93.93 124.17,92.38 122.64,92.38 122.41,92.15 121.08,92.15 v2(120.87,91.95)
DPB_LANE_P3_C: length 1.1
  TOP w0.089: C308.2 119.81,94.52 119.81,94.85 R258.2
DPB_MB_P14: length 5.1
  TOP w0.102: v2(273.1,90.33) 272.89,90.55 272.31,90.55 v1(272.3,90.54) 271.62,89.85 R168.2
  BOTTOM w0.102: v2(273.1,90.33) 272.97,90.46 272.97,91.99 272.81,92.15 JMDP1.6
DPC_CA_DET: length 110.9
  TOP w0.102: U6.A14 200.21,84.8 200.8,85.39 v2(200.8,86)
  IN3 w0.122: v2(200.8,86) 200.51,85.71 194.3,85.71 193.41,86.6 190.13,86.6 189.56,87.17 186.14,87.17 184.43,85.46 v2(184.25,85.46) 183.83,85.46 183.57,85.19 v2(182.04,85.19) ; v2(180.25,90.26) 180.25,90.58 179.38,91.44 156.61,91.44 152.33,95.73 149.75,95.73 149.02,96.45 148.79,96.45 145.26,99.98 144.69,99.98 144.34,99.64 144.34,98.51 143.65,97.82 143.65,96.81 143.09,96.25 136.22,96.25 135.81,95.83 131.19,95.83 129.57,97.45 115,97.45 v2(114.63,97.83)
  BOTTOM w0.102: R121.2 113.27,96.47 v2(114.63,97.83) 114.63,99.44 114.45,99.62 JDOCK1.5 ; v2(182.04,85.19) 181.55,85.68 U13.1 181.55,87.66 182.42,88.53 182.42,88.87 182.61,89.06 v1(182.61,89.59) 182.61,89.84 182.36,90.1 Q6.2 181.36,89.8 180.47,89.8 180.25,90.02 v2(180.25,90.26) ; v2(184.25,85.46) 184.14,85.46 183.5,86.09 U13.4
DPC_CA_DET#: length 15.6
  BOTTOM w0.102: Q6.1 179.69,89.38 v1(179.69,87.05) 179.69,86.65 181.6,84.75 181.6,83.48 182.2,82.87 U13.13 182.2,80.14 ; U13.10 184.15,80.19 183.95,79.98 182.36,79.98 182.2,80.14 ; 182.2,80.14 182.05,79.98 181.15,79.98 180.34,80.8 R56.2
DPC_DOCK_AUX: length 82.1
  IN1 w0.084: v2(184.33,84.73) 184.33,84.59 183.45,83.71 177.93,83.71 176.97,84.67 169.97,84.67 168.99,85.65 165.84,85.65 165.24,86.25 162.59,86.25 160.28,88.55 155.98,88.55 155.41,87.99 153.75,87.99 151.29,90.44 147.71,90.44 143.93,94.22 126.76,94.22 126.54,94 125.06,94 124.93,94.13 123.93,94.13 123.58,93.79 123.58,93.49 v2(123.48,93.38)
  BOTTOM w0.089: U13.3 182.85,86.06 184.11,84.8 184.26,84.8 v2(184.33,84.73) 184.44,84.62 184.44,83.33 183.95,82.84 183.95,82.21 183.5,81.76 U13.11 ; JDOCK1.33 121.45,99.76 121.18,99.48 121.18,96.32 122.41,95.1 122.41,95.1 123.62,93.89 123.62,93.53 v2(123.48,93.38)
DPC_DOCK_AUX#: length 82
  IN1 w0.084: v2(185,84.76) 184.85,84.76 184.71,84.62 184.71,84.44 183.61,83.33 177.77,83.33 176.82,84.29 169.81,84.29 168.83,85.27 165.68,85.27 165.08,85.86 162.43,85.86 160.12,88.17 156.14,88.17 155.57,87.61 153.59,87.61 151.14,90.06 147.55,90.06 143.77,93.84 126.92,93.84 126.7,93.62 124.9,93.62 124.77,93.75 124.09,93.75 123.96,93.63 123.96,93.48 v2(124.06,93.38)
  BOTTOM w0.089: U13.6 184.8,86.12 184.57,85.89 184.57,85.75 184.66,85.66 184.66,85.1 v2(185,84.76) 184.9,84.76 184.76,84.62 184.76,83.04 185.45,82.35 U13.8 ; v2(124.06,93.38) 124.04,93.38 123.94,93.48 123.94,94.02 122.54,95.41 122.54,95.41 121.49,96.46 121.49,99.35 121.73,99.59 121.84,99.59 121.95,99.7 JDOCK1.35
