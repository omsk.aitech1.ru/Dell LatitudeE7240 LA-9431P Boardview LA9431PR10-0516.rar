# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D50: length 83.2
  IN4 w0.084: v2(77.74,27.53) 77.74,27.17 77.66,27.09 77.44,27.09 77.36,27 77.36,26.83 77.44,26.75 77.66,26.75 77.74,26.67 77.74,26.5 77.66,26.42 77.44,26.42 77.36,26.33 77.36,26.16 77.44,26.08 77.66,26.08 77.74,26 77.74,25.83 77.66,25.75 77.44,25.75 77.36,25.66 77.36,25.49 77.44,25.41 77.66,25.41 77.74,25.33 77.74,24.89 77.84,24.79 78.08,24.79 78.18,24.89 78.18,30.18 78.1,30.27 77.74,30.27 77.66,30.35 77.66,30.52 77.74,30.6 78.1,30.6 78.18,30.68 78.18,30.85 78.1,30.94 77.74,30.94 77.66,31.02 77.66,31.19 77.74,31.27 78.1,31.27 78.18,31.35 78.18,31.52 78.1,31.61 77.78,31.61 77.7,31.69 77.7,31.86 77.78,31.94 78.1,31.94 78.18,32.03 78.18,32.34 89.22,43.38 110.44,43.38 116.51,49.45 116.51,54.29 119.74,57.53 119.74,58.94 120.75,59.95 120.75,62.06 120.91,62.22 121.86,62.22 122.42,62.78 122.42,63.74 122.82,64.14 123.15,64.14 123.6,64.59 124.07,64.59 124.51,65.03 v2(124.83,65.03)
  BOTTOM w0.076: v2(124.83,65.03) 124.86,65.06 124.9,65.06 125.08,65.25 UC1.AM43
  BOTTOM w0.102: JDIMM1.59 76.9,27.06 77.37,27.53 v2(77.74,27.53)
DDR_A_D51: length 83.2
  IN4 w0.084: v2(77.74,29.05) 77.34,29.45 77.34,31.93 89.09,43.68 110.28,43.68 113.19,46.59 113.19,46.72 112.86,47.05 112.86,47.19 112.96,47.28 113.1,47.28 113.42,46.96 113.54,46.96 113.66,47.07 113.66,47.19 113.16,47.69 113.16,47.8 113.3,47.94 113.42,47.94 113.93,47.43 114.07,47.43 114.16,47.53 114.16,47.67 113.66,48.18 113.66,48.29 113.78,48.41 113.9,48.41 114.4,47.91 114.54,47.91 114.64,48 114.64,48.14 114.13,48.65 114.13,48.77 114.25,48.89 114.37,48.89 114.88,48.38 115.02,48.38 115.11,48.48 115.11,48.62 114.61,49.12 114.61,49.24 114.73,49.36 114.85,49.36 115.35,48.85 115.49,48.85 115.59,48.95 115.59,49.09 115.08,49.6 115.08,49.72 115.2,49.84 115.32,49.84 115.83,49.33 115.96,49.33 116.06,49.43 116.06,49.57 115.56,50.07 115.56,50.19 115.68,50.31 115.79,50.31 115.97,50.13 116.11,50.13 116.21,50.23 116.21,50.37 116.03,50.55 116.03,50.67 116.21,50.84 116.21,53.3 116.19,53.32 116.19,54.31 119.54,57.66 119.54,59.02 120.55,60.03 120.55,62.2 120.96,62.61 121.49,62.61 121.53,62.64 121.53,63.79 121.74,64.01 122.4,64.01 122.74,64.34 123.03,64.34 123.67,64.98 v2(123.93,64.98)
  BOTTOM w0.076: UC1.AM45 124.2,65.25 v2(123.93,64.98)
  BOTTOM w0.102: JDIMM1.57 76.3,27.61 v2(77.74,29.05)
DDR_A_D52: length 83.1
  IN4 w0.084: v2(123.95,66.28) 123.67,66.56 122.82,66.56 122.59,66.33 122.59,64.94 121.87,64.21 121.09,64.21 120.53,63.65 120.53,62.83 120.29,62.59 120.29,60.06 119.34,59.11 119.34,57.74 115.99,54.39 115.99,53.58 115.91,53.5 115.91,50.97 112.51,47.57 112.51,46.48 110.01,43.98 88.97,43.98 77.03,32.04 77.03,21.27 v2(77.42,20.87)
  BOTTOM w0.076: v2(123.95,66.28) 124.21,66.55 UC1.AK45
  BOTTOM w0.102: v2(77.42,20.87) 76,19.45 JDIMM1.56
DDR_A_D53: length 85.1
  IN4 w0.084: v2(77.42,19.35) 76.68,20.09 76.68,32.11 88.85,44.28 108.79,44.28 115.61,51.09 115.61,53.67 115.78,53.84 115.78,54.48 119.13,57.83 119.13,59.58 119.6,60.05 119.6,63.65 120.51,64.56 120.51,66.23 121.63,67.35 123.74,67.35 v2(124.83,66.27)
  BOTTOM w0.076: UC1.AK43 125.11,66.55 v2(124.83,66.27)
  BOTTOM w0.102: v2(77.42,19.35) 77.11,19.35 76.6,18.84 JDIMM1.58
DDR_A_D54: length 85.1
  IN4 w0.084: v2(80.2,19.35) 80.9,20.05 80.9,22.92 80.98,23 81.14,23 81.24,23.1 81.24,23.24 81.14,23.34 80.98,23.34 80.9,23.42 80.9,23.59 80.98,23.67 81.32,23.67 81.41,23.76 81.41,23.92 81.32,24.01 80.98,24.01 80.9,24.09 80.9,24.26 80.98,24.34 81.32,24.34 81.41,24.43 81.41,24.59 81.32,24.68 80.98,24.68 79.84,25.82 79.84,31.74 89.88,41.78 111.1,41.78 118.1,48.78 118.1,53.7 120.73,56.33 123.05,56.33 123.4,56.67 123.4,61.22 123.78,61.6 123.78,62.1 124.25,62.57 126.17,62.57 126.38,62.78 126.38,64.53 v2(126.75,64.9)
  BOTTOM w0.076: UC1.AM40 127.1,65.25 v2(126.75,64.9)
  BOTTOM w0.102: JDIMM1.68 79.6,18.75 v2(80.2,19.35)
DDR_A_D55: length 85
  IN4 w0.084: v2(125.84,65.01) 125.84,64.8 125.73,64.7 125.73,64.7 125.51,64.48 125.51,64.48 125.47,64.43 125.47,64.11 125.37,64.01 124.74,64.01 124.51,63.78 124.51,62.82 124.43,62.74 124.15,62.74 123.5,62.08 123.5,61.88 123.12,61.5 122.81,61.5 122.55,61.24 122.55,58.49 121.07,57.01 120.98,57.01 120,56.03 119.51,56.03 117.8,54.32 117.8,48.91 110.98,42.08 89.76,42.08 79.5,31.83 79.5,25.29 79.58,25.21 80.03,25.21 80.13,25.11 80.13,24.97 80.03,24.87 79.6,24.87 79.5,24.77 79.5,24.6 79.6,24.5 80.5,24.5 80.6,24.4 80.6,24.22 80.51,24.13 79.6,24.13 79.51,24.05 79.51,23.88 79.6,23.8 80.51,23.8 80.6,23.71 80.6,21.27 v2(80.2,20.87)
  BOTTOM w0.076: UC1.AM42 126.07,65.25 v2(125.84,65.01)
  BOTTOM w0.102: JDIMM1.70 80.2,18.74 80.63,19.17 80.63,20.44 v2(80.2,20.87)
DDR_A_D56: length 60.8
  IN1 w0.084: v2(122.98,65.52) 122.58,65.12 122.58,64.69 121.88,64 121.84,64 121.48,63.64 121.48,62.95 121.23,62.7 120.95,62.7 120.26,62.01 120.26,59.12 120.58,58.8 120.58,58.45 120.12,57.99 120.12,57.19 116.87,53.95 116.87,42.16 121.61,37.42 121.61,25.47 121.48,25.34 119.6,25.34 119.49,25.23 119.49,25 119.58,24.91 120.34,24.91 120.43,24.81 120.43,24.68 120.34,24.58 119.58,24.58 119.49,24.49 119.49,24.23 119.58,24.15 120.33,24.15 120.41,24.06 120.41,23.9 120.33,23.81 119.58,23.81 119.49,23.73 119.49,23.56 119.58,23.48 120.33,23.48 120.41,23.39 120.41,23.22 120.33,23.14 119.58,23.14 119.15,22.71 119.15,21.06 v2(119.55,20.66)
  BOTTOM w0.076: v2(122.98,65.52) 123.25,65.25 UC1.AM46
  BOTTOM w0.102: JDIMM1.192 119.2,18.88 119.12,18.96 119.12,20.23 v2(119.55,20.66)
DDR_A_D57: length 60.1
  IN1 w0.084: v2(122.98,66.17) 123.35,65.8 123.35,64.72 122.4,63.76 122.4,62.81 122.11,62.52 121.02,62.52 120.44,61.94 120.44,59.19 120.75,58.88 120.75,58.33 120.33,57.91 120.33,57.16 117.17,54 117.17,42.28 121.91,37.54 121.91,23.93 121.83,23.85 120.89,23.85 120.8,23.77 120.8,23.6 120.89,23.51 121.83,23.51 121.91,23.43 121.91,23.26 121.83,23.18 120.89,23.18 120.8,23.1 120.8,22.93 120.89,22.84 121.51,22.84 121.64,22.72 121.64,21.97 121.51,21.84 120.22,21.84 120.09,21.72 120.09,19.68 v2(119.55,19.13)
  BOTTOM w0.076: UC1.AK46 123.36,66.55 v2(122.98,66.17)
  BOTTOM w0.102: v2(119.55,19.13) 119.8,18.88 JDIMM1.194
DDR_A_D58: length 57.9
  IN1 w0.084: v2(121.08,64.95) 120.71,64.95 120.3,64.54 119.93,64.54 119.11,63.71 119.11,62.96 118.31,62.16 118.31,58.41 113.78,53.88 113.78,53.52 114.93,52.37 114.93,40.9 117.64,38.18 117.64,35.96 117.72,35.88 118.72,35.88 118.82,35.78 118.82,35.64 118.72,35.54 117.72,35.54 117.64,35.46 117.64,35.29 117.72,35.21 119.04,35.21 119.12,35.12 119.12,34.96 119.04,34.87 117.72,34.87 117.64,34.79 117.64,34.62 117.72,34.54 119.04,34.54 119.12,34.45 119.12,34.29 119.04,34.2 117.72,34.2 117.64,34.12 117.64,33.95 117.72,33.87 119.04,33.87 119.12,33.78 119.12,33.62 119.04,33.53 117.72,33.53 117.64,33.45 117.64,33.28 117.72,33.2 119.04,33.2 119.12,33.11 119.12,31.04 118.17,30.09 118.17,27.98 v2(117.72,27.53)
  BOTTOM w0.076: v2(121.08,64.95) 121.37,65.25 UC1.AM49
  BOTTOM w0.102: v2(117.72,27.53) 117.07,27.53 116.5,26.96 116.5,26.03 JDIMM1.183
DDR_A_D59: length 57.7
  IN1 w0.084: v2(116.58,19.13) 115.89,19.83 115.89,24.47 116.72,25.31 116.72,37.83 114.03,40.52 114.03,52.23 113.23,53.04 113.23,54.3 116.89,57.97 116.89,66.37 117.45,66.93 120.39,66.93 v2(121.08,66.25)
  BOTTOM w0.076: v2(121.08,66.25) 121.37,66.55 UC1.AK49
  BOTTOM w0.102: JDIMM1.182 116.2,18.75 v2(116.58,19.13)
DDR_A_D60: length 60.1
  IN1 w0.084: v2(119.64,29.05) 120.02,29.05 120.12,29.16 120.12,30.16 120.2,30.24 120.74,30.24 120.84,30.34 120.84,30.57 120.74,30.68 120.52,30.68 120.43,30.76 120.43,30.93 120.52,31.01 120.93,31.01 121.01,31.09 121.01,31.26 120.93,31.35 120.52,31.35 120.43,31.43 120.43,31.6 120.52,31.68 120.93,31.68 121.01,31.76 121.01,31.93 120.93,32.02 120.52,32.02 120.43,32.1 120.43,32.27 120.52,32.35 120.93,32.35 121.01,32.44 121.01,32.6 120.93,32.69 120.52,32.69 120.43,32.77 120.43,32.94 120.52,33.02 120.93,33.02 121.01,33.11 121.01,33.27 120.93,33.36 120.52,33.36 120.43,33.44 120.43,33.61 120.52,33.69 120.93,33.69 121.01,33.78 121.01,33.94 120.93,34.03 120.52,34.03 120.43,34.11 120.43,34.28 120.52,34.36 120.93,34.36 121.01,34.45 121.01,34.61 120.93,34.7 120.52,34.7 120.43,34.78 120.43,34.95 120.52,35.03 120.93,35.03 121.01,35.12 121.01,35.29 120.93,35.37 120.52,35.37 120.43,35.45 120.43,35.62 120.52,35.7 120.93,35.7 121.01,35.79 121.01,35.96 120.93,36.04 120.52,36.04 120.43,36.12 120.43,36.29 120.52,36.38 120.93,36.38 121.01,36.46 121.01,36.63 120.93,36.71 120.52,36.71 120.43,36.79 120.43,36.96 120.52,37.05 120.61,37.05 120.69,37.13 120.69,37.49 120.16,38.02 120.04,38.02 119.43,37.41 119.29,37.41 119.19,37.5 119.19,37.64 119.8,38.26 119.8,38.38 119.56,38.62 119.44,38.62 119.31,38.49 119.17,38.49 119.07,38.58 119.07,38.72 119.2,38.86 119.2,38.98 119.09,39.1 118.97,39.1 118.83,38.96 118.69,38.96 118.6,39.06 118.6,39.2 118.73,39.33 118.73,39.45 118.61,39.57 118.49,39.57 118.36,39.44 118.22,39.44 118.12,39.54 118.12,39.68 118.26,39.81 118.26,39.93 118.14,40.05 118.02,40.05 117.89,39.91 117.75,39.91 117.65,40.01 117.65,40.15 117.78,40.28 117.78,40.4 117.66,40.52 117.54,40.52 117.41,40.39 117.27,40.39 117.17,40.49 117.17,40.62 117.31,40.76 117.31,40.88 117.19,40.99 117.07,40.99 116.94,40.86 116.8,40.86 116.7,40.96 116.7,41.1 116.83,41.23 116.83,41.35 116.71,41.47 116.59,41.47 116.46,41.34 116.32,41.34 116.22,41.43 116.22,41.57 116.36,41.71 116.36,41.82 116.27,41.91 116.27,53.84 119.63,57.19 119.63,61.91 120.5,62.79 120.5,63.84 120.85,64.18 121.47,64.18 122.03,64.74 v2(122.03,64.92)
  BOTTOM w0.076: v2(122.03,64.92) 122.35,65.25 UC1.AM48
  BOTTOM w0.102: v2(119.64,29.05) 118.9,28.32 JDIMM1.191
DDR_A_D61: length 58.8
  IN1 w0.084: v2(119.64,27.53) 119.63,27.53 119.63,25.91 119.74,25.81 121.21,25.81 121.31,25.91 121.31,26.1 121.23,26.19 120.65,26.19 120.56,26.27 120.56,26.44 120.65,26.52 121.23,26.52 121.31,26.61 121.31,26.77 121.23,26.86 120.65,26.86 120.56,26.94 120.56,27.11 120.65,27.19 121.23,27.19 121.31,27.28 121.31,27.44 121.23,27.53 120.65,27.53 120.56,27.61 120.56,27.78 120.65,27.86 121.23,27.86 121.31,27.95 121.31,28.12 121.23,28.2 120.56,28.2 120.46,28.3 120.46,28.44 120.56,28.53 121.23,28.53 121.31,28.62 121.31,28.79 121.23,28.87 120.65,28.87 120.56,28.95 120.56,29.12 120.65,29.2 121.23,29.2 121.31,29.29 121.31,29.46 121.23,29.54 120.65,29.54 120.56,29.62 120.56,29.79 120.65,29.88 121.23,29.88 121.31,29.96 121.31,37.3 116.57,42.04 116.57,53.89 119.82,57.14 119.82,61.86 120.68,62.72 120.68,63.77 120.92,64.01 121.6,64.01 121.77,64.17 121.81,64.17 122.4,64.77 122.4,65.85 v2(122.03,66.22)
  BOTTOM w0.076: v2(122.03,66.22) 122.35,66.55 UC1.AK48
  BOTTOM w0.102: JDIMM1.193 119.5,27.39 v2(119.64,27.53)
DDR_A_D62: length 57.1
  IN1 w0.084: v2(120.12,64.92) 119.86,64.92 119.74,65.04 119.74,65.82 119.61,65.95 119.02,65.95 118.8,65.73 118.8,62.91 118.13,62.24 118.13,58.67 113.6,54.14 113.6,53.36 114.63,52.34 114.63,40.77 117.32,38.07 117.32,32.9 117.41,32.82 118.72,32.82 118.82,32.72 118.82,32.58 118.72,32.48 117.41,32.48 117.32,32.4 117.32,32.23 117.41,32.15 118.72,32.15 118.82,32.05 118.82,31.91 118.72,31.81 117.41,31.81 117.32,31.73 117.32,31.56 117.41,31.48 118.72,31.48 118.82,31.38 118.82,31.24 118.72,31.14 117.41,31.14 117.32,31.06 117.32,30.89 117.41,30.81 118.13,30.81 118.23,30.71 118.23,30.57 118.13,30.47 117.41,30.47 117.32,30.39 117.32,29.45 v2(117.72,29.05)
  BOTTOM w0.076: v2(120.12,64.92) 120.45,65.25 UC1.AM51
  BOTTOM w0.102: JDIMM1.181 115.9,27.23 v2(117.72,29.05)
DDR_A_D63: length 56.1
  IN1 w0.084: v2(116.58,20.66) 116.19,21.06 116.19,24.28 117.02,25.11 117.02,37.95 114.33,40.65 114.33,52.26 113.4,53.19 113.4,54.22 117.39,58.21 117.39,61.87 117.85,62.33 117.85,66.38 118.23,66.76 119.59,66.76 v2(120.12,66.22)
  BOTTOM w0.076: UC1.AK51 120.21,66.22 v2(120.12,66.22)
  BOTTOM w0.102: JDIMM1.180 115.6,19.67 v2(116.58,20.66)
DDR_A_DQS0: length 62.9
  IN1 w0.114: v2(102.58,28.67) 102.77,28.87 102.98,28.87 103.28,29.16 103.28,30.5 102.48,31.3 102.48,47.52 102.6,47.64 102.82,47.64 103.09,47.91 103.09,48.51 102.82,48.78 102.6,48.78 102.48,48.9 102.48,49.27 102.59,49.38 102.78,49.38 103.09,49.68 103.09,50.27 102.8,50.55 102.6,50.55 102.48,50.66 102.48,51.01 102.6,51.12 102.8,51.12 103.09,51.4 103.09,51.98 102.8,52.27 102.6,52.27 102.48,52.38 102.48,52.72 102.6,52.84 102.8,52.84 103.09,53.12 103.09,53.7 102.8,53.98 102.6,53.98 102.48,54.1 102.48,54.71 102.59,54.81 102.82,54.81 103.1,55.09 103.1,55.68 102.82,55.96 100.88,55.96 100.77,56.07 100.77,56.42 100.88,56.53 102.82,56.53 103.1,56.81 103.1,57.39 102.82,57.68 101.02,57.68 100.9,57.8 100.9,58.12 101.02,58.25 104.2,58.25 106.22,60.27 106.22,60.85 106.48,61.1 106.48,61.91 107.81,63.25 v2(107.81,64.05)
  BOTTOM w0.076: UC1.AJ62 113.8,66.86 113.87,66.93 113.87,67.02 113.79,67.1 113.69,67.15 113.56,67.15 113.4,67.08 113.19,67.08 113.14,67.1 113.06,67.14 113.04,67.15 112.91,67.15 112.85,67.13 112.74,67.08 112.19,67.08 112.07,66.96 110.78,66.96 110.45,66.62 110.45,66.59 110.43,66.58
  BOTTOM w0.114: v2(107.81,64.05) 107.66,64.05 107.54,64.17 107.54,64.46 109.13,66.05 109.91,66.05 110.43,66.58 ; JDIMM1.137 102.7,26.91 102.46,27.15 102.46,27.41 102.11,27.77 102.11,28.9 102.25,29.04 102.45,29.04 102.58,28.92 v2(102.58,28.67)
DDR_A_DQS1: length 84.6
  IN4 w0.114: v2(110.8,63.54) 110.9,63.44 110.9,62.72 109.06,60.89 109.06,60.77 104.65,56.35 101.16,56.35 98.75,53.94 82.73,53.94 61.55,32.75 61.55,21.28 62.23,20.6 62.71,20.6 v2(62.82,20.49)
  BOTTOM w0.076: v2(110.8,63.54) 110.8,63.79 110.67,63.92 110.67,64.32 111.16,64.81 112.44,64.81 112.44,64.81 112.71,64.81 112.87,64.89 113.07,64.89 113.23,64.81 113.65,64.81 113.81,64.65 114.05,64.65 UC1.AN61
  BOTTOM w0.114: JDIMM1.12 62.8,19.14 62.01,19.93 62.01,20.5 62.18,20.68 62.64,20.68 v2(62.82,20.49)
DDR_A_DQS2: length 54.6
  IN1 w0.084: v2(115.42,64.27) 115.25,64.44 115.04,64.44 114.15,63.55 114.15,62.19 113.46,61.5 112.02,60.06 112.02,60.06 112.02,60.04 112.01,60.04
  IN1 w0.114: v2(107.69,20.28) 107.93,20.52 108.12,20.52 108.46,20.85 108.46,21.62 108.8,21.96 108.8,22.62 108.52,22.9 107.66,22.9 107.56,23.01 107.56,23.37 107.66,23.48 108.52,23.48 108.8,23.76 108.8,24.73 108.43,25.1 108.43,36.14 107.83,36.74 107.83,55.86 112.01,60.04
  BOTTOM w0.076: UC1.AN58 115.74,64.6 v2(115.42,64.27)
  BOTTOM w0.114: v2(107.69,20.28) 107.47,20.5 107.32,20.5 107.28,20.45 107.28,19.31 107.8,18.79 JDIMM1.154
DDR_A_DQS3: length 80.7
  IN4 w0.084: 114.54,60.23 114.56,60.23 114.58,60.25 115.74,60.25 117.89,62.4 117.89,64.9 117.95,64.96 118.24,64.96 v2(118.27,64.92)
  IN4 w0.114: v2(67.75,28.67) 67.93,28.85 68.24,28.85 68.52,29.14 68.52,29.9 68.91,30.29 68.91,31.07 68.63,31.34 68.16,31.34 68.03,31.47 68.03,32.01 68.16,32.14 69.2,32.14 69.62,32.55 69.62,33.15 69.04,33.73 69.04,33.91 69.26,34.13 69.44,34.13 69.84,33.73 70.26,33.73 70.65,34.12 70.65,34.54 70.25,34.94 70.25,35.12 70.47,35.35 70.65,35.35 71.06,34.94 71.46,34.94 71.97,35.44 71.97,35.92 71.65,36.23 71.65,36.47 85.14,49.96 100.39,49.96 101.15,50.71 102.99,50.71 103.24,50.97 103.24,51.49 103.37,51.62 103.69,51.62 103.81,51.49 103.81,50.95 104.05,50.71 105.22,50.71 110.8,56.29 110.8,56.83 114.2,60.23 114.54,60.23
  BOTTOM w0.076: v2(118.27,64.92) 118.04,64.92 UC1.AN55
  BOTTOM w0.114: JDIMM1.29 67.9,26.82 67.66,27.06 67.66,27.38 67.22,27.82 67.22,28.79 67.38,28.95 67.47,28.95 v2(67.75,28.67)
DDR_A_DQS4: length 49.2
  IN1 w0.084: 111.24,51.41 111.24,51.42 111.25,51.43 111.25,54.75 111.62,55.12 111.62,56.01 111.9,56.29 112.79,56.29 113.02,56.52 113.02,56.68 112.38,57.31 v2(112.28,57.31)
  IN1 w0.114: v2(113.15,29.44) 113.39,29.2 113.5,29.2 113.62,29.31 113.62,30.63 113.5,30.74 113.38,30.74 113.11,31.01 113.11,31.62 113.38,31.89 114.06,31.89 114.19,32.02 114.19,32.33 114.06,32.46 113.38,32.46 113.11,32.73 113.11,33.34 113.38,33.61 114.09,33.61 114.19,33.71 114.19,34.08 114.09,34.18 113.4,34.18 113.12,34.46 113.12,35.04 113.4,35.32 114.09,35.32 114.19,35.43 114.19,35.79 114.09,35.9 113.38,35.9 113.11,36.17 113.11,36.77 113.38,37.04 113.5,37.04 113.62,37.16 113.62,37.7 111.24,40.09 111.24,51.41
  BOTTOM w0.076: UC1.AW57 116.51,61.34 116.44,61.41 116.35,61.41 116.27,61.33 116.22,61.23 116.22,61.1 116.29,60.94 116.29,60.73 116.27,60.68 116.23,60.6 116.22,60.58 116.22,60.45 116.25,60.39 116.29,60.29 116.29,60 116.05,59.75 116.05,59.23 114.91,58.09 114.09,58.09 113.21,57.21 112.82,57.21 112.68,57.36 112.32,57.36 v2(112.28,57.31)
  BOTTOM w0.114: v2(113.15,29.44) 113.41,29.17 113.62,29.17 113.94,28.86 113.94,27.75 113.41,27.23 112.82,27.23 112.73,27.14 112.73,26.98 112.9,26.81 JDIMM1.171
DDR_A_DQS5: length 76
  IN4 w0.084: 112.62,51.41 112.62,52.26 112.82,52.46 112.82,53.73 116.83,57.73 117.25,57.73 117.62,57.36 v2(117.83,57.36)
  IN4 w0.114: v2(73.89,28.67) 73.66,28.9 73.39,28.9 73.15,29.15 73.15,30.91 73.45,31.21 73.81,31.21 74.12,31.53 74.12,32.79 81.52,40.19 81.52,40.35 81.17,40.7 81.17,41.11 81.56,41.51 81.98,41.51 82.33,41.16 82.49,41.16 82.93,41.59 82.93,41.75 82.61,42.07 82.61,42.49 83,42.88 83.42,42.88 83.74,42.56 83.9,42.56 84.14,42.8 84.14,42.97 83.76,43.35 83.76,43.77 84.15,44.16 84.57,44.16 84.95,43.78 85.11,43.78 85.36,44.02 85.36,44.18 84.97,44.56 84.97,44.98 85.37,45.37 85.78,45.37 86.17,44.99 86.33,44.99 86.57,45.23 86.57,45.39 86.21,45.75 86.21,46.17 86.61,46.56 87.02,46.56 87.38,46.2 87.54,46.2 87.9,46.56 102.11,46.56 102.86,47.31 108.6,47.31 112.62,51.34 112.62,51.41
  BOTTOM w0.076: UC1.AW53 118.72,60.94 118.72,60.73 118.7,60.68 118.66,60.6 118.65,60.58 118.65,60.45 118.68,60.39 118.72,60.29 118.72,59.97 118.47,59.72 118.47,59.59 118.32,59.45 118.32,58.63 117.96,58.26 117.96,58.13 117.53,57.7 117.53,57.41 117.61,57.33 117.8,57.33 v2(117.83,57.36)
  BOTTOM w0.114: JDIMM1.47 73.3,27.12 73.1,27.32 73.1,28.72 73.31,28.93 73.63,28.93 v2(73.89,28.67)
DDR_A_DQS6: length 84.4
  IN4 w0.084: v2(125.84,65.62) 125.46,65.25 125.46,64.76 125.09,64.39 124.96,64.39 124.95,64.4 124.48,64.4 124.25,64.16 123.85,64.16 123.59,63.9 123.59,62.82 123.16,62.39 122.64,62.39 122.31,62.06 122.31,59.31 120.55,57.55 120.55,57.31 117.28,54.04 117.28,51.43 117.3,51.42 117.3,51.41
  IN4 w0.114: 117.3,51.41 117.3,49.12 110.77,42.59 89.55,42.59 79,32.03 79,24.11 78.7,23.82 78.36,23.82 78.26,23.72 78.26,23.07 78.36,22.97 79.33,22.97 79.67,22.63 79.67,21.01 79.35,20.7 79.14,20.7 v2(78.93,20.49)
  BOTTOM w0.076: v2(125.84,65.62) 126.11,65.9 UC1.AL42
  BOTTOM w0.114: v2(78.93,20.49) 78.64,20.78 78.44,20.78 78.2,20.54 78.2,18.94 78.4,18.75 JDIMM1.64
DDR_A_DQS7: length 58.2
  IN1 w0.084: 115.43,51.41 115.43,51.42 115.45,51.43 115.45,53.99 119.16,57.71 119.16,62.14 119.23,62.22 119.38,62.36 119.38,63.11 119.38,63.11 119.38,63.22 119.41,63.24 119.41,63.75 120.01,64.35 120.37,64.35 120.59,64.57 121.27,64.57 121.45,64.75 121.45,65.22 v2(121.08,65.6)
  IN1 w0.114: 115.43,51.41 115.43,41.11 118.38,38.16 118.38,36.86 118.68,36.56 119.53,36.56 119.63,36.46 119.63,30.83 118.68,29.89 118.68,26.83 118.57,26.71 117.91,26.71 117.63,26.43 117.63,25.85 117.91,25.57 118.57,25.57 118.68,25.45 118.68,24.37 117.15,22.84 117.15,20.8 117.49,20.46 118.1,20.46 v2(118.28,20.28)
  BOTTOM w0.076: UC1.AL49 121.37,65.9 v2(121.08,65.6)
  BOTTOM w0.114: v2(118.28,20.28) 118.03,20.52 117.93,20.52 117.81,20.41 117.81,18.96 118,18.77 JDIMM1.188
DDR_A_DQS#0: length 63.1
  IN1 w0.114: v2(102.58,29.44) 102.58,29.27 102.7,29.15 102.87,29.15 102.99,29.28 102.99,30.38 102.2,31.18 102.2,47.64 102.48,47.92 102.71,47.92 102.81,48.02 102.81,48.39 102.71,48.49 102.48,48.49 102.2,48.78 102.2,49.39 102.47,49.66 102.66,49.66 102.8,49.8 102.8,50.15 102.68,50.26 102.48,50.26 102.2,50.54 102.2,51.12 102.48,51.41 102.68,51.41 102.8,51.52 102.8,51.86 102.68,51.98 102.48,51.98 102.2,52.26 102.2,52.84 102.48,53.12 102.68,53.12 102.8,53.24 102.8,53.58 102.68,53.7 102.48,53.7 102.2,53.98 102.2,54.83 102.47,55.1 102.7,55.1 102.82,55.21 102.82,55.56 102.7,55.67 100.76,55.67 100.48,55.95 100.48,56.53 100.76,56.82 102.7,56.82 102.82,56.93 102.82,57.27 102.7,57.39 100.9,57.39 100.61,57.68 100.61,58.24 100.9,58.53 104.09,58.53 105.94,60.38 105.94,60.96 106.19,61.22 106.19,62.03 107.52,63.37 107.52,63.64 107.41,63.75 v2(107.3,63.75)
  BOTTOM w0.076: 110.27,66.74 110.28,66.76 110.31,66.76 110.7,67.15 111.99,67.15 112.08,67.24 112.71,67.24 112.8,67.28 112.87,67.32 113.07,67.32 113.23,67.24 113.36,67.24 113.46,67.29 113.52,67.32 113.75,67.32 113.78,67.29 113.89,67.24 113.95,67.18 114.27,66.86 UC1.AJ61
  BOTTOM w0.114: 110.27,66.74 109.81,66.29 109.03,66.29 107.3,64.55 v2(107.3,63.75) ; JDIMM1.135 102.1,27.01 102.25,27.16 102.25,27.32 101.89,27.68 101.89,28.99 102.16,29.26 102.4,29.26 v2(102.58,29.44)
DDR_A_DQS#1: length 84.7
  IN4 w0.114: v2(111.31,63.87) 111.18,63.75 111.18,62.61 109.35,60.77 109.35,60.65 104.76,56.07 101.28,56.07 98.87,53.65 82.85,53.65 61.84,32.63 61.84,21.4 62.35,20.89 62.7,20.89 62.82,21 v2(62.82,21.25)
  BOTTOM w0.076: v2(111.31,63.87) 111.23,63.79 111.1,63.79 110.92,63.97 110.92,64.3 111.27,64.65 112.74,64.65 112.8,64.67 112.89,64.71 112.91,64.72 113.04,64.72 113.06,64.71 113.14,64.67 113.19,64.65 113.56,64.65 113.67,64.55 113.67,64.47 UC1.AN62
  BOTTOM w0.114: v2(62.82,21.25) 62.82,21 62.73,20.91 62.09,20.91 61.78,20.6 61.78,19.83 62.57,19.04 62.57,18.9 62.51,18.84 62.26,18.84 62.2,18.79 JDIMM1.10
DDR_A_DQS#2: length 54.9
  IN1 w0.084: 111.81,60.24 111.81,60.26 111.83,60.24 113.35,61.76 113.35,61.76 113.89,62.3 113.89,63.65 114.94,64.69 115.19,64.69 v2(115.42,64.92)
  IN1 w0.114: 111.81,60.24 107.55,55.98 107.55,36.62 108.15,36.02 108.15,24.98 108.51,24.61 108.51,23.88 108.4,23.76 107.54,23.76 107.27,23.49 107.27,22.89 107.54,22.62 108.4,22.62 108.51,22.5 108.51,22.08 108.17,21.74 108.17,20.97 108.01,20.8 107.93,20.8 v2(107.69,21.04)
  BOTTOM w0.076: UC1.AM58 115.74,65.25 v2(115.42,64.92)
  BOTTOM w0.114: JDIMM1.152 107.2,19 107.04,19.16 107.04,20.55 107.23,20.73 107.39,20.73 v2(107.69,21.04)
DDR_A_DQS#3: length 81
  IN4 w0.084: v2(117.32,64.92) 117.32,65.02 117.44,65.14 117.6,65.14 117.7,65.04 117.7,62.56 115.64,60.51 114.58,60.51 114.56,60.52 114.54,60.52
  IN4 w0.114: 114.54,60.52 114.08,60.52 110.51,56.95 110.51,56.41 105.11,51 104.17,51 104.1,51.07 104.1,51.61 103.8,51.9 103.25,51.9 102.95,51.61 102.95,51.09 102.87,51 101.03,51 100.28,50.25 85.03,50.25 73.34,38.57 72.51,37.74 71.36,36.59 71.36,36.11 71.68,35.8 71.68,35.56 71.34,35.22 71.18,35.22 70.77,35.63 70.36,35.63 69.96,35.24 69.96,34.82 70.36,34.42 70.36,34.24 70.14,34.02 69.96,34.02 69.56,34.42 69.14,34.42 68.75,34.03 68.75,33.61 69.33,33.03 69.33,32.67 69.08,32.42 68.04,32.42 67.75,32.13 67.75,31.35 68.04,31.06 68.51,31.06 68.62,30.95 68.62,30.41 68.23,30.02 68.23,29.25 68.12,29.14 67.84,29.14 67.75,29.24 v2(67.75,29.44)
  BOTTOM w0.076: UC1.AM55 117.71,65.12 117.51,64.92 v2(117.32,64.92)
  BOTTOM w0.114: v2(67.75,29.44) 67.49,29.18 67.28,29.18 66.99,28.88 66.99,27.72 67.43,27.28 67.43,27.03 67.3,26.9 JDIMM1.27
DDR_A_DQS#4: length 49.4
  IN1 w0.084: 111.52,51.41 111.52,51.42 111.51,51.43 111.51,54.64 111.88,55.01 111.88,55.9 112,56.03 112.89,56.03 113.27,56.41 113.27,56.78 112.65,57.4 112.65,57.69 v2(112.74,57.77)
  IN1 w0.114: 111.52,51.41 111.52,40.2 113.9,37.82 113.9,37.04 113.62,36.75 113.5,36.75 113.4,36.65 113.4,36.28 113.5,36.18 114.2,36.18 114.47,35.91 114.47,35.31 114.2,35.04 113.52,35.04 113.41,34.92 113.41,34.58 113.52,34.47 114.2,34.47 114.47,34.2 114.47,33.59 114.2,33.32 113.5,33.32 113.4,33.22 113.4,32.85 113.5,32.75 114.18,32.75 114.47,32.45 114.47,31.9 114.18,31.6 113.5,31.6 113.4,31.5 113.4,31.13 113.5,31.03 113.62,31.03 113.9,30.75 113.9,29.19 113.62,28.91 113.39,28.91 v2(113.15,28.67)
  BOTTOM w0.076: v2(112.74,57.77) 112.74,57.53 112.89,57.38 113.14,57.38 114.02,58.25 114.84,58.25 115.88,59.3 115.88,59.82 116.13,60.06 116.13,60.25 116.05,60.41 116.05,60.61 116.13,60.77 116.13,60.9 116.08,61 116.05,61.06 116.05,61.26 116.13,61.43 116.19,61.49 116.28,61.58 116.43,61.58 116.51,61.66 UC1.AV57
  BOTTOM w0.114: v2(113.15,28.67) 113.42,28.94 113.52,28.94 113.7,28.76 113.7,27.84 113.32,27.46 112.72,27.46 112.49,27.23 112.49,27.09 112.3,26.9 JDIMM1.169
DDR_A_DQS#5: length 76.4
  IN4 w0.084: v2(117.37,56.9) 117.49,57.02 117.49,57.13 117.14,57.48 116.93,57.48 116.43,56.98 113.08,53.63 113.08,52.35 112.88,52.15 112.88,51.54 112.89,51.52 112.89,51.43 112.91,51.42 112.91,51.41
  IN4 w0.114: 112.91,51.41 112.91,51.22 108.72,47.03 102.98,47.03 102.23,46.27 88.02,46.27 87.66,45.92 87.26,45.92 86.91,46.27 86.73,46.27 86.5,46.05 86.5,45.87 86.86,45.51 86.86,45.11 86.45,44.7 86.05,44.7 85.66,45.09 85.49,45.09 85.26,44.86 85.26,44.68 85.64,44.3 85.64,43.9 85.23,43.49 84.83,43.49 84.45,43.87 84.27,43.87 84.05,43.65 84.05,43.47 84.43,43.08 84.43,42.69 84.02,42.27 83.62,42.27 83.3,42.59 83.12,42.59 82.9,42.37 82.9,42.19 83.21,41.87 83.21,41.47 82.61,40.87 82.21,40.87 81.86,41.22 81.68,41.22 81.46,41 81.46,40.82 81.81,40.47 81.81,40.07 74.41,32.67 74.41,31.41 73.92,30.92 73.57,30.92 73.43,30.79 73.43,29.27 73.51,29.19 73.74,29.19 73.89,29.33 v2(73.89,29.44)
  BOTTOM w0.076: v2(117.37,56.9) 117.37,57.77 117.79,58.2 117.79,58.33 118.16,58.7 118.16,59.51 118.31,59.66 118.31,59.79 118.56,60.04 118.56,60.25 118.51,60.35 118.49,60.41 118.49,60.61 118.56,60.77 118.56,61.26 118.67,61.37 118.67,61.53 UC1.AV53
  BOTTOM w0.114: JDIMM1.45 72.7,26.92 72.87,27.1 72.87,28.82 73.22,29.17 73.62,29.17 v2(73.89,29.44)
DDR_A_DQS#6: length 84.7
  IN4 w0.084: 117.01,51.41 117.01,51.42 117.03,51.43 117.03,54.15 120.29,57.41 120.29,57.65 122.05,59.41 122.05,62.16 122.54,62.65 123.05,62.65 123.33,62.93 123.33,64.01 123.74,64.42 124.14,64.42 124.38,64.65 124.98,64.65 125.02,64.69 125.03,64.69 125.21,64.87 125.21,65.36 125.3,65.45 125.3,65.61 125.21,65.7 v2(124.89,65.7)
  IN4 w0.114: v2(78.93,21.25) 78.93,21.08 79.02,20.99 79.23,20.99 79.38,21.13 79.38,22.51 79.21,22.68 78.24,22.68 77.97,22.95 77.97,23.84 78.24,24.11 78.58,24.11 78.71,24.23 78.71,32.15 89.43,42.87 110.65,42.87 117.01,49.24 117.01,51.41
  BOTTOM w0.076: v2(124.89,65.7) 125.08,65.9 UC1.AL43
  BOTTOM w0.114: v2(78.93,21.25) 78.69,21.01 78.34,21.01 77.97,20.64 77.97,18.87 77.8,18.7 JDIMM1.62
DDR_A_DQS#7: length 58.7
  IN1 w0.084: v2(122.03,65.57) 121.93,65.67 121.67,65.67 121.57,65.57 121.57,65.39 121.65,65.31 121.65,64.66 121.35,64.36 120.67,64.36 120.45,64.15 120.09,64.15 119.61,63.67 119.61,63.24 119.64,63.22 119.64,62.25 119.42,62.03 119.42,57.6 115.7,53.89 115.7,51.43 115.72,51.42 115.72,51.41
  IN1 w0.114: 115.72,51.41 115.72,41.23 118.67,38.27 118.67,36.98 118.8,36.85 119.64,36.85 119.91,36.58 119.91,30.71 118.97,29.77 118.97,26.71 118.69,26.43 118.03,26.43 117.91,26.31 117.91,25.97 118.03,25.86 118.69,25.86 118.97,25.57 118.97,24.25 117.44,22.72 117.44,20.92 117.61,20.75 118.17,20.75 118.28,20.86 v2(118.28,21.04)
  BOTTOM w0.076: UC1.AL48 122.35,65.9 v2(122.03,65.57)
  BOTTOM w0.114: JDIMM1.186 117.4,18.75 117.57,18.93 117.57,20.5 117.83,20.76 118,20.76 v2(118.28,21.04)
DDR_A_MA0: length 77.8
  IN4 w0.084: 126.29,51.41 126.29,52.05 127.74,53.5 127.74,55.24 128.79,56.29 128.79,58.05 128.58,58.26 128.58,60.4 128.71,60.53 128.71,61.45 128.99,61.73 128.99,61.73 129.18,61.92 v2(129.27,61.92)
  IN4 w0.132: v2(91.36,19.9) 91.85,20.38 91.85,25.35 90.26,26.94 90.26,32.35 92.7,34.79 119.37,34.79 126.29,41.71 126.29,51.41
  BOTTOM w0.076: v2(129.27,61.92) 129.49,62.14 UC1.AU36
  BOTTOM w0.17: v2(91.36,19.9) 90.88,19.42 90.88,18.92 91,18.8 JDIMM1.98
DDR_A_MA1: length 79.3
  IN4 w0.084: 127.06,51.41 127.06,52.11 128.09,53.14 128.09,55.09 129.14,56.14 129.14,59.03 v2(129.27,59.16)
  IN4 w0.132: 127.06,51.41 127.06,40.54 120.24,33.72 117.82,33.72 116.72,32.62 112.85,32.62 112.71,32.75 112.71,33.21 112.61,33.31 112.29,33.31 112.19,33.21 112.19,32.75 112.05,32.62 111.75,32.62 111.62,32.75 111.62,33.6 111.49,33.73 111.23,33.73 111.09,33.6 111.09,32.75 110.96,32.62 110.7,32.62 110.57,32.75 110.57,33.6 110.43,33.73 110.17,33.73 110.04,33.6 110.04,32.75 109.91,32.62 109.64,32.62 109.51,32.75 109.51,33.6 109.38,33.73 109.11,33.73 108.98,33.6 108.98,32.75 108.85,32.62 108.58,32.62 108.45,32.75 108.45,33.6 108.32,33.73 108.06,33.73 107.92,33.6 107.92,32.75 107.79,32.62 107.53,32.62 107.4,32.75 107.4,33.6 107.26,33.73 107,33.73 106.87,33.6 106.87,32.75 106.74,32.62 106.35,32.62 106.25,32.72 106.25,33.62 106.15,33.72 92.86,33.72 91.71,32.56 91.71,28.7 91.3,28.29 v2(90.75,28.29)
  BOTTOM w0.076: v2(129.27,59.16) 128.85,59.58 UC1.AY37
  BOTTOM w0.17: JDIMM1.97 90.7,26.82 91.21,27.34 91.21,27.83 v2(90.75,28.29)
DDR_A_MA2: length 80.8
  IN4 w0.084: 125.13,51.41 125.13,52.16 127.23,54.25 127.23,55.48 128.19,56.44 128.19,57.92 127.33,58.78 127.33,59.9 127.5,60.07 127.75,60.07 128.25,60.57 v2(128.25,62.97)
  IN4 w0.132: v2(91.36,21.42) 90.89,21.89 90.89,25.2 88.39,27.7 88.39,32.19 92.14,35.95 116.94,35.95 122.87,41.88 124.82,41.88 125.13,42.19 125.13,46.13 124.66,46.6 124.66,47.42 125.13,47.89 125.13,51.41
  BOTTOM w0.076: v2(128.25,62.97) 128.57,63.3 UC1.AR38
  BOTTOM w0.17: v2(91.36,21.42) 90.4,20.46 JDIMM1.96
DDR_A_MA3: length 79.6
  IN4 w0.084: v2(129.2,63.77) 129.36,63.77 129.6,63.53 129.6,62.74 129.72,62.62 129.72,61.69 129.58,61.55 129.06,61.55 128.89,61.38 128.89,60.44 128.77,60.31 128.77,58.32 128.97,58.12 128.97,56.21 127.92,55.16 127.92,53.21 126.68,51.97 126.68,51.41
  IN4 w0.132: v2(90.75,29.82) 90.76,29.82 91.32,30.38 91.32,32.8 92.64,34.12 112.06,34.12 112.18,34 112.18,33.8 112.28,33.7 112.6,33.7 112.71,33.8 112.71,34 112.84,34.13 113.1,34.13 113.23,34 113.23,33.11 113.34,33 113.66,33 113.76,33.11 113.76,34 113.89,34.13 114.16,34.13 114.29,34 114.29,33.11 114.39,33 114.72,33 114.82,33.11 114.82,34 114.95,34.13 115.22,34.13 115.35,34 115.35,33.11 115.45,33 115.77,33 115.88,33.11 115.88,34 116.01,34.13 116.27,34.13 116.4,34 116.4,33.37 116.51,33.27 116.83,33.27 116.93,33.37 116.93,34 117.05,34.12 120.09,34.12 126.68,40.7 126.68,51.41
  BOTTOM w0.076: UC1.AP36 129.37,63.95 v2(129.2,63.77)
  BOTTOM w0.17: JDIMM1.95 90.1,29.17 v2(90.75,29.82)
DDR_A_MA4: length 80.7
  IN4 w0.084: v2(127.69,61.89) 127.24,61.89 126.97,61.62 126.97,58.63 127.83,57.77 127.83,56.65 125.36,54.18 125.36,54.03 124.36,53.04 124.36,51.41
  IN4 w0.132: 124.36,51.41 124.36,48.21 123.89,47.74 123.89,46.28 124.36,45.81 124.36,44.6 116.58,36.82 91.78,36.82 87.35,32.39 87.35,27.03 87.48,26.9 88.01,26.9 88.14,26.77 88.14,26.5 88.01,26.37 87.48,26.37 87.35,26.24 87.35,25.98 87.48,25.84 88.04,25.84 88.18,25.71 88.18,25.45 88.04,25.32 87.48,25.32 87.35,25.18 87.35,21.37 v2(88.06,20.66)
  BOTTOM w0.076: v2(127.69,61.89) 127.94,62.14 UC1.AU39
  BOTTOM w0.17: v2(88.06,20.66) 89.2,19.52 89.2,19.52 JDIMM1.92
DDR_A_MA5: length 79.5
  IN4 w0.084: 125.9,51.41 125.9,52.23 127.57,53.9 127.57,55.32 128.61,56.36 128.61,57.98 128.38,58.21 128.38,60.46 128.54,60.61 128.54,61.97 128.62,62.06 128.79,62.06 128.9,62.17 128.9,62.31 128.79,62.42 128.64,62.42 128.52,62.54 128.52,62.71 128.64,62.84 129.15,62.84 129.2,62.89 v2(129.2,63.12)
  IN4 w0.132: 125.9,51.41 125.9,41.87 121.79,37.75 121.64,37.75 121.41,37.98 121.23,37.98 121.04,37.79 121.04,37.61 121.25,37.39 121.25,37.21 121.06,37.02 120.88,37.02 120.08,37.82 119.9,37.82 119.71,37.62 119.71,37.44 120.5,36.65 120.5,36.47 120.31,36.27 120.13,36.27 119.33,37.07 119.15,37.07 118.96,36.87 118.96,36.7 119.76,35.9 119.76,35.72 119.56,35.53 119.38,35.53 118.63,36.28 118.44,36.28 118.25,36.1 118.25,35.91 118.61,35.55 118.61,35.37 118.42,35.18 118.24,35.18 117.88,35.54 117.62,35.54 117.26,35.18 92.54,35.18 89.77,32.41 89.77,28.17 89.64,28.04 89.35,28.04 89.22,28.17 v2(89.22,28.29)
  BOTTOM w0.076: v2(129.2,63.12) 129.37,63.3 UC1.AR36
  BOTTOM w0.17: JDIMM1.91 88.9,27.19 88.76,27.34 88.76,27.94 89.1,28.29 v2(89.22,28.29)
DDR_A_MA6: length 80.3
  IN4 w0.084: 123.97,51.41 123.97,53.03 125.09,54.14 125.09,54.57 v2(127.46,56.94)
  IN4 w0.132: 123.97,51.41 123.97,48.37 123.51,47.9 123.51,46.12 123.97,45.65 123.97,44.76 116.42,37.21 91.62,37.21 86.8,32.39 86.8,27.22 86.67,27.09 85.37,27.09 85.24,26.96 85.24,26.69 85.37,26.56 86.67,26.56 86.8,26.43 86.8,19.43 87.1,19.13 v2(88.06,19.13)
  BOTTOM w0.076: v2(127.46,56.94) 127.88,57.36 127.88,58.01 126.98,58.91 126.98,61.19 UC1.AV40
  BOTTOM w0.17: v2(88.06,19.13) 88.6,18.59 JDIMM1.90
DDR_A_MA7: length 81.3
  IN4 w0.084: v2(127.69,60.54) 127.15,60 127.15,58.7 128.01,57.84 128.01,56.58 127.05,55.63 127.05,54.4 124.75,52.09 124.75,51.41
  IN4 w0.132: v2(88.06,22.18) 88.65,22.18 88.81,22.34 88.81,23.32 88.94,23.45 89.43,23.45 89.56,23.58 89.56,23.85 89.43,23.98 88.94,23.98 88.81,24.11 88.81,24.37 88.94,24.51 89.43,24.51 89.56,24.64 89.56,24.9 89.43,25.03 88.94,25.03 88.81,25.17 88.81,25.43 88.94,25.56 89.36,25.56 89.48,25.69 89.48,25.96 89.36,26.09 88.94,26.09 88.81,26.22 88.81,26.73 88,27.54 88,32.43 91.96,36.38 116.76,36.38 122.64,42.27 124.66,42.27 124.75,42.35 124.75,45.97 124.28,46.44 124.28,47.58 124.75,48.05 124.75,51.41
  BOTTOM w0.076: v2(127.69,60.54) 127.98,60.84 UC1.AW39
  BOTTOM w0.17: v2(88.06,22.18) 87.4,21.53 JDIMM1.86
DDR_A_MA8: length 78.1
  IN4 w0.084: 125.52,51.41 125.52,52.16 127.4,54.04 127.4,55.4 128.37,56.37 128.37,57.98 128.08,58.27 128.08,59.21 v2(127.7,59.58)
  IN4 w0.132: v2(89.22,29.82) 89.08,29.82 88.78,30.12 88.78,30.87 88.9,31 89.2,31 89.33,31.13 89.33,31.4 89.2,31.53 88.9,31.53 88.78,31.65 88.78,31.98 88.9,32.11 89.14,32.11 89.33,32.3 89.33,32.59 92.3,35.56 117.1,35.56 119.9,38.36 120.09,38.36 120.49,37.97 120.67,37.97 120.86,38.16 120.86,38.34 120.46,38.74 120.46,38.92 120.66,39.12 120.83,39.12 121.63,38.32 121.81,38.32 122,38.51 122,38.69 121.21,39.49 121.21,39.67 121.4,39.86 121.58,39.86 122.38,39.07 122.56,39.07 122.75,39.26 122.75,39.44 121.96,40.23 121.96,40.42 122.15,40.61 122.33,40.61 123.13,39.81 123.3,39.81 123.5,40.01 123.5,40.19 122.7,40.98 122.7,41.16 122.96,41.42 123.14,41.42 123.94,40.61 124.1,40.61 125.52,42.03 125.52,46.29 125.05,46.76 125.05,47.26 125.52,47.73 125.52,51.41
  BOTTOM w0.076: UC1.AY39 127.7,59.79 v2(127.7,59.58)
  BOTTOM w0.17: v2(89.22,29.82) 88.28,28.88 88.28,27.22 88.3,27.21 JDIMM1.89
DDR_A_MA9: length 80.6
  IN4 w0.084: 123.59,51.41 123.59,52.96 124.86,54.24 124.86,55.06 127.39,57.59 v2(127.46,57.59)
  IN4 w0.132: 123.59,51.41 123.59,48.61 123.12,48.14 123.12,45.96 123.59,45.49 123.59,44.92 120.47,41.8 120.28,41.8 119.72,42.37 119.53,42.37 119.34,42.18 119.34,41.99 119.91,41.43 119.91,41.24 119.63,40.97 119.49,40.97 118.87,41.59 118.69,41.59 118.5,41.4 118.5,41.21 119.12,40.6 119.12,40.45 118.89,40.22 118.74,40.22 118.13,40.84 117.94,40.84 117.75,40.65 117.75,40.46 118.37,39.85 118.37,39.71 118.14,39.47 118,39.47 117.38,40.09 117.19,40.09 117,39.9 117,39.72 117.62,39.1 117.62,38.96 117.39,38.73 117.25,38.73 116.63,39.34 116.44,39.34 116.26,39.16 116.26,38.97 116.87,38.35 116.87,38.21 116.64,37.98 116.5,37.98 115.88,38.6 115.7,38.6 115.51,38.41 115.51,38.22 115.77,37.97 115.77,37.82 115.54,37.59 115.39,37.59 115.14,37.85 114.95,37.85 114.75,37.65 91.44,37.65 86.31,32.53 86.31,29.96 86.17,29.82 v2(85.82,29.82)
  BOTTOM w0.076: v2(127.46,57.59) 126.82,58.23 126.82,61.44 127.23,61.85 UC1.AU40
  BOTTOM w0.17: v2(85.82,29.82) 87.1,28.54 JDIMM1.85
DDR_A_MA10: length 80.7
  IN4 w0.084: v2(130.15,63.62) 129.78,63.25 129.78,62.82 129.96,62.63 129.96,60.31 130.1,60.17 130.1,58.55 130.42,58.24 130.42,56.15 130.25,55.98 130.25,55.84 129.08,54.68 129.08,51.9 128.94,51.76 128.94,51.41
  IN4 w0.132: 128.94,51.41 128.94,39.76 120.96,31.78 118.54,31.78 116.82,30.06 116.82,27.47 116.3,26.94 106.54,26.94 106.4,27.08 106.4,29.69 106.3,29.79 105.98,29.79 105.88,29.69 105.88,27.08 105.74,26.94 105.3,26.94 105.07,27.18 105.07,29.96 104.29,30.74 101.57,30.74 100.47,31.84 96.64,31.84 95.88,31.07 95.88,30.57 v2(95.12,29.82)
  BOTTOM w0.076: v2(130.15,63.62) 130.48,63.95 UC1.AP35
  BOTTOM w0.17: JDIMM1.107 93.7,28.4 v2(95.12,29.82)
DDR_A_MA11: length 79.6
  IN4 w0.084: v2(126.12,60.53) 126.63,60.02 126.63,57.47 126.22,57.06 124.13,54.97 124.13,54.5 122.82,53.19 122.82,51.41
  IN4 w0.132: v2(86.28,21.42) 85.81,21.89 85.81,23.91 85.37,24.35 85.37,24.88 85.27,24.98 84.67,24.98 84.57,25.08 84.57,25.41 84.7,25.54 86.24,25.54 86.37,25.67 86.37,25.94 86.24,26.07 84.7,26.07 84.57,26.2 84.57,29.41 84.85,29.7 84.85,32.3 91.07,38.53 114.46,38.53 121.73,45.8 121.73,48.64 121.83,48.75 122.46,48.75 122.82,49.1 122.82,51.41
  BOTTOM w0.076: UC1.AW41 126.43,60.84 v2(126.12,60.53)
  BOTTOM w0.17: v2(86.28,21.42) 86.8,20.9 JDIMM1.84
DDR_A_MA12: length 79.6
  IN4 w0.084: 123.2,51.41 123.2,52.89 124.69,54.38 124.69,55.15 126.56,57.02 126.8,57.26 126.8,61.7 126.55,61.95 126.24,61.95 v2(126.11,61.82)
  IN4 w0.132: v2(85.82,28.29) 85.08,28.29 84.95,28.42 84.95,28.8 85.08,28.93 85.21,28.93 85.34,29.06 85.34,30.98 85.46,31.1 85.79,31.1 85.93,31.23 85.93,31.5 85.79,31.63 85.46,31.63 85.34,31.76 85.34,32.08 85.46,32.21 85.8,32.21 85.93,32.33 85.93,32.76 86.46,33.3 86.46,33.3 91.26,38.09 114.64,38.09 119.58,43.03 119.77,43.03 120.35,42.45 120.53,42.45 120.72,42.64 120.72,42.83 120.14,43.4 120.14,43.59 120.33,43.78 120.52,43.78 121.09,43.2 121.28,43.2 121.47,43.39 121.47,43.57 120.89,44.15 120.89,44.34 121.08,44.52 121.26,44.52 121.84,43.95 122.03,43.95 122.21,44.13 122.21,44.32 121.64,44.9 121.64,45.08 121.83,45.27 122.01,45.27 122.59,44.69 122.77,44.69 123.2,45.12 123.2,45.33 122.53,46 122.25,46 122.12,46.13 122.12,47.18 122.25,47.3 122.61,47.3 122.73,47.43 122.73,47.7 122.61,47.83 122.22,47.83 122.12,47.93 122.12,48.26 122.22,48.36 122.62,48.36 123.2,48.94 123.2,51.41
  BOTTOM w0.076: v2(126.11,61.82) 126.42,62.14 UC1.AU41
  BOTTOM w0.17: JDIMM1.83 86.5,27.62 v2(85.82,28.29)
DDR_A_MA13: length 80.2
  IN4 w0.084: 130.52,51.41 130.52,51.42 130.25,51.69 130.25,54.96 130.94,55.64 130.94,57.65 131.07,57.79 131.09,57.79 131.41,58.1 131.41,58.12 131.41,58.13 131.41,59.63 131.11,59.94 130.65,59.94 130.15,60.43 v2(130.15,62.97)
  IN4 w0.132: v2(98.52,29.82) 99.22,29.11 99.22,28.38 102.2,25.4 103.63,25.4 103.98,25.06 104.88,25.06 105.01,24.92 105.01,24.29 105.14,24.15 105.41,24.15 105.54,24.29 105.54,24.92 105.67,25.06 105.93,25.06 106.07,24.92 106.07,24.29 106.2,24.15 106.46,24.15 106.59,24.29 106.59,24.92 106.73,25.06 108.6,25.06 108.73,24.92 108.73,24.33 108.86,24.19 109.13,24.19 109.26,24.33 109.26,24.92 109.39,25.06 109.66,25.06 109.79,24.92 109.79,24.33 109.92,24.19 110.18,24.19 110.32,24.33 110.32,24.92 110.45,25.06 112.2,25.06 112.33,24.92 112.33,24.34 112.46,24.21 112.73,24.21 112.86,24.34 112.86,24.92 112.99,25.06 115.88,25.06 116.61,25.79 117.39,25.79 118.77,27.16 118.77,30.09 119.3,30.62 120.09,30.62 121.01,29.7 121.31,29.7 122.21,30.6 122.21,31.39 130.1,39.28 130.1,50.42 130.52,50.84 130.52,51.41
  BOTTOM w0.076: UC1.AR35 130.48,63.3 v2(130.15,62.97)
  BOTTOM w0.17: v2(98.52,29.82) 97.58,28.88 97.58,27.19 97.3,26.91 JDIMM1.119
DDR_A_MA14: length 79.5
  IN4 w0.084: 122.43,51.41 122.43,53.05 123.75,54.37 123.75,54.84 126.04,57.13 126.45,57.54 126.45,58.36 v2(126.08,58.73)
  IN4 w0.132: 122.43,51.41 122.43,49.43 122.13,49.13 121.4,49.13 121.3,49.03 121.3,45.91 114.3,38.91 90.91,38.91 84.36,32.36 84.36,29.9 84.07,29.61 84.07,23.33 84.17,23.23 84.77,23.23 84.87,23.13 84.87,22.89 85.01,22.76 85.28,22.76 85.41,22.63 85.41,22.36 85.28,22.23 85.01,22.23 84.87,22.1 84.87,21.83 85.01,21.7 85.28,21.7 85.41,21.57 85.41,21.3 85.28,21.17 85.01,21.17 84.87,21.04 84.87,20.62 84.98,20.52 85.62,20.52 86.25,19.88 86.25,19.87 v2(86.28,19.9)
  BOTTOM w0.076: v2(126.08,58.73) 125.41,59.4 125.41,61.19 UC1.AV42
  BOTTOM w0.17: v2(86.28,19.9) 85.6,19.22 JDIMM1.80
DDR_A_MA15: length 81.4
  IN4 w0.084: v2(126.08,58.08) 125.05,57.05 125.05,56.7 123.31,54.96 123.31,54.18 122.04,52.91 122.04,51.89
  IN4 w0.132: v2(84.32,21.42) 83.76,21.42 83.58,21.59 83.58,29.81 83.87,30.1 83.87,32.42 90.75,39.3 114.14,39.3 120.86,46.01 120.86,49.42 120.96,49.52 121.94,49.52 122.04,49.62 122.04,49.97 121.91,50.1 120.99,50.1 120.85,50.24 120.85,50.5 120.99,50.63 121.91,50.63 122.04,50.76 122.04,51.03 121.91,51.16 121.21,51.16 121.11,51.26 121.11,51.59 121.21,51.69 121.91,51.69 122.04,51.82 122.04,51.89
  BOTTOM w0.076: UC1.AU42 125.65,61.95 125.24,61.54 125.24,58.91 126.08,58.07 v2(126.08,58.08)
  BOTTOM w0.17: JDIMM1.78 85,20.74 v2(84.32,21.42)
DDR_A_RAS#: length 79.6
  IN4 w0.084: v2(132.95,54.26) 132.37,53.67 132.37,51.41
  IN4 w0.132: v2(95.1,19.9) 95.95,19.9 96.16,20.11 96.16,20.27 96.3,20.4 96.55,20.4 96.69,20.53 96.69,20.8 96.55,20.93 95.87,20.93 95.75,21.06 95.75,21.33 95.87,21.46 96.55,21.46 96.69,21.59 96.69,21.85 96.55,21.98 96.3,21.98 96.16,22.12 96.16,22.44 96.33,22.61 116.4,22.61 124.54,30.75 124.54,31.54 132.37,39.37 132.37,42.72 132.24,42.85 132.05,42.85 131.93,42.98 131.93,43.25 132.05,43.38 132.24,43.38 132.37,43.51 132.37,43.77 132.24,43.91 131.78,43.91 131.64,44.04 131.64,44.3 131.78,44.43 132.24,44.43 132.37,44.57 132.37,44.83 132.24,44.96 131.78,44.96 131.64,45.09 131.64,45.36 131.78,45.49 132.24,45.49 132.37,45.62 132.37,45.89 132.24,46.02 131.78,46.02 131.64,46.15 131.64,46.41 131.78,46.55 132.24,46.55 132.37,46.68 132.37,46.94 132.24,47.08 131.78,47.08 131.64,47.21 131.64,47.47 131.78,47.6 132.24,47.6 132.37,47.74 132.37,48 132.24,48.13 131.78,48.13 131.64,48.26 131.64,49.3 132.37,50.02 132.37,51.41
  BOTTOM w0.076: v2(132.95,54.26) 131.25,55.96 UC1.AY34
  BOTTOM w0.17: JDIMM1.110 94.6,19.4 v2(95.1,19.9)
DDR_A_WE#: length 80.2
  IN4 w0.084: v2(130.84,60.53) 131.01,60.53 131.76,59.78 131.76,57.99 131.75,57.98 131.75,57.96 131.28,57.49 131.28,52.51 131.39,52.4 131.39,51.41
  IN4 w0.132: 131.39,51.41 131.39,50.29 130.87,49.77 130.87,42.04 131,41.9 131.49,41.9 131.59,41.8 131.59,39.68 122.99,31.07 122.99,30.29 117.71,25.01 116.93,25.01 116.59,24.67 116.59,23.88 116.08,23.38 103.64,23.38 103.51,23.51 103.51,24.07 103.41,24.17 103.08,24.17 102.98,24.07 102.98,23.51 102.85,23.38 102.58,23.38 102.45,23.51 102.45,24.01 102.35,24.11 102.03,24.11 101.92,24.01 101.92,23.51 101.79,23.38 101.45,23.38 101.32,23.51 101.32,25.18 101.22,25.29 100.89,25.29 100.79,25.18 100.79,23.51 100.66,23.38 100.29,23.38 100.12,23.55 100.12,25.32 98.02,27.43 98.02,28.87 v2(97.07,29.82)
  BOTTOM w0.076: UC1.AW34 131.15,60.84 v2(130.84,60.53)
  BOTTOM w0.17: JDIMM1.113 95.5,27.29 96.13,27.92 96.13,28.88 v2(97.07,29.82)
DDR_B_BS0: length 99.1
  IN1 w0.084: v2(130.15,65.57) 129.76,65.97 129.76,67.07 129.51,67.31 129.2,67.31 128.62,66.74 128.62,57.55 128.38,57.31 128.38,53.62 127.64,52.88 127.64,51.41
  IN1 w0.132: v2(171.22,28.17) 170.78,28.61 169.47,28.61 169.34,28.74 169.34,29.01 169.47,29.14 170.65,29.14 170.77,29.26 170.77,29.59 170.65,29.72 170.47,29.72 170.35,29.84 170.35,31.82 166.53,35.64 139.31,35.64 139.18,35.77 139.18,37.5 139.06,37.62 138.77,37.62 138.65,37.5 138.65,35.77 138.52,35.64 138.23,35.64 138.11,35.77 138.11,38.36 137.98,38.49 137.7,38.49 137.57,38.36 137.57,36.57 137.44,36.45 137.16,36.45 137.03,36.57 137.03,38.36 136.9,38.49 136.62,38.49 136.49,38.36 136.49,37.65 136.36,37.52 136.08,37.52 135.95,37.65 135.95,38.36 135.83,38.49 135.12,38.49 134.69,38.91 134.69,39.1 134.95,39.36 134.95,39.54 134.75,39.74 134.57,39.74 134.31,39.48 134.12,39.48 133.93,39.68 133.93,39.86 134.19,40.12 134.19,40.31 133.99,40.5 133.81,40.5 133.55,40.24 133.36,40.24 132.59,41.01 132.59,41.2 132.85,41.46 132.85,41.65 132.65,41.84 132.47,41.84 132.21,41.58 132.02,41.58 131.83,41.78 131.83,41.96 132.09,42.22 132.09,42.41 131.89,42.6 131.71,42.6 131.45,42.34 131.26,42.34 131.07,42.54 131.07,42.72 131.32,42.98 131.32,43.17 131.13,43.36 130.94,43.36 130.69,43.11 130.5,43.11 130.31,43.3 130.31,43.49 130.56,43.74 130.56,43.93 130.37,44.13 130.18,44.13 129.92,43.87 129.74,43.87 129.54,44.06 129.54,44.25 129.8,44.51 129.8,44.69 127.64,46.85 127.64,51.41
  BOTTOM w0.076: v2(130.15,65.57) 130.48,65.9 UC1.AL35
  BOTTOM w0.17: v2(171.22,28.17) 170.74,27.68 170.74,27.05 170.8,26.99 JDIMM2.109
DDR_B_BS1: length 100
  IN1 w0.084: 128.44,51.41 128.44,52.76 129.35,53.67 129.35,56.75 129.62,57.02 129.89,57.3 129.89,61.91 129.59,62.21 129.59,64.95 129.46,65.07 v2(129.2,65.07)
  IN1 w0.132: 128.44,51.41 128.44,47.15 136.33,39.26 143.06,39.26 143.19,39.13 143.19,36.68 143.31,36.56 168.19,36.56 169.66,35.09 169.66,34.91 169.24,34.49 169.24,34.31 169.44,34.11 169.62,34.11 170.04,34.52 170.22,34.52 170.49,34.26 170.49,34.08 169.93,33.52 169.93,33.33 170.12,33.14 170.31,33.14 170.87,33.7 171.05,33.7 171.25,33.5 171.25,33.32 170.69,32.76 170.69,32.57 170.89,32.38 171.07,32.38 171.46,32.77 171.64,32.77 171.85,32.57 171.85,32.39 171.45,32 171.12,31.66 171.12,31 171.25,30.87 171.72,30.87 171.85,30.75 171.85,27.03 171.67,26.85 170.46,26.85 170.33,26.72 170.33,26.45 170.46,26.32 171.72,26.32 171.85,26.19 171.85,25.92 171.72,25.79 170.46,25.79 170.33,25.66 170.33,25.4 170.46,25.26 171.72,25.26 171.85,25.14 171.85,24.86 171.72,24.74 170.46,24.74 170.33,24.6 170.33,24.34 170.46,24.21 171.67,24.21 171.8,24.08 171.8,22.36 171.67,22.24 v2(171.05,22.24)
  BOTTOM w0.076: v2(129.2,65.07) 129.37,65.25 UC1.AM36
  BOTTOM w0.17: v2(171.05,22.24) 170.5,21.69 JDIMM2.108
DDR_B_BS2: length 95.4
  IN1 w0.084: 119.33,51.41 119.33,52.64 122.2,55.51 122.2,60.96 v2(121.4,61.76)
  IN1 w0.132: v2(161.19,23.76) 161.63,23.76 161.76,23.89 161.76,25.65 161.63,25.78 158.09,25.78 157.97,25.65 157.97,24.72 157.84,24.59 157.55,24.59 157.43,24.72 157.43,25.65 157.3,25.78 157.02,25.78 156.89,25.65 156.89,24.72 156.76,24.59 156.48,24.59 156.35,24.72 156.35,25.65 156.22,25.78 155.94,25.78 155.81,25.65 155.81,24.72 155.68,24.59 155.4,24.59 155.27,24.72 155.27,25.65 155.15,25.78 154.86,25.78 154.73,25.65 154.73,24.72 154.61,24.59 154.32,24.59 154.2,24.72 154.2,25.65 154.07,25.78 153.78,25.78 153.66,25.65 153.66,24.72 153.53,24.59 153.25,24.59 153.12,24.72 153.12,25.65 152.99,25.78 152.71,25.78 152.58,25.65 152.58,24.72 152.45,24.59 152.17,24.59 152.04,24.72 152.04,25.65 151.92,25.78 151.63,25.78 151.5,25.65 151.5,24.72 151.38,24.59 151.09,24.59 150.97,24.72 150.97,25.65 150.84,25.78 150.55,25.78 150.43,25.65 150.43,24.72 150.3,24.59 150.02,24.59 149.89,24.72 149.89,25.65 149.76,25.78 149.48,25.78 149.35,25.65 149.35,24.72 149.22,24.59 148.94,24.59 148.81,24.72 148.81,25.65 148.68,25.78 135.51,25.78 131.83,29.46 130.72,29.46 129.14,31.03 129.14,32.15 124.07,37.22 124.07,38.44 119.33,43.18 119.33,51.41
  BOTTOM w0.076: v2(121.4,61.76) 121.4,61.82 121.71,62.14 UC1.AU49
  BOTTOM w0.17: v2(161.19,23.76) 161.42,23.76 161.8,24.14 JDIMM2.79
DDR_B_CAS#: length 98.8
  IN1 w0.084: 129.59,51.41 129.59,53.11 129.86,53.38 129.86,56.54 130.41,57.08 130.41,62.46 130.72,62.76 130.72,64.55 131.11,64.94 v2(131.11,64.99)
  IN1 w0.132: v2(172.78,28.17) 173.08,28.17 173.21,28.04 173.21,26.99 173.08,26.87 172.75,26.87 172.62,26.74 172.62,26.47 172.75,26.34 173.09,26.34 173.22,26.21 173.22,25.94 173.09,25.81 172.75,25.81 172.62,25.68 172.62,25.41 172.75,25.28 173.09,25.28 173.22,25.15 173.22,24.49 173.34,24.36 173.67,24.36 173.79,24.49 173.79,25.03 173.92,25.15 175.39,25.15 175.51,25.28 175.51,25.56 175.39,25.68 173.92,25.68 173.79,25.81 173.79,26.08 173.92,26.21 175.78,26.21 175.9,26.34 175.9,28.01 175.78,28.14 175.37,28.14 175.25,28.01 175.25,26.87 175.12,26.74 173.92,26.74 173.79,26.87 173.79,27.23 173.93,27.36 174.21,27.36 174.35,27.5 174.35,27.76 174.21,27.89 173.93,27.89 173.79,28.03 173.79,28.29 173.93,28.42 174.27,28.42 174.39,28.55 174.39,28.82 174.27,28.95 173.93,28.95 173.79,29.08 173.79,32.59 168.67,37.72 152.01,37.72 151.88,37.84 151.88,38.27 151.76,38.4 151.47,38.4 151.35,38.27 151.35,37.84 151.22,37.72 150.93,37.72 150.81,37.84 150.81,38.27 150.68,38.4 148.99,38.4 146.97,40.42 136.81,40.42 129.59,47.63 129.59,51.41
  BOTTOM w0.076: UC1.AM33 131.37,65.25 v2(131.11,64.99)
  BOTTOM w0.17: v2(172.78,28.17) 172.32,27.7 172.32,27.15 172.6,26.87 JDIMM2.115
DDR_B_D0: length 83.4
  IN1 w0.084: v2(177.1,20.66) 177.1,20.5 177.23,20.38 177.92,20.38 178.05,20.5 178.05,33.59 177.5,34.14 177.5,35.2 172.58,40.12 172.58,40.67 172.48,40.77 149.97,40.77 147.95,42.79 137.83,42.79 132.19,48.43 132.19,52.72 133.5,54.03 133.5,56.11 v2(132.95,56.66)
  BOTTOM w0.076: v2(132.95,56.66) 132.11,57.5 132.11,59.67 132.5,60.05 UC1.AY31
  BOTTOM w0.102: JDIMM2.132 177.7,20.06 v2(177.1,20.66)
DDR_B_D1: length 84.4
  IN1 w0.084: v2(177.3,27.4) 177.3,26.9 177.43,26.77 177.62,26.77 177.75,26.9 177.75,33.47 177.21,34.01 177.21,35.08 172.44,39.84 172.32,39.84 172.24,39.92 172.24,40.37 172.15,40.47 172.01,40.47 171.91,40.37 171.91,39.93 171.81,39.84 171.67,39.84 171.57,39.93 171.57,40.37 171.48,40.47 171.34,40.47 171.24,40.37 171.24,39.93 171.14,39.84 171,39.84 170.9,39.93 170.9,40.37 170.81,40.47 170.67,40.47 170.57,40.37 170.57,39.93 170.47,39.84 170.33,39.84 170.23,39.93 170.23,40.37 170.13,40.47 170,40.47 169.9,40.37 169.9,39.93 169.8,39.84 169.66,39.84 169.56,39.93 169.56,40.37 169.46,40.47 169.33,40.47 169.23,40.37 169.23,39.93 169.13,39.84 168.99,39.84 168.89,39.93 168.89,40.37 168.79,40.47 168.65,40.47 168.56,40.37 168.56,39.93 168.46,39.84 168.32,39.84 168.22,39.93 168.22,40.37 168.12,40.47 167.98,40.47 167.89,40.37 167.89,39.93 167.79,39.84 167.65,39.84 167.55,39.93 167.55,40.37 167.45,40.47 167.31,40.47 167.22,40.37 167.22,39.94 167.11,39.84 166.96,39.84 166.85,39.94 166.85,40.34 166.72,40.47 149.85,40.47 147.83,42.49 137.71,42.49 131.67,48.53 131.67,52.44 133.33,54.1 133.33,55.1 v2(132.95,55.47)
  BOTTOM w0.076: v2(132.95,55.47) 131.95,56.48 131.95,59.73 132.21,60 132.21,60.26 132.3,60.43 132.5,60.63 UC1.AW31
  BOTTOM w0.102: v2(177.3,27.4) 177.4,27.31 JDIMM2.131
DDR_B_D2: length 84
  IN1 w0.084: v2(134.58,54.33) 134.95,53.95 134.95,52.22 134.43,51.7 134.43,48.91 138.66,44.69 148.81,44.69 150.83,42.67 174.6,42.67 178.51,38.76 178.51,36.88 180.1,35.29 180.1,31.72 180.84,30.97 180.84,25.03 180.43,24.62 180.43,19 180.18,18.74 179.78,18.74 179.64,18.89 v2(179.64,19.13)
  BOTTOM w0.076: v2(134.58,54.33) 133.73,55.17 133.73,59.06 133.85,59.18 UC1.AY29
  BOTTOM w0.102: v2(179.64,19.13) 180.1,18.67 JDIMM2.140
DDR_B_D3: length 85
  IN1 w0.084: v2(134.58,54.98) 135.12,54.43 135.12,52.12 134.73,51.73 134.73,49.03 134.92,48.84 135.04,48.84 135.11,48.91 135.23,48.91 135.35,48.79 135.35,48.67 135.28,48.61 135.28,48.49 135.4,48.37 135.52,48.37 135.58,48.44 135.7,48.44 135.82,48.32 135.82,48.2 135.75,48.13 135.75,48.01 135.87,47.89 135.99,47.89 136.06,47.96 136.18,47.96 136.29,47.84 136.29,47.72 136.23,47.66 136.23,47.54 136.35,47.42 136.46,47.42 136.53,47.49 136.65,47.49 136.77,47.37 136.77,47.25 136.7,47.18 136.7,47.06 136.82,46.95 136.94,46.95 137.01,47.01 137.12,47.01 137.24,46.89 137.24,46.78 137.18,46.71 137.18,46.59 137.29,46.47 137.41,46.47 137.48,46.54 137.6,46.54 137.72,46.42 137.72,46.3 137.65,46.23 137.65,46.12 137.77,46 137.89,46 137.95,46.06 138.07,46.06 138.19,45.95 138.19,45.83 138.12,45.76 138.12,45.64 138.24,45.52 138.36,45.52 138.43,45.59 138.55,45.59 138.67,45.47 138.67,45.35 138.6,45.28 138.6,45.17 138.78,44.99 148.93,44.99 150.95,42.97 174.72,42.97 178.83,38.86 179.6,38.09 179.6,37.92 178.81,37.12 178.81,37.01 179,36.82 179.11,36.82 179.93,37.64 180.05,37.64 180.17,37.52 180.17,37.4 179.35,36.58 179.35,36.46 179.47,36.34 179.59,36.34 180.41,37.16 180.53,37.16 180.65,37.04 180.65,36.93 179.83,36.11 179.83,35.99 179.97,35.84 180.09,35.84 180.44,36.2 180.56,36.2 180.67,36.08 180.67,35.96 180.32,35.61 180.32,35.49 181.14,34.67 181.14,30.48 181.77,29.85 181.77,29.32 v2(181.37,28.93)
  BOTTOM w0.076: v2(134.58,54.98) 133.9,55.65 133.9,58.97 134.02,59.08 134.02,59.94 134.14,60.06 134.14,60.31 133.85,60.6 UC1.AW29
  BOTTOM w0.102: JDIMM2.141 180.4,27.18 180.58,27.36 180.58,28.14 v2(181.37,28.93)
