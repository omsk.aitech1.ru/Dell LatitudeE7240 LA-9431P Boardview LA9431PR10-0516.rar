# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYSTEM_ID: length 6.2
  TOP w0.102: R386.2 24.5,4.47 24.5,5.18 24.56,5.24 24.56,5.94 24.49,6.02 24.49,7.12 24.65,7.29 C369.1 25.44,7.79 U38.A10
TAA_CLK32: length 9.5
  TOP w0.102: v2(177.77,79.96) v1(177.27,79.45) 174.51,79.45 v2(172.52,81.44)
  BOTTOM w0.102: v2(177.77,79.96) 178.3,79.44 R18.2 ; JTAA1.9 172.03,80.13 172.52,80.62 v2(172.52,81.44)
TAA_CLK64: length 10.6
  TOP w0.102: v2(177.15,79.98) 174.9,79.98 v1(173.76,81.13) 172.58,82.31 v2(172.58,82.71)
  BOTTOM w0.102: v2(172.58,82.71) 172.96,82.33 172.96,80.62 172.43,80.09 JTAA1.7 ; R13.2 177.41,79.73 v2(177.15,79.98)
TAA_CS0#_R: length 2.4
  BOTTOM w0.102: R10.2 171.8,81.44 171.8,80.89 171.63,80.72 JTAA1.11
TAA_CS1#_R: length 18.1
  IN2 w0.122: v2(169.55,81.5) 169.44,81.5 167.39,79.44 167.39,76.8 167.02,76.43 167.02,75.48 167.6,74.89 167.6,73.2 167.92,72.88 167.92,71.13 v2(167.12,70.33)
  BOTTOM w0.102: JTAA1.13 171.23,80.43 170.93,80.73 170.31,80.73 v2(169.55,81.5) ; v2(167.12,70.33) 166.92,70.13 v1(166.38,70.13) 165.89,69.63 R17.2
TAA_DIN32: length 6
  BOTTOM w0.102: R41.2 166.15,82.02 167.75,80.42 v1(168.48,80.42) 169.81,80.42 170.03,80.2 JTAA1.19
TAA_DIN64: length 6.8
  BOTTOM w0.102: JTAA1.17 170.43,80.24 169.66,81.01 167.81,81.01 166.79,82.03 v1(166.79,82.05) 165.93,82.92 R22.2
TAA_DO2_32: length 3.4
  BOTTOM w0.102: R59.1 170.51,74.18 v1(170.51,74.99) 170.83,74.99 171.23,75.39 JTAA1.14
TAA_DO2_64: length 3
  BOTTOM w0.102: JTAA1.12 171.63,75.84 171.8,75.67 v1(171.8,75.03) 171.8,74.28 R58.1
TAA_DO3_32: length 3
  BOTTOM w0.102: JTAA1.10 172.03,75.83 172.2,75.66 172.2,74.32 R48.1
TAA_DO3_64: length 3.2
  BOTTOM w0.102: R43.1 173.38,74.78 v1(173.15,75.01) 172.6,75.56 172.6,75.69 172.43,75.86 JTAA1.8
TAA_DO32: length 2.4
  BOTTOM w0.102: JTAA1.3 173.23,80.48 173.4,80.65 173.4,81.71 R12.2
TAA_DO64: length 3.3
  BOTTOM w0.102: R11.2 174.99,81.51 v1(174.99,80.8) 174.82,80.62 174.1,80.62 173.63,80.14 JTAA1.1
TDI_IREF: length 6.9
  BOTTOM w0.076: UC1.B12 143.81,82.52 143.7,82.62 143.7,84.09 143.24,84.55 v1(143.24,85.05) 143.24,85.55 143.24,85.56 143.24,85.57
  BOTTOM w0.102: 143.24,85.57 143.24,85.7 142.94,86 142.32,86 141.81,86.51 RC236.2
TDI_XDP: length 28.3
  TOP w0.102: RC96.2 59.15,63.13 JXDP1.56 63.64,63.13 64.05,63.54 v1(64.05,69.75) 64.05,70.48 68.53,74.97 v2(68.8,74.97)
  BOTTOM w0.102: RC103.1 73.46,70.26 72.69,71.03 70.86,71.03 68.62,73.27 68.62,74.79 v2(68.8,74.97)
TDI_XDP_R: length 7.2
  TOP w0.102: v1(78.5,71.6) 78.24,71.86 v2(77.97,71.86) 77.83,71.99 UC6.5
  BOTTOM w0.102: v2(77.97,71.86) 77.39,72.43 75.55,72.43 74.47,71.35 RC103.2 RC104.1
TDO_XDP: length 31.1
  TOP w0.102: RC280.2 58.65,62.84 59.27,62.84 59.98,62.13 JXDP1.52 63.29,62.13 64.62,63.46 64.62,70.41 68.54,74.33 71.83,74.33 v1(72.16,74) 72.16,73.74 73.91,71.98 v2(75.81,71.98) 76.33,72.51 UC6.2
  BOTTOM w0.102: v2(75.81,71.98) 76.44,71.35 RC95.2 RC123.1
THERMATRIP2#: length 7.2
  TOP w0.102: R402.2 31.89,19.91 31.38,19.41 30.4,19.41 29.58,18.58 U38.B34 ; R402.2 31.99,19.05 C371.1 ; R402.2 31.99,20.19 v1(32.8,21.01) 33.73,21.01 33.96,20.77 Q12.1
THERMATRIP3#: length 11.1
  TOP w0.102: U38.A2 21.44,8.81 21.27,8.65 21.13,8.65 20.63,8.15 v2(20.63,8.03) ; v2(18.06,6.88) 18.06,4.96 18.59,4.43 18.59,3.85 v1(18.91,3.53) 19.23,3.21 20.38,3.21 R364.2
  BOTTOM w0.102: v2(20.63,8.03) 20.59,7.99 20.59,7.47 20.01,6.88 v2(18.06,6.88)
THSEL_STRAP: length 11.7
  TOP w0.102: v2(28.41,15.63) 28.42,15.65 28.64,15.65 29.07,16.08 U38.B29 ; v1(36.49,14.66) 36.49,15.89 36.2,16.18 v2(35.85,16.18) 35.65,15.98 R383.1
  BOTTOM w0.102: v2(28.41,15.63) 28.42,15.65 29.72,15.65 30.02,15.34 31.04,15.34 31.23,15.53 33.83,15.53 34.28,15.98 35.65,15.98 v2(35.85,16.18)
TMDS_CLK#_C: length 3.4
  TOP w0.102: R466.1 194.44,96.18 194.44,95.66 v2(194.63,95.48)
  BOTTOM w0.102: L11.1 194.79,96.5 L10.4 194.79,96.14 194.63,95.99 v2(194.63,95.48) 194.81,95.3 C191.1
TMDS_CLK_C: length 3.4
  TOP w0.102: R464.1 194.23,96.23 194.23,95.66 v2(194.04,95.48)
  BOTTOM w0.102: L9.1 193.94,96.5 L10.1 193.94,96.06 194.11,95.88 194.11,95.54 v2(194.04,95.48) 193.85,95.29 C103.1
TMDS_N0_C: length 3.6
  TOP w0.102: R463.1 196.86,96.18 196.86,95.59 v2(196.96,95.48)
  BOTTOM w0.102: C209.1 197.28,95.16 v2(196.96,95.48) 196.96,95.67 197.2,95.9 L13.4 197.2,96.5 L14.1
TMDS_N1_C: length 3.4
  TOP w0.102: v2(192.28,95.48) 192.09,95.66 192.09,96.18 R469.1
  BOTTOM w0.102: L17.1 192.37,96.5 L16.4 192.37,96.06 192.2,95.89 192.2,95.55 v2(192.28,95.48) 192.28,94.97 C270.1
TMDS_N2_C: length 3.4
  TOP w0.102: v2(189.93,95.48) 189.74,95.66 189.74,96.25 R468.1
  BOTTOM w0.102: L20.1 190.02,96.5 L19.4 190.02,96.04 189.87,95.88 189.87,95.54 v2(189.93,95.48) 189.93,95.1 C272.1
TMDS_P0_C: length 3.6
  TOP w0.102: R462.1 196.64,96.23 196.64,95.74 v2(196.38,95.48)
  BOTTOM w0.102: C199.1 196.38,94.74 v2(196.38,95.48) 196.57,95.67 196.57,95.77 196.35,95.99 L13.1 196.35,96.5 L12.1
TMDS_P1_C: length 3.4
  TOP w0.102: v2(191.69,95.48) 191.88,95.66 191.88,96.23 R467.1
  BOTTOM w0.102: L15.1 191.52,96.5 L16.1 191.52,96.11 191.69,95.94 v2(191.69,95.48) 191.69,95.05 C269.1
TMDS_P2_C: length 3.5
  TOP w0.102: R465.1 189.22,96.54 189.53,96.24 189.53,95.66 v2(189.34,95.48)
  BOTTOM w0.102: L18.1 189.17,96.5 L19.1 189.17,96.03 189.34,95.86 v2(189.34,95.48) 189.51,95.32 189.51,95.14 C271.1
TMDSB_CON_CLK: length 7.4
  BOTTOM w0.102: JHDMI1.10 195.54,102.58 195.54,102.5 195.3,102.26 194.67,102.26 194.19,101.78 194.19,99.74 C273.1 194.09,99.15 194.19,99.05 194.19,98.61 193.94,98.36 L10.2 193.94,97.88 L9.2
TMDSB_CON_CLK#: length 7.4
  BOTTOM w0.102: JHDMI1.12 195.76,102.58 195.76,102.41 195.39,102.04 194.76,102.04 194.41,101.69 194.41,99.74 C274.1 194.51,99.15 194.41,99.05 194.41,98.66 194.79,98.28 L10.3 194.79,97.88 L11.2
TMDSB_CON_N0: length 15.6
  BOTTOM w0.089: 199.98,101.96 199.98,103.26
  BOTTOM w0.102: JHDMI1.9 194.65,103.88 194.83,103.71 195.31,103.71 195.53,103.64 195.73,103.64 196.18,103.76 196.58,103.62 196.78,103.62 197.01,103.72 197.21,103.72 197.74,103.59 198.01,103.72 198.23,103.72 198.57,103.64 198.76,103.64 198.94,103.72 199.23,103.72 199.6,103.63 199.98,103.26 ; L14.2 197.2,97.88 L13.3 197.2,98.56 197.13,98.63 196.79,98.63 196.72,98.7 196.72,99.06 196.81,99.15 C276.1 196.84,99.66 196.84,101.32 197.11,101.6 199.69,101.6 199.98,101.88 199.98,101.96
TMDSB_CON_N1: length 6.7
  BOTTOM w0.089: 193.09,102.91 JHDMI1.6
  BOTTOM w0.102: 193.09,102.91 192.74,102.56 192.74,102.29 192.2,101.75 192.2,101.27 191.99,101.06 191.99,99.74 C278.1 192.16,99.15 192.02,99.01 192.02,98.65 192.37,98.3 L16.3 192.37,97.88 L17.2
TMDSB_CON_N2: length 8.3
  BOTTOM w0.102: JHDMI1.3 191.5,104.17 189.67,102.35 189.67,99.71 C382.1 189.9,99.15 189.71,98.95 189.71,98.66 190.02,98.34 L19.3 190.02,97.88 L20.2
TMDSB_CON_P0: length 15.5
  BOTTOM w0.089: 199.76,103.17 199.76,101.98 199.74,101.96
  BOTTOM w0.102: 199.76,103.17 199.49,103.44 199.29,103.49 199.17,103.51 199.05,103.51 198.8,103.42 198.62,103.42 198.2,103.51 198.05,103.51 197.75,103.38 197.18,103.51 197.05,103.51 196.82,103.41 196.55,103.41 196.18,103.54 195.75,103.43 195.49,103.43 195.27,103.5 194.32,103.5 JHDMI1.7 ; 199.74,101.96 199.59,101.81 197.02,101.81 196.62,101.41 196.62,99.69 C275.1 196.51,98.72 196.51,98.64 196.35,98.48 L13.2 196.35,97.88 L12.2
TMDSB_CON_P1: length 6.8
  BOTTOM w0.102: JHDMI1.4 192.52,102.6 192.52,102.37 191.99,101.84 191.99,101.36 191.78,101.15 191.78,99.74 C277.1 191.68,99.15 191.81,99.02 191.81,98.61 191.52,98.33 L16.2 191.52,97.88 L15.2
TMDSB_CON_P2: length 8.1
  BOTTOM w0.102: JHDMI1.1 190.81,104.02 190.81,103.8 190,103 190,102.98 189.46,102.44 189.46,99.71 C279.1 189.36,99.15 189.49,99.02 189.49,98.61 189.17,98.29 L19.2 189.17,97.88 L18.2
TMS_XDP: length 30.1
  TOP w0.102: JXDP1.58 62.69,63.63 63.49,64.43 63.49,70.57 70.74,77.83 75.62,77.83 v1(76.14,78.35) 76.63,78.84 77.75,78.84 77.89,78.7 77.89,77.95 RC101.2 78.35,76.7 78.33,76.68 UC6.9
TOUCH_PANEL_INTR#: length 72.6
  TOP w0.102: RC181.2 122.42,105.79 RC180.1 121.29,105.79 v2(120.66,105.17) v1(120.21,104.72) 120.03,104.53 120.03,103.76 120.95,102.84 JLED1.6
  IN1 w0.084: v2(154.04,76.68) 152.97,76.68 152.71,76.95 151.61,76.95 151.28,77.28 151.28,78.14 150.98,78.44 150.98,81.86 148.95,83.9 146.84,83.9 145.48,82.54 140.55,82.54 139.96,83.14 138.31,83.14 137.52,83.93 136.29,83.93 135.19,82.84 132.76,82.84 132.54,83.06 132.54,83.91 132.26,84.19 131.13,84.19 130.05,85.27 v2(124.99,85.27)
  IN2 w0.089: 124.99,85.57 v2(124.99,85.27)
  IN2 w0.122: v2(120.66,105.17) 122.95,102.88 122.95,97.32 122.35,96.72 122.35,91.39 124.99,88.75 124.99,85.57
  BOTTOM w0.076: 153.85,76.68 153.66,76.68 153.15,76.17 153.15,76.1 152.19,75.14 151.15,75.14 151.14,75.12 151.14,75.12 150.94,74.93 150.94,74.69 150.8,74.55 150.33,74.55 150.08,74.81 UC1.P3
  BOTTOM w0.102: 153.85,76.68 v2(154.04,76.68)
TOUCH_RST_N_GYRO_INT1: length 7.8
  BOTTOM w0.076: 153.85,77.65 153.59,77.39 153.11,77.39 152.55,76.83 151.77,76.83 UC1.L1
  BOTTOM w0.102: RC202.2 157.84,77.05 v1(156.93,77.05) 156.87,77.05 156.25,77.67 153.87,77.67 153.85,77.65
TOUCH_SCREEN_PD#: length 3.9
  TOP w0.102: v2(16.31,37.22) 16.31,37.12 16.21,37.02 U37.B55
  BOTTOM w0.102: v2(16.31,37.22) 15.42,38.11 T98.1
TOUCHPAD_INTR#: length 18.1
  TOP w0.102: RC140.2 161.72,75.35 v2(162.04,75.67)
  IN3 w0.089: 153.85,74.89 150.97,74.89 150.67,74.59 148.01,74.59 147.51,74.09 v2(147.49,74.09)
  IN3 w0.122: v2(162.04,75.67) 162.04,75.05 160.44,73.46 158.66,73.46 157.86,74.27 155.42,74.27 154.8,74.89 153.89,74.89 153.89,74.89 153.85,74.89
  BOTTOM w0.076: v2(147.49,74.09) 147.34,73.93 UC1.U7
TP_CLK: length 20.1
  TOP w0.102: v2(191.99,7.56) 191.63,7.91 191.63,9.45 190.69,10.39 190.37,10.39 189.78,10.98 v5(189.78,12.42) C380.1 189.78,15.21 190.06,15.49 C378.1 ; C378.1 R449.2 ; C378.1 R444.2 190.04,17.27 R405.2 ; v2(195.89,6.88) 196.09,6.68 198.17,6.68 198.45,6.4 JKBTP1.3
  IN3 w0.122: v2(191.99,7.56) 192.1,7.44 195.33,7.44 v2(195.89,6.88)
TP_DATA: length 33.3
  TOP w0.102: JKBTP1.4 198.95,5.18 198.99,5.13 v2(199.01,5.13) ; v2(192.08,8.17) 192.25,7.99 193.33,7.99 193.78,8.43 193.78,12.9 C379.1 192.66,15.73 192.7,15.77 C377.1 193.11,16.9 193.21,16.9 R441.2 R404.2 193.88,18.47 193.88,19.75 193.59,20.04 v1(193.15,20.04) 192.94,20.25 192.94,21.46 192.51,21.89 189.38,21.89 189.17,21.68 R450.2
  IN3 w0.122: v2(199.01,5.13) 199.01,5.33 197.7,6.64 196.74,6.64 195.69,7.69 192.55,7.69 v2(192.08,8.17)
TP_DC_TEST_B2: length 11.4
  BOTTOM w0.102: UC1.B2 151.53,82.31 152.32,83.1 152.32,85.19 152.71,85.57 153.63,85.57 v1(154.57,86.51) 154.52,86.56 154.52,87.81 154.13,88.2 154.13,88.48 153.94,88.67 152.18,88.67 RC254.2
TP_LAN_JTAG_TCK: length 3.9
  TOP w0.102: v1(247.32,74.38) 246.89,74.82 R172.2 247.93,75.29 248.41,75.77 U21.35
TP_LAN_JTAG_TDI: length 1.7
  TOP w0.102: U21.32 247.86,76.97 T92.1
TP_LAN_JTAG_TDO: length 1.9
  TOP w0.102: U21.34 248.92,76.17 248.79,76.05 248.21,76.05 T93.1
TP_LAN_JTAG_TMS: length 2.8
  TOP w0.102: U21.33 248.48,76.57 v1(248.36,76.45) 247.1,76.45 R171.2
TP_NFC_RSVD1: length 2.9
  TOP w0.102: T89.1 253.96,7.38 JNFC1.13
TP_NFC_RSVD3: length 4.1
  TOP w0.102: JNFC1.10 252.46,8.16 R37.2 251.64,8.22 v1(251.5,8.08)
TP_NFC_RSVD4: length 2.6
  TOP w0.102: JNFC1.5 249.96,7.72 T88.1
TP_NFC_SWP_PWR_RSVD: length 4.1
  TOP w0.102: T87.1 249.46,8.76 JNFC1.4
TPM_ID0: length 10.1
  TOP w0.102: v2(149.65,79.66) 149.96,79.35 v1(150.74,79.35) 151.36,79.35 151.82,79.81 153.89,79.81 154.58,79.12 156.26,79.12 157.05,78.33 RC284.2
  BOTTOM w0.076: UC1.E4 149.32,79.94 149.6,79.66 v2(149.65,79.66)
TPM_ID1: length 5.5
  BOTTOM w0.076: UC1.C3 149.98,81.51 150.36,81.89 150.36,82.46 150.8,82.91 150.92,82.91 151.65,83.64 151.65,85.57
  BOTTOM w0.102: 151.65,85.57 151.65,85.58 RC285.2
TRIP_+V1.05SP: length 4
  TOP w0.102: v1(239.94,70.64) PR302.2
  TOP w0.254: PU300.2 239.06,73.58 239.42,73.21 239.42,71.82 239.57,71.67 PR302.2
TRST#_XDP: length 27.3
  TOP w0.102: UC6.12 76.83,76.61 76.1,77.34 74.52,77.34 v1(73.34,76.16) 71.74,74.56 68.45,74.56 64.38,70.49 64.38,63.54 63.47,62.63 JXDP1.54
UG_3V: length 4.6
  TOP w0.102: v3(199,51.09) 199.61,51.09 v1(200.03,51.51)
  IN1 w1.016: 199.97,55.24 199.01,54.28 199.01,52.27
  vias: v3(199,50.46) v3(199.36,56.16) v3(200.08,56.16)
UG_5V: length 10
  TOP w0.102: v1(193.36,51.68) 193.98,51.05 v3(194.03,51.05)
  IN1 w1.016: 193.01,51.19 189.85,54.36 189.85,56.04 187.82,58.08
  vias: v2(187.12,59.28) v2(187.12,58.65) v3(194.49,50.57)
UG_+V1.05SP: length 11.1
  TOP w0.102: v3(226.87,75.48) v1(225.97,75.48)
  IN1 w0.762: 226.77,74.04 226.77,72.91 228.84,70.84 233.12,70.84 234.44,72.16
  vias: v3(226.87,74.84) v3(234.39,73) v3(234.9,73.46)
UIM_CLK: length 194
  TOP w0.102: v1(260.16,4.57) 260.25,4.48 v2(261.76,4.48) 263.75,4.48 264.04,4.76 JSH1.4
  IN2 w0.122: v2(261.76,4.48) 260.89,3.61 251.49,3.61 248.06,7.04 248.06,12.85 248.75,13.54 248.75,20.04 249.48,20.78 249.48,22.79 249.18,23.09 249.18,28.45 252.87,32.13 262,32.13 262.55,32.69 264.52,32.69 266.03,34.19 266.03,69.39 264.26,71.16 254.32,71.16 250.63,74.84 245.17,74.84 243.94,76.07 240.44,76.07 237.06,79.45 236.5,79.45 235.4,80.55 223.17,80.55 219.39,76.77 219.39,74.92 217.04,72.57 213.19,72.57 211.81,71.19 208.83,71.19 208.7,71.05 207.31,71.05 206.19,69.93 206.19,68.65 205.82,68.28 205.82,66.5 206.57,65.75 206.57,63.74 207.19,63.12 207.19,47.94 207.38,47.74 207.38,45.7 208.14,44.95 JMINI2.12
UIM_DATA: length 197.8
  TOP w0.102: v2(264.85,7.02) 265.06,7.02 265.44,7.4 v1(265.71,7.4) 265.86,7.4 266.04,7.23 JSH1.8
  IN2 w0.122: v2(264.85,7.02) 263.5,5.67 250.76,5.67 249.43,7 249.43,12.13 249.13,12.43 249.13,19.86 249.86,20.59 249.86,22.95 249.56,23.25 249.56,28.29 253.02,31.76 262.15,31.76 262.71,32.31 264.68,32.31 266.41,34.04 266.41,38.58 267.73,39.9 267.73,41.56 266.4,42.88 266.4,69.54 264.41,71.54 259.33,71.54 258.76,72.11 256.75,72.11 253.64,75.22 245.33,75.22 244.1,76.45 241.53,76.45 240.74,77.24 240,77.24 237.44,79.81 237.44,80.06 236.58,80.92 223.02,80.92 221.65,79.55 218.94,79.55 217.46,78.08 214.35,78.08 212.69,76.42 212.69,72.6 211.65,71.56 209.55,71.56 209.04,72.07 207.72,72.07 205.16,69.51 205.16,68.45 205.45,68.16 205.45,66.35 206.2,65.6 206.2,63.58 206.8,62.98 206.8,47.8 207.01,47.59 207.01,45.36 208.22,44.15 JMINI2.10
UIM_RESET: length 196
  TOP w0.102: JSH1.6 265.04,4.52 v2(265.16,4.39) ; v1(207.02,46.02) 207.3,45.75 JMINI2.14
  IN2 w0.122: v2(265.16,4.39) 264,3.23 251.34,3.23 247.69,6.89 247.69,14.06 248.37,14.74 248.37,20.2 249.06,20.88 249.06,22.12 247.96,23.23 247.96,25.53 248.81,26.38 248.81,29.98 251.89,33.06 264.37,33.06 265.65,34.35 265.65,69.23 264.1,70.78 254.16,70.78 250.5,74.44 243.11,74.44 241.91,75.64 240.34,75.64 236.92,79.06 235.67,79.06 234.56,80.17 223.33,80.17 219.77,76.61 219.77,74.76 217.12,72.11 213.26,72.11 211.96,70.81 208.99,70.81 208.86,70.68 207.51,70.68 206.57,69.74 206.57,68.48 206.2,68.11 206.2,66.66 206.95,65.91 206.95,63.93 207.56,63.32 207.56,50.17 208.18,49.55 208.18,47.24 207.76,46.81 207.76,46.32 208.33,45.75 JMINI2.14
UIM_VPP: length 195.4
  TOP w0.102: v1(264.05,7.4) 264.05,7 264.45,6.59 265.21,6.59 265.53,6.27 JSH1.7 265.53,4.66 v2(265.8,4.39)
  IN2 w0.122: v2(265.8,4.39) 264.26,2.86 251.18,2.86 247.31,6.73 247.31,15.2 247.96,15.85 247.96,20.31 248.68,21.04 248.68,21.97 247.58,23.07 247.58,25.68 248.43,26.53 248.43,30.13 251.74,33.44 264.21,33.44 265.28,34.5 265.28,69.08 263.94,70.41 254.01,70.41 250.35,74.07 242.95,74.07 241.78,75.23 240.21,75.23 236.76,78.69 235.51,78.69 234.4,79.8 226.53,79.8 225.91,79.17 222.86,79.17 220.14,76.45 220.14,74.47 217.35,71.68 213.41,71.68 212.17,70.43 209.14,70.43 209.01,70.3 207.67,70.3 206.94,69.58 206.94,68.57 207.33,68.19 207.33,64.09 207.94,63.47 207.94,50.33 208.56,49.71 208.56,47.04 208.31,46.79 208.31,46.66 208.41,46.55 JMINI2.16
USB3RN1: length 158.4
  TOP w0.102: R484.1 265.85,85.9 L55.4 265.32,86.43 265.13,86.43 265.07,86.49 263.99,87.57 261.25,87.57 260.19,88.63 242.43,88.63 241.8,89.27 241.8,92.39 240.93,93.26 233.41,93.26 232.18,92.02 232.18,91.88 231.99,91.69 231.7,91.69 v2(231.55,91.85)
  IN4 w0.084: 139.95,85.01 139.95,84.99 139.95,84.99 139.95,83.02 140.92,82.05 140.92,79.8 140.66,79.54 140.07,79.54 139.74,79.21 v2(139.43,79.21)
  IN4 w0.091: v2(231.55,91.85) 231.18,91.48 229.56,91.48 227.17,89.09 219.57,89.09 217.86,87.38 214.81,87.38 211.41,83.98 211.12,83.98 210.64,83.5 210.64,82.84 206.94,79.13 204.89,79.13 202.33,76.57 192.17,76.57 191.12,77.63 188.72,77.63 188.54,77.8 188.54,85.88 187.15,87.27 185.86,87.27 184.62,86.03 174.92,86.03 174.64,85.76 166.6,85.76 165.61,86.75 160.87,86.75 159.91,87.71 156.68,87.71 155.62,86.65 152.67,86.65 152.12,86.09 140.92,86.09 139.95,85.13 139.95,85.01
  BOTTOM w0.076: UC1.G20 139.79,79.21 v2(139.43,79.21)
USB3RN1_D-: length 12.6
  TOP w0.102: R484.2 266.88,85.07 L55.3 267.07,84.68 267.07,84.23 267.39,83.91 267.39,83.54 267.13,83.29 267.13,83.22 267.14,83.21 267.14,82.54 267.13,82.52 267.13,82.21 267.26,82.08 267.47,82.08 D34.1 D34.9 269.18,80.37 269.18,80.16 v3(269.51,79.83) 269.8,79.55 269.8,78.59 270.18,78.21 271.67,78.21 272.17,78.71 272.53,78.71 272.97,79.15 JUSB3.5
USB3RN2: length 75.6
  TOP w0.102: v2(76.21,87.66) 76.4,87.85 76.4,88.03 76.08,88.35 L40.4 75.93,88.93 R246.1
  IN4 w0.084: v2(140.55,80.64) 140.28,80.37 140.18,80.37 140.09,80.45 140.09,80.73 138.71,82.12 129.51,82.12 128.33,83.29 128.33,85.45 128.21,85.57
  IN4 w0.091: 128.21,85.57 128.12,85.66 128.12,85.67 127.89,85.9 120.55,85.9 120.06,86.39 115.97,86.39 114.83,87.53 112.14,87.53 109.44,90.23 107.84,90.23 107.53,89.92 104.99,89.92 103.18,91.74 94.1,91.74 91.94,89.58 84.69,89.58 83.39,88.28 81.28,88.28 80.88,87.88 78.21,87.88 77.65,88.44 76.68,88.44 76.4,88.16 76.4,87.86 v2(76.21,87.66)
  BOTTOM w0.076: UC1.E18 140.99,80.2 v2(140.55,80.64)
USB3RN2_D-: length 17.1
  TOP w0.102: R246.2 76.08,90.18 L40.3 76.08,90.8 76.4,91.12 76.4,91.31 76.46,91.37 D17.1 D17.9 76.46,93.35 76.6,93.49 76.6,93.67 75.96,94.31 75.55,94.31 73.43,96.43 v3(73.43,97.05) 73.43,98.49 73.09,98.83 72.42,98.83 72.3,98.72 71.3,98.72 71.17,98.84 70.35,98.84 70.16,98.65 69.58,98.65 69.57,98.64 68.96,98.64 68.95,98.65 68.82,98.65 68.5,98.97 68.5,99.54 68.4,99.64 JUSB1.5
USB3RN3: length 54.2
  TOP w0.102: U33.5 164.34,105.67 164.71,106.03 164.71,106.16 164.61,106.26 v2(164.48,106.26)
  IN2 w0.089: v2(141.5,79.13) 141.45,79.18 141.45,79.32 141.58,79.45 141.88,79.45 142.1,79.67 142.1,80.72 144.02,82.64 144.02,83.77 143.55,84.23 143.55,85.52
  IN2 w0.132: v2(164.48,106.26) 164.48,106.56 164.58,106.67 164.58,106.85 164.51,106.92 163.62,106.92 163.34,106.65 160.07,106.65 159.02,105.6 159.02,99.98 158.23,99.19 154.25,99.19 151.99,101.45 145.34,101.45 143.4,99.51 143.4,92.2 142.95,91.74 142.95,86.95 143.55,86.34 143.55,85.52
  BOTTOM w0.076: UC1.G17 141.74,78.89 v2(141.5,79.13)
USB3RN3_D-: length 11.3
  TOP w0.102: R235.2 206.18,95.36 L37.3 206.81,95.36 207.08,95.09 v3(207.73,95.09) 208.08,95.09 208.77,95.78 209.03,95.78 209.15,95.91 D15.1 D15.9 211.14,95.91 211.25,95.8 211.45,95.8 211.91,96.25 211.91,96.42 211.9,96.43 211.9,97.01 211.91,97.03 211.91,98.58 211.62,98.87 211.62,99.57 211.54,99.64 JUSB2.5
USB3RP1: length 158.2
  TOP w0.102: v2(231.55,91.26) 231.76,91.48 232.08,91.48 232.4,91.8 232.4,91.93 233.5,93.04 240.84,93.04 241.58,92.3 241.58,89.18 242.34,88.42 260.1,88.42 261.16,87.35 263.9,87.35 264.22,87.03 264.85,86.4 264.85,85.69 L55.1 265.25,85.29 R485.1
  IN4 w0.084: v2(139.61,78.65) 139.61,78.85 140.14,79.37 140.73,79.37 141.08,79.73 141.08,82.12 140.12,83.09 140.12,84.99 140.12,85 140.12,85.01
  IN4 w0.091: 140.12,85.01 140.12,85.06 140.99,85.92 152.19,85.92 152.74,86.47 155.69,86.47 156.75,87.53 159.84,87.53 160.8,86.57 165.53,86.57 166.52,85.58 174.71,85.58 174.99,85.86 184.69,85.86 185.93,87.1 187.08,87.1 188.37,85.81 188.37,77.73 188.65,77.45 191.05,77.45 192.1,76.4 202.4,76.4 204.96,78.96 207.01,78.96 210.82,82.77 210.82,83.43 211.19,83.81 211.48,83.81 214.88,87.21 217.94,87.21 219.64,88.92 227.24,88.92 229.63,91.31 231.5,91.31 v2(231.55,91.26)
  BOTTOM w0.076: v2(139.61,78.65) 139.69,78.65 UC1.H20
USB3RP1_D+: length 12.5
  TOP w0.102: 265.9,84.44 266.1,84.44 L55.2 266.45,84.09 266.9,84.09 267.17,83.82 267.17,83.63 266.92,83.38 v3(266.92,82.91) 266.92,82.12 267.13,81.9 267.13,81.71 D34.2 D34.8 268.83,80.01 269.03,80.01 269.15,79.89 269.15,79.87 269.58,79.44 269.58,78.5 270.09,77.99 270.36,77.99 270.37,77.98 270.99,77.98 271.01,77.99 271.76,77.99 272.26,78.5 272.55,78.5 272.97,78.08 272.97,77.76 JUSB3.6
USB3RP2: length 75.3
  TOP w0.102: v2(76.8,87.66) 76.61,87.85 76.61,88.03 76.93,88.35 L40.1 77.08,88.93 R247.1
  IN4 w0.084: 128.09,85.45 128.1,85.44 128.11,85.44 128.17,85.38 128.17,83.22 129.44,81.95 138.64,81.95 139.93,80.66 139.93,80.38 140.11,80.2 140.31,80.2 v2(140.53,79.98)
  IN4 w0.091: v2(76.8,87.66) 76.58,87.89 76.58,88.09 76.75,88.27 77.58,88.27 78.14,87.71 80.95,87.71 81.35,88.1 83.46,88.1 84.76,89.41 92.02,89.41 94.17,91.57 103.11,91.57 104.92,89.75 107.6,89.75 107.91,90.06 109.36,90.06 112.06,87.36 114.76,87.36 115.9,86.21 119.99,86.21 120.48,85.72 127.82,85.72 127.95,85.59 127.95,85.59 128.09,85.45
  BOTTOM w0.076: v2(140.53,79.98) 140.96,79.55 UC1.F18
USB3RP2_D+: length 17.4
  TOP w0.102: JUSB1.6 68.82,99.64 68.72,99.54 68.72,99.06 68.91,98.87 70.07,98.87 70.26,99.06 71.26,99.06 71.39,98.93 72.21,98.93 72.33,99.05 72.44,99.05 72.45,99.06 73.05,99.06 73.06,99.05 73.18,99.05 73.65,98.58 73.65,97.42 73.67,97.4 73.67,96.75 73.65,96.72 73.65,96.52 75.64,94.53 76.09,94.53 v3(76.49,94.12) 76.82,93.8 76.82,93.52 76.96,93.37 D17.8 D17.2 76.96,91.57 76.61,91.22 76.61,91.12 76.93,90.8 L40.2 76.93,90.18 R247.2
USB3RP3: length 54.5
  TOP w0.102: v2(164.99,106.55) 164.99,105.98 164.74,105.74 U33.4
  IN2 w0.089: v2(141.5,79.96) 141.48,79.93 141.48,79.84 141.67,79.65 141.8,79.65 141.9,79.75 141.9,80.81 143.82,82.72 143.82,83.68 143.35,84.15 143.35,85.41 143.33,85.43 143.33,85.49 143.31,85.51 143.31,85.52
  IN2 w0.132: v2(164.99,106.55) 164.99,106.8 164.61,107.17 163.51,107.17 163.24,106.9 159.96,106.9 158.77,105.7 158.77,100.09 158.12,99.44 154.35,99.44 152.09,101.69 145.24,101.69 143.16,99.61 143.16,92.3 142.7,91.84 142.7,86.84 143.31,86.24 143.31,85.52
  BOTTOM w0.076: UC1.F17 141.87,79.55 141.5,79.91 v2(141.5,79.96)
USB3RP3_D+: length 11.3
  TOP w0.102: R236.2 206.09,94.56 L37.2 206.59,94.56 206.9,94.88 207.45,94.88 207.46,94.86 208.01,94.86 208.02,94.88 208.17,94.88 208.86,95.56 208.97,95.56 209.13,95.41 D15.2 D15.8 211.08,95.41 211.25,95.58 211.54,95.58 212.13,96.16 v3(212.13,96.71) 212.13,98.67 211.83,98.96 211.83,99.39 212.09,99.64 JUSB2.6
USB3TN1: length 161.9
  TOP w0.102: v2(232.99,91.85) 233.07,91.77 233.38,91.77 233.5,91.89 233.5,92.21 233.85,92.56 240.43,92.56 240.84,92.14 240.84,89.03 241.96,87.91 259.85,87.91 261.16,86.6 261.85,86.6 262.29,86.16 C448.2
  IN4 w0.084: v2(130,84.33) 130.01,84.33 132.22,84.33 132.6,84.7 135.91,84.7 136.94,85.73 138.29,85.73 139.7,87.15 140.68,87.15 141.04,86.79 151.84,86.79 152.86,87.81 155.81,87.81 156.39,88.39 160.19,88.39 160.82,87.76 165.55,87.76 166.75,86.56 174.43,86.56 174.58,86.71 181.28,86.71 183.63,89.07 187.82,89.07 190.56,86.33 190.56,79.27 192.57,77.25 202.05,77.25 204.63,79.83 206.67,79.83 209.96,83.12 209.96,84.98 210.69,85.71 212.09,85.71 216.16,89.78 224.41,89.78 227.39,92.76 231.62,92.76 232.53,91.85 v2(232.99,91.85)
  BOTTOM w0.076: 130.95,83.16 130.95,83.15 130.93,83.12 130.93,83.08 130.92,83.07 130.92,82.72 131.13,82.51 131.13,82.1 131.55,81.69 UC1.C33
  BOTTOM w0.102: v2(130,84.33) 130.22,84.11 130.4,84.11 130.95,83.56 130.95,83.16
USB3TN1_D-: length 15.6
  TOP w0.102: R486.2 265.4,83.59 L56.3 265.62,83.16 265.62,82.63 265.98,82.27 265.98,82.21 265.99,82.19 265.99,81.57 265.98,81.56 265.98,81.45 D34.4 D34.7 268.12,79.3 268.12,79.1 268.85,78.38 v3(268.85,76.75) 268.85,75.92 270.94,73.82 271.39,73.82 272.34,72.87 272.85,72.87 272.97,72.99 JUSB3.8
USB3TN1_RP_C: length 2
  TOP w0.102: C448.1 263.29,85.04 263.41,84.93 263.85,84.93 L56.4 264.37,84.41 R486.1
USB3TN2: length 65.4
  TOP w0.102: C292.2 78.38,86.22 78.38,86.04 78.63,85.8 80.1,85.8 80.44,86.14 80.44,86.47 80.47,86.5 80.47,87.12 80.44,87.15 80.44,88.32 v2(80.54,88.42)
  IN4 w0.091: v2(131.98,83.11) 131.78,83.31 131.5,83.31 131.3,83.11 129.81,83.11 128.96,83.96 128.96,85.75 128.19,86.52 121.49,86.52 121.15,86.86 116.95,86.86 115.82,88 115.28,88 114.8,88.48 114.8,88.94 113.48,90.26 111.18,90.26 110.14,91.3 108.55,91.3 107.5,92.36 93.69,92.36 91.43,90.11 84.53,90.11 83.66,89.23 80.62,89.23 80.29,88.91 80.29,88.66 v2(80.54,88.42)
  BOTTOM w0.076: v2(131.98,83.11) 132,83.09 132,82.85 131.55,82.4 UC1.B33
USB3TN2_C: length 2.1
  TOP w0.102: R248.1 78.14,88.94 L41.4 78.14,88.25 78.47,87.92 78.47,87.81 C292.1
USB3TN2_D-: length 13.8
  TOP w0.102: R248.2 78.14,90.21 L41.3 78.14,90.89 78.35,91.1 78.35,91.19 78.11,91.43 78.11,91.58 77.96,91.74 D17.4 D17.7 77.96,93.41 78.09,93.55 78.09,94.02 78.08,94.03 78.08,94.65 78.09,94.66 77.47,95.29 v3(77.11,95.29) 75.63,95.29 74.16,96.76 74.16,98.83 74.6,99.28 74.6,99.58 74.54,99.64 JUSB1.8
USB3TN3: length 71.5
  TOP w0.102: U33.2 165.54,105.68 165.64,105.77 165.64,105.97 166.95,107.29 167.75,107.29 v2(168.01,107.54)
  IN1 w0.091: v2(153.26,108.94) 153.47,109.15 153.47,109.68 153.66,109.87 158.35,109.87 161.06,107.16 164.46,107.16 164.61,107.31 167.78,107.31 168.01,107.54 v2(168.01,107.54)
  IN2 w0.132: v2(153.26,108.94) 153.47,109.15 153.47,109.23 153.24,109.46 152.26,109.46 150.76,107.96 146.43,107.96 144.92,106.45 144.92,104.19 142.41,101.68 131.38,101.68 130.45,100.75 130.45,96.82 129.48,95.85 129.48,86.44 130.63,85.3 v2(131.78,85.3)
  BOTTOM w0.076: v2(131.78,85.3) 131.78,85.18 131.89,85.08 132.24,85.08 132.45,84.87 132.45,84.24 132.61,84.07 132.61,82.8 132.69,82.57 132.69,82.4 132.67,82.32 132.66,82.31 132.63,82.25 132.63,82.12 132.66,82.01 132.87,81.81 133.05,81.81 133.22,81.63 UC1.C30
USB3TN3_D-: length 16.2
  TOP w0.102: R237.2 206.06,93.31 206.66,93.31 206.98,93 207.26,93 208.52,94.26 208.79,94.26 208.94,94.41 D15.4 D15.7 211.19,94.41 211.33,94.26 212.07,94.26 212.68,94.87 212.68,95.24 v3(213.06,95.62) 214.31,96.88 214.55,96.88 214.57,96.89 215.18,96.89 215.19,96.88 215.65,96.88 216.43,97.66 216.43,98.31 217.49,99.37 217.49,99.54 217.39,99.64 JUSB2.8
USB3TP1: length 161.8
  TOP w0.102: C449.2 262.24,85.76 262.24,85.89 261.76,86.37 261.06,86.37 259.75,87.68 241.87,87.68 240.61,88.93 240.61,92.05 240.34,92.33 233.95,92.33 233.73,92.11 233.73,91.8 233.48,91.54 233.27,91.54 v2(232.99,91.26)
  IN4 w0.084: v2(232.99,91.26) 232.62,91.64 232.45,91.64 231.54,92.55 227.48,92.55 224.5,89.56 216.25,89.56 212.18,85.5 210.78,85.5 210.17,84.89 210.17,83.03 206.76,79.62 204.72,79.62 202.14,77.04 192.48,77.04 190.35,79.18 190.35,86.24 187.73,88.86 183.72,88.86 181.37,86.5 174.66,86.5 174.52,86.35 166.66,86.35 165.47,87.55 160.73,87.55 160.11,88.17 156.48,88.17 155.9,87.6 152.95,87.6 151.93,86.58 140.95,86.58 140.59,86.94 139.79,86.94 138.37,85.52 137.03,85.52 136,84.49 132.68,84.49 132.31,84.12 130.43,84.12 v2(130,83.69)
  BOTTOM w0.076: UC1.B34 130.81,81.84 130.76,81.89 130.76,82.07 130.94,82.25 130.94,82.43 130.74,82.63 130.74,83.16
  BOTTOM w0.102: v2(130,83.69) 130,83.73 130.17,83.9 130.31,83.9 130.74,83.47 130.74,83.16
USB3TP1_D+: length 15.8
  TOP w0.102: R487.2 264.59,82.78 L56.2 264.93,82.65 265.29,82.65 265.76,82.18 v3(265.76,81.89) 265.76,81.36 265.9,81.22 266.12,81 266.12,80.6 D34.5 266.48,80.24 D34.6 267.77,78.95 267.97,78.95 268.63,78.29 268.63,77.06 268.62,77.05 268.62,76.47 268.63,76.45 268.63,75.83 270.85,73.61 271.3,73.61 272.25,72.66 272.87,72.66 272.97,72.55 JUSB3.9
USB3TP1_RP_C: length 2
  TOP w0.102: C449.1 263.14,84.89 263.25,84.77 263.25,84.33 L56.1 263.77,83.81 R487.1
USB3TP2: length 65.5
  TOP w0.102: C293.2 78.84,86.72 78.66,86.72 78.6,86.65 78.6,86.13 78.72,86.02 80.01,86.02 80.23,86.23 v3(80.23,86.79) 80.23,88.14 v2(79.95,88.42)
  IN4 w0.091: v2(131.98,83.69) 131.77,83.48 131.42,83.48 131.23,83.29 129.88,83.29 129.14,84.03 129.14,85.82 128.26,86.69 121.56,86.69 121.22,87.03 117.02,87.03 115.89,88.17 115.35,88.17 114.97,88.55 114.97,89.01 113.55,90.44 111.26,90.44 110.21,91.48 108.62,91.48 107.57,92.53 93.61,92.53 91.36,90.28 84.46,90.28 83.59,89.41 80.54,89.41 80.12,88.98 80.12,88.58 v2(79.95,88.42)
  BOTTOM w0.076: UC1.A33 131.55,83.34 131.9,83.69 v2(131.98,83.69)
USB3TP2_C: length 2
  TOP w0.102: R250.1 78.99,88.93 L41.1 78.99,88.18 78.7,87.9 78.7,87.77 C293.1
USB3TP2_D+: length 13.8
  TOP w0.102: R250.2 78.99,90.21 L41.2 78.99,90.67 78.6,91.06 78.6,91.25 78.33,91.52 78.33,91.59 78.46,91.72 D17.5 D17.6 78.46,93.4 78.31,93.55 v3(78.31,94.39) 78.31,94.75 77.56,95.5 77.5,95.5 77.48,95.52 76.84,95.52 76.82,95.5 75.72,95.5 74.37,96.85 74.37,98.74 74.82,99.19 74.82,99.57 74.89,99.64 JUSB1.9
USB3TP3: length 71.2
  TOP w0.102: v2(168.01,106.91) 167.84,107.07 167.04,107.07 165.85,105.88 165.85,105.82 165.94,105.72 U33.1
  IN1 w0.091: v2(153.85,108.94) 153.64,109.15 153.64,109.61 153.73,109.7 158.28,109.7 160.99,106.99 164.53,106.99 164.68,107.14 167.78,107.14 v2(168.01,106.91)
  IN2 w0.132: v2(153.85,108.94) 153.72,109.06 153.72,109.32 153.34,109.7 152.15,109.7 150.65,108.2 146.33,108.2 144.67,106.55 144.67,104.29 142.3,101.92 131.28,101.92 130.21,100.85 130.21,96.93 129.24,95.95 129.24,86.34 130.52,85.05 131.44,85.05 v2(131.78,84.72)
  BOTTOM w0.076: UC1.C31 132.61,81.79 132.51,81.94 132.47,82.09 132.47,82.28 132.48,82.31 132.53,82.43 132.53,82.54 132.47,82.71 132.45,82.77 132.45,83.97 132.26,84.16 132.26,84.79 132.17,84.89 131.95,84.89 v2(131.78,84.72)
USB3TP3_D+: length 16.6
  TOP w0.102: JUSB2.9 217.81,99.64 217.71,99.54 217.71,99.28 216.65,98.22 216.65,97.57 215.74,96.66 v3(214.87,96.66) 214.4,96.66 213.44,95.69 213.44,95.67 213.01,95.24 212.99,95.24 212.9,95.15 212.9,94.78 212.16,94.05 211.33,94.05 211.19,93.91 D15.6 D15.5 208.92,93.91 208.79,94.04 208.61,94.04 208.27,93.7 208.27,93.68 207.84,93.26 207.82,93.26 207.35,92.78 206.98,92.78 206.66,92.46 L38.2 206.09,92.46 R239.2
USB_OC0#: length 125.1
  TOP w0.102: v2(91.66,96.8) 91.92,96.8 v1(95.8,100.68) 96.2,101.08 96.2,104.51 96.47,104.77 U35.5
  IN1 w0.084: v2(154.39,66.25) 154.39,66.36 153.72,67.03 151.63,67.03 149.85,68.81 146.69,68.81 145.73,69.76 144.72,69.76 144.37,70.1 143.15,70.1 141.91,71.35 138.93,71.35 138.14,70.56 137.35,70.56 136.56,69.77 135.72,69.77 135.35,70.14 118.16,70.14 117.78,70.52 116.83,70.52 116.45,70.9 116.13,70.9 115.68,71.35 113.32,71.35 112.46,72.21 111.79,72.21 111.57,72.43 109.05,72.43 108.81,72.67 108.81,73.38 107.22,74.97 94.99,74.97 91.62,78.34 89.6,78.34 88.66,79.29 83.16,79.29 81.94,80.5 v2(80.77,80.5)
  IN3 w0.122: v2(156.29,67.03) 155.62,67.03 154.84,66.25 v2(154.39,66.25)
  BOTTOM w0.076: UC1.AL3 150.23,65.56 150.75,65.56 150.98,65.8 150.98,65.97 151.15,66.14 152.16,66.14 153.11,65.2
  BOTTOM w0.102: v2(156.29,67.03) 156.29,67.31 156.82,67.84 157.65,67.84 158.12,67.38 RP5.7 ; 153.11,65.2 153.75,65.2 154.28,65.73 154.28,66.14 v2(154.39,66.25) ; v2(80.77,80.5) 81.03,80.76 81.03,82.61 80.89,82.75 80.89,86.15 85.33,90.59 86.42,90.59 88.44,92.61 88.44,93.36 91.66,96.57 v2(91.66,96.8)
USB_OC1#: length 120.6
  TOP w0.102: U52.5 236.16,82.03 237.53,83.41 238.28,84.15 v1(238.28,84.53) 238.28,86.13 v2(238.73,86.59) ; v2(153.37,61.32) 154.27,60.41 154.27,59.38 155.1,58.55 155.75,58.55 156.46,57.84 156.46,54.98 156.74,54.7 RC166.1
  IN3 w0.122: v2(238.73,86.59) 238.65,86.5 233.52,86.5 233.33,86.69 229.79,86.69 227.98,84.88 220.39,84.88 219.91,84.4 211.94,84.4 211.75,84.21 209.5,84.21 207.99,82.69 207.4,82.69 202.73,78.02 202.18,78.02 201.38,77.22 200.43,77.22 198.86,75.64 198.86,74.72 198.49,74.35 192.51,74.35 191.36,73.2 190.17,73.2 188.57,71.6 185.31,71.6 184.83,71.12 180.98,71.12 179.9,70.03 176.49,70.03 173.94,67.48 171.15,67.48 168.99,65.32 168.99,64.83 168.46,64.3 167.95,64.3 166.18,62.53 165.58,62.53 165.39,62.71 164.85,62.71 163.81,61.68 162.41,61.68 161.25,60.53 161.25,60.02 160.25,59.01 159.74,59.01 159.15,58.42 157.08,58.42 154.19,61.32 v2(153.37,61.32)
  BOTTOM w0.076: UC1.AT1 151.44,62.65 152.13,62.65 152.4,62.38 152.4,61.83 152.36,61.79 152.36,61.2 152.62,60.95 153,60.95 v2(153.37,61.32)
USB_OC2#: length 94.6
  IN3 w0.089: 153.85,68.91 153.19,68.91 v2(152.39,68.11)
  IN3 w0.122: v2(227.79,87.84) 227.79,87.78 227.17,87.17 218.24,87.17 218.16,87.08 205.95,87.08 205.3,86.43 202.93,86.43 200.69,84.19 200.69,83.21 199.98,82.5 199.98,79.39 197.39,76.81 193.53,76.81 190.92,74.19 189.76,74.19 189,73.43 185.38,73.43 184.68,72.74 177.09,72.74 176.43,72.08 173.41,72.08 172.56,71.23 169.25,71.23 168.83,70.81 165.68,70.81 165.05,70.18 163.87,70.18 162.74,71.31 162.24,71.31 161.94,71.01 160.99,71.01 160.72,70.74 158.88,70.74 157.37,69.23 v2(157.37,68.34) 156.24,68.34 155.66,68.91 153.85,68.91
  BOTTOM w0.076: UC1.AH2 150.63,67.35 151.08,67.81 151.63,67.81 151.66,67.78 152.06,67.78 v2(152.39,68.11)
  BOTTOM w0.102: v2(157.37,68.34) 157.99,68.34 158.45,67.88 RP5.8 ; v2(227.79,87.84) 227.79,87.64 226.53,86.38 U32.5
USB_OC3#: length 9.9
  TOP w0.102: v1(152.78,60.36) 152.78,59.21 v2(152.86,59.13) 153.34,59.13 154.78,57.7 154.78,57.23 154.99,57.01 RP10.7
  BOTTOM w0.076: 151.46,61.17 151.14,61.17 151.13,61.18 150.48,61.18 150.15,61.51 UC1.AV3
  BOTTOM w0.102: 151.46,61.17 151.69,60.93 151.69,59.47 152.03,59.13 v2(152.86,59.13)
USB_PWR_SHR_EN#: length 94.9
  TOP w0.102: v2(14.85,26.97) 15.04,27.16 R287.2 ; R242.1 51.84,73.23 v1(53.75,71.32) 54.02,71.05 v2(54.02,70.21) ; U37.B10 20.68,30.14 20.88,30.34 20.88,30.7 20.24,31.33 v2(20.24,31.6)
  IN4 w0.084: v2(20.24,31.6) 19.89,31.95 16,31.95 15.7,32.26 15.7,38.22 16.54,39.06 24.78,39.06 25.76,40.04 27.51,40.04 29.94,42.47 31.67,42.47 32.06,42.87 34.36,42.87 34.88,43.39 38.55,43.39 40.7,45.53 47.72,45.53 49.04,46.85 50.13,46.85 54.7,51.42 54.7,55.23 55.46,55.99 55.46,64.87 54.07,66.26 54.07,70.15 v2(54.02,70.21) ; v2(20.64,27.16) 20.53,27.04 18.05,27.04 17.61,26.6 15.22,26.6 v2(14.85,26.97)
  BOTTOM w0.102: v2(20.24,31.6) 19.95,31.3 19.95,27.77 20.56,27.16 v2(20.64,27.16)
USB_PWR_SHR_VBUS_EN: length 81.5
  TOP w0.102: U37.B50 16.68,38.65 v2(16.88,38.46) ; R241.1 54.8,74.08 55.47,74.75 v2(58.27,74.75) 57.75,75.27 v1(57.75,75.77)
  IN3 w0.122: v2(58.27,74.75) 57.5,73.98 57.5,71.04 57.09,70.64 57.09,66.24 55.33,64.48 55.33,50.69 55.77,50.25 55.77,49.48 54.79,48.5 54.31,48.5 54.13,48.68 53.04,48.68 52.34,47.98 48.59,47.98 48.17,48.4 37.63,48.4 34.28,45.04 32.26,45.04 30.71,43.5 30.21,43.5 27.35,40.64 25.56,40.64 24.48,39.56 20.6,39.56 20.16,39.12 18.36,39.12 18.19,38.95 17.37,38.95 v2(16.88,38.46)
  BOTTOM w0.102: R291.2 16.23,41.54 17.17,40.6 17.17,38.75 v2(16.88,38.46)
USB_SIDE_EN#: length 311
  TOP w0.102: U52.4 v1(225.65,82.03) 224.01,82.03 223.01,81.04 v2(223.01,78.71) ; R288.2 23.99,41.5 24.18,41.31 v2(24.18,41.06) 24.18,40.55 23.93,40.3 U37.A33
  IN3 w0.122: v2(131.81,18.02) 132.13,18.02 132.51,17.64 133.15,17.64 134.03,16.76 134.51,16.76 135.18,17.43 139.54,17.43 139.75,17.64 178.09,17.64 178.46,18.02 188.57,18.02 192.3,14.29 194.1,14.29 194.94,15.13 199.41,15.13 199.87,15.6 202.95,15.6 204.26,16.91 204.26,20.68 205.84,22.26 205.84,26.61 201.77,30.69 201.77,35.55 202.74,36.52 202.74,37.18 203.03,37.46 203.73,37.46 205.32,39.05 205.32,39.98 207.01,41.67 207.01,47.33 206.49,47.85 206.49,50.9 205.37,52.02 205.37,56.04 204.69,56.72 204.69,62.29 205.26,62.86 205.26,63.14 205.46,63.33 205.46,68.22 205.07,68.61 205.07,69.32 204.24,70.15 204.24,70.53 204.93,71.22 207.25,71.22 208.1,72.07 208.66,72.07 209.73,73.14 209.73,73.85 214.59,78.71 218.86,78.71 219.44,78.12 222.42,78.12 v2(223.01,78.71)
  BOTTOM w0.102: v2(131.81,18.02) 132.01,18.22 132.01,24.71 132.56,25.26 132.56,30.28 131.83,31.01 131.83,38.09 124.84,45.08 67.55,45.08 66.85,45.78 58.75,45.78 57.66,46.88 53.51,46.88 52.39,47.99 52.39,49.25 51.71,49.94 49.87,49.94 48.76,51.04 47.55,51.04 46.4,52.19 39.34,52.19 33.08,45.94 31.43,45.94 29.3,43.8 25.06,43.8 24.18,42.92 v2(24.18,41.06)
USBP0+: length 149
  TOP w0.102: U36.8 77.77,81.31 77.55,81.09 76.35,81.09 74.63,79.37 70.61,79.37 69.84,80.15 67.97,80.15 67.59,79.77 67.59,79.26 67.3,78.97 66.93,78.97 v2(66.88,78.92)
  IN2 w0.089: v2(146.51,64.89) 146.86,64.54 146.86,63.94 146.55,63.64 146.26,63.64 146.16,63.54 145.72,63.54 145.09,62.9 145.09,62.39 144.84,62.15 143.74,62.15 143.62,62.27 142.61,62.27 141.61,61.26 141.61,52.79 141.23,52.41 140.72,52.41 139.74,51.43 139.71,51.43 139.69,51.41
  IN2 w0.132: v2(66.88,78.92) 67.05,78.74 67.05,78.63 66.87,78.44 64.55,78.44 62.48,76.37 62.48,75.39 60.83,73.74 60.83,69.29 59.85,68.31 59.85,65.18 57.56,62.9 57.56,59.97 57.23,59.64 57.23,56.2 58.02,55.41 58.02,53.47 59.03,52.46 60.16,52.46 63.88,48.75 68.54,48.75 69.3,49.51 74.63,49.51 75.02,49.9 114.4,49.9 115.19,50.69 138.97,50.69 139.69,51.41
  BOTTOM w0.076: UC1.AM8 146.79,64.89 v2(146.51,64.89)
USBP0-: length 148.7
  TOP w0.102: U36.7 77.27,81.76 77.33,81.7 77.43,81.7 77.56,81.57 77.56,81.4 77.46,81.3 76.26,81.3 74.54,79.59 70.7,79.59 69.93,80.36 67.88,80.36 67.37,79.86 67.37,79.35 67.28,79.26 67.1,79.26 66.85,79.5 v2(66.85,79.54)
  IN2 w0.089: 139.51,51.58 139.52,51.59 139.55,51.59 139.59,51.63 139.66,51.63 140.64,52.62 141.15,52.62 141.4,52.87 141.4,61.35 142.52,62.47 143.71,62.47 143.82,62.36 144.76,62.36 144.88,62.48 144.88,62.99 145.64,63.74 146.08,63.74 146.18,63.84 146.47,63.84 146.59,63.96 146.59,64.06 v2(146.48,64.17)
  IN2 w0.132: v2(66.85,79.54) 67.12,79.54 67.3,79.36 67.3,78.52 66.97,78.2 64.65,78.2 62.73,76.27 62.73,75.29 61.07,73.63 61.07,69.19 60.09,68.21 60.09,65.08 57.81,62.8 57.81,59.87 57.48,59.54 57.48,56.3 58.27,55.52 58.27,53.57 59.13,52.7 60.27,52.7 63.98,48.99 68.44,48.99 69.2,49.75 74.53,49.75 74.92,50.14 114.29,50.14 115.09,50.94 138.87,50.94 139.51,51.58
  BOTTOM w0.076: UC1.AN8 146.97,64.55 146.91,64.62 146.77,64.62 146.67,64.52 146.48,64.52 146.41,64.44 146.41,64.25 v2(146.48,64.17)
USBP0_D+: length 11.2
  TOP w0.102: R249.2 73.11,90.06 L42.3 73.11,90.75 73.39,91.03 73.67,91.03 73.75,91.12 73.75,91.38 73.58,91.54 73.14,91.54 73,91.68 D18.2 73.76,92.4 73.86,92.51 73.86,93.06 71.59,95.32 v3(71.59,95.67) 71.59,96.72 71.58,96.74 71.58,97.27 JUSB1.3
USBP0_D-: length 11.2
  TOP w0.102: R251.2 74.31,90.06 L42.2 74.31,90.78 73.97,91.12 73.97,91.33 74.12,91.48 74.85,91.48 74.93,91.55 D18.3 74.17,92.4 74.07,92.51 74.07,93.15 71.82,95.4 71.82,95.93 71.81,95.95 v3(71.81,97) 71.81,97.25 JUSB1.2
USBP1+: length 141
  TOP w0.102: R482.1 265.01,76.56 L54.1 265.01,75.84 264.7,75.52 264.7,74.93 264.19,74.42 264.19,73.77 264.34,73.62 v2(264.34,73.62)
  IN1 w0.084: v2(147.98,63.16) 148.24,62.9 149.15,62.9 149.47,62.59 150.52,62.59 151.16,63.22 153.64,63.22 153.85,63.43
  IN1 w0.091: 153.85,63.43 156.49,66.07 160.12,66.07 162.73,63.46 162.73,61.89 163.41,61.21 165.58,61.21 165.87,60.91 166.95,60.91 169.29,63.25 169.29,64.49 169.39,64.59 169.39,64.91 171.15,66.67 176.03,66.67 176.53,66.16 190.63,66.16 191.49,67.02 195.49,67.02 196.01,67.54 199.9,67.54 200.12,67.31 203.72,67.31 204.45,68.05 205.73,68.05 206.36,68.68 206.36,69.16 207.31,70.11 207.31,71.52 211.3,75.51 211.3,75.9 215.48,80.09 223.98,80.09 225.07,81.17 234.75,81.17 235.16,80.77 237.2,80.77 242.77,75.2 243.63,75.2 v2(243.79,75.04)
  IN4 w0.091: v2(264.34,73.62) 264.19,73.47 264.19,73.08 263.45,72.34 259.78,72.34 259.21,72.92 256.56,72.92 254.71,74.77 244.71,74.77 244.35,75.13 243.88,75.13 v2(243.79,75.04)
  BOTTOM w0.076: v2(147.98,63.16) 147.82,63.16 147.54,62.88 UC1.AT7
USBP1-: length 141.1
  TOP w0.102: v2(263.76,73.62) 263.97,73.83 263.97,74.51 264.48,75.02 264.48,75.52 264.16,75.84 L54.4 264.16,76.56 R483.1
  IN1 w0.084: v2(148.01,63.76) 148.01,63.66 148.57,63.1 149.18,63.1 149.54,62.75 150.44,62.75 151.08,63.39 153.56,63.39 153.85,63.67
  IN1 w0.091: 153.85,63.67 156.42,66.24 160.19,66.24 162.9,63.53 162.9,61.96 163.48,61.38 165.65,61.38 165.94,61.09 166.88,61.09 169.11,63.32 169.11,64.56 169.22,64.66 169.22,64.98 171.08,66.84 176.1,66.84 176.6,66.33 190.56,66.33 191.42,67.19 195.42,67.19 195.94,67.71 199.97,67.71 200.19,67.49 203.64,67.49 204.38,68.22 205.66,68.22 206.19,68.75 206.19,69.24 207.14,70.18 207.14,71.59 211.13,75.59 211.13,75.98 215.41,80.26 223.91,80.26 225,81.35 234.82,81.35 235.23,80.94 237.27,80.94 242.84,75.37 243.54,75.37 v2(243.79,75.62)
  IN4 w0.091: v2(263.76,73.62) 263.74,73.62 264.01,73.36 264.01,73.14 263.38,72.52 259.85,72.52 259.28,73.09 256.63,73.09 254.78,74.94 244.79,74.94 244.42,75.31 244.09,75.31 243.79,75.61 v2(243.79,75.62)
  BOTTOM w0.076: v2(148.01,63.76) 147.68,63.44 UC1.AR7
USBP1_R_D+: length 14
  TOP w0.102: v2(264.21,79.48) 264.36,79.32 264.62,79.32 264.86,79.08 264.86,78.64 265.01,78.48 L54.2 265.01,77.77 R482.2
  BOTTOM w0.102: JUSB3.3 271.48,76.74 271.48,75.95 271.41,75.88 267.98,75.88 267.71,76.16 267.71,76.17 267.33,76.55 267.32,76.55 266.73,77.13 266.73,78.68 266.19,79.23 265.66,79.23 265.56,79.33 D33.3 264.8,79.32 264.36,79.32 v2(264.21,79.48)
USBP1_R_D-: length 13.9
  TOP w0.102: v2(264.21,78.89) 264.4,79.08 264.55,79.08 264.64,78.99 264.64,78.73 264.16,78.25 L54.3 264.16,77.77 R483.2
  BOTTOM w0.102: JUSB3.2 271.47,75.6 271.4,75.67 267.89,75.67 266.52,77.04 266.52,78.59 266.1,79.01 265.66,79.01 265.56,78.91 D33.2 264.63,79.08 264.4,79.08 v2(264.21,78.89)
USBP2+: length 103
  IN1 w0.084: v2(146.51,63.26) 146.66,63.12 147.04,63.12 147.22,62.94 147.22,62.27 147.12,62.17 147.12,61.05 147.48,60.69 153.3,60.69 153.68,61.07 153.71,61.1 153.71,61.11 153.73,61.12
  IN1 w0.091: JMINI1.38 212.27,26.8 211.95,26.48 210.86,26.48 204.66,32.68 204.66,36.77 205.3,37.41 205.3,40.07 207.28,42.05 207.28,47.35 206.86,47.76 206.33,47.76 205.36,46.79 192.34,46.79 190.66,48.48 189.74,48.48 181.67,56.54 174.77,56.54 174.35,56.97 168.93,56.97 167.53,58.36 166.37,58.36 165.96,58.77 162.1,58.77 161.55,59.32 161.55,63.04 159.66,64.93 157,64.93 154.8,62.74 154.8,62.2 153.73,61.12
  BOTTOM w0.076: v2(146.51,63.26) 146.97,63.72 UC1.AP8
USBP2-: length 103
  IN1 w0.084: 153.85,61 153.72,60.87 153.71,60.87 153.37,60.53 147.41,60.53 146.95,60.98 146.95,62.23 147.05,62.34 147.05,62.87 146.97,62.95 146.92,62.95 v2(146.58,62.61)
  IN1 w0.091: 153.85,61 154.98,62.13 154.98,62.67 157.07,64.76 159.58,64.76 161.38,62.97 161.38,59.24 162.03,58.6 165.89,58.6 166.29,58.19 167.46,58.19 168.86,56.79 174.28,56.79 174.7,56.37 181.6,56.37 189.67,48.3 190.58,48.3 192.27,46.61 205.43,46.61 206.4,47.59 206.79,47.59 207.1,47.27 207.1,42.13 205.12,40.14 205.12,37.49 204.48,36.85 204.48,32.61 210.79,26.31 211.93,26.31 212.24,26 JMINI1.36
  BOTTOM w0.076: UC1.AR8 146.97,63.01 v2(146.58,62.61)
USBP3+: length 120.3
  IN2 w0.089: 144.36,51.41 144.36,51.42 144.34,51.44 144.34,51.57 146.28,53.5 146.28,56.46 144.65,58.09 144.65,59.99 145.48,60.82 145.48,62.56 145.65,62.73 145.95,62.73 146.04,62.65 v2(146.04,62.46)
  IN2 w0.132: 144.36,51.41 144.36,50.67 141.46,47.77 116.59,47.77 115.6,46.77 71.14,46.77 70.86,47.05 70.64,47.05 v2(70.52,46.93)
  IN4 w0.091: v2(71.36,69.07) 71.04,69.07 70.86,69.07 70.68,68.89 70.68,63.73 73.85,60.56 73.85,51.95 71.17,49.27 71.17,47.3 70.93,47.07 70.66,47.07 v2(70.52,46.93)
  BOTTOM w0.076: UC1.AT10 145.71,62.79 v2(146.04,62.46)
  BOTTOM w0.102: R100.1 68.16,70.88 L8.1 68.45,70.54 68.96,70.03 69.92,69.07 v2(71.36,69.07)
USBP3-: length 120.2
  IN2 w0.089: v2(145.97,63.11) 145.8,62.94 145.56,62.94 145.28,62.65 145.28,60.9 144.44,60.07 144.44,58 146.07,56.37 146.07,53.59 144.14,51.65 144.14,51.44 144.12,51.42 144.12,51.41
  IN2 w0.132: v2(70.52,47.52) 70.74,47.3 70.97,47.3 71.24,47.02 115.49,47.02 116.49,48.02 141.36,48.02 144.12,50.77 144.12,51.41
  IN4 w0.091: v2(70.52,47.52) 70.52,47.5 70.78,47.24 70.86,47.24 71,47.38 71,49.34 73.68,52.02 73.68,60.49 70.51,63.65 70.51,68.96 70.79,69.24 70.97,69.24 71.36,69.64 v2(71.36,69.65)
  BOTTOM w0.076: UC1.AR10 145.65,63.44 v2(145.97,63.11)
  BOTTOM w0.102: R101.1 69.26,70.88 69.25,70.88 69.25,70.46 69.11,70.32 69.11,70.18 70.01,69.28 70.99,69.28 v2(71.36,69.65)
USBP3_D+: length 4.7
  BOTTOM w0.102: R100.2 67.85,72.16 L8.2 67.93,72.24 67.93,72.96 67.91,72.98 67.91,73.28 67.9,73.29 67.9,73.82 67.91,73.84 67.91,74.28 v3(67.46,74.73) 67.13,75.06 66.95,75.14 JEDP1.31
USBP3_D-: length 4.7
  BOTTOM w0.102: JEDP1.32 67.42,75.31 67.42,75.09 67.8,74.71 67.8,74.69 68.13,74.37 v3(68.13,73.56) 68.13,73.07 68.67,72.53 L8.3 68.94,72.2 R101.2
USBP4+: length 123.4
  TOP w0.102: JUSH1.3 184.26,5.35 184.2,5.3 184.02,5.3 183.97,5.24 183.97,4.76 184.42,4.32 187.91,4.32 188.56,3.67 192.21,3.67 194.74,6.2 194.74,7.73 194.72,7.76 194.72,8.29 194.74,8.32 194.74,14.34 196.02,15.62 196.02,15.73 v2(195.66,16.1)
  IN1 w0.084: 153.85,57 153.83,57 153.83,57 148.14,57 145.27,59.88 144.13,59.88 143.49,60.51 143.49,62.18 143.49,62.18 142.27,62.18 141.85,62.61 141.85,64.65 142.34,65.15 142.5,65.15 v2(142.74,65.39)
  IN1 w0.091: v2(195.66,16.1) 195.9,16.34 195.9,16.56 196.53,17.2 196.78,17.2 199.76,20.17 199.76,28.95 200.22,29.41 200.22,32.68 199.82,33.09 199.82,35.44 199.32,35.94 199.32,37.3 198.89,37.74 198.89,38.02 193.68,43.23 193.68,44.11 190.37,47.42 189.64,47.42 181.33,55.73 161.35,55.73 161.05,56.02 161.05,57.84 160.75,58.15 157.39,58.15 156.12,56.88 155.51,56.88 155.39,57 153.85,57
  BOTTOM w0.076: v2(142.74,65.39) 142.89,65.39 143.13,65.63 UC1.AL15
USBP4-: length 123.4
  TOP w0.102: v2(196.24,16.1) 196.24,15.53 194.96,14.25 v3(194.96,8.01) 194.96,6.11 192.3,3.45 188.47,3.45 187.82,4.1 184.33,4.1 183.76,4.67 JUSH1.2
  IN1 w0.084: v2(142.74,64.74) 142.49,64.99 142.41,64.99 142.01,64.58 142.01,62.67 142.34,62.34 143.56,62.34 143.66,62.25 143.66,60.58 144.2,60.05 145.34,60.05 148.21,57.17 153.83,57.17 153.83,57.17 153.85,57.17
  IN1 w0.091: 153.85,57.17 155.47,57.17 155.58,57.06 156.05,57.06 157.32,58.32 160.82,58.32 161.23,57.91 161.23,56.1 161.42,55.9 181.4,55.9 189.71,47.59 190.44,47.59 193.86,44.18 193.86,43.3 199.06,38.1 199.06,37.81 199.49,37.37 199.49,36.01 199.99,35.51 199.99,33.16 200.39,32.75 200.39,29.34 199.93,28.88 199.93,20.1 196.86,17.02 196.61,17.02 196.07,16.49 196.07,16.27 v2(196.24,16.1)
  BOTTOM w0.076: UC1.AM15 143.06,65.06 v2(142.74,64.74)
USBP5+: length 100.7
  TOP w0.102: U33.6 163.94,105.7 163.82,105.83 163.82,106.05 v2(163.91,106.13)
  IN2 w0.132: v2(173.38,60.41) 173.55,60.24 173.55,59.96 173.81,59.7 174.33,59.7 174.74,60.11 174.74,61.46 175.48,62.21 175.48,65.11 172.86,67.74 172.86,76.54 172.68,76.71 172.68,78.94 175.37,81.62 175.37,87.43 173.89,88.91 173.89,91.69 168.57,97.01 168.57,100.47 166.98,102.06 166.98,104.67 166.42,105.23 163.75,105.23 163.56,105.43 163.56,105.78 v2(163.91,106.13)
  IN4 w0.084: 153.85,56.31 153.83,56.31 153.82,56.31 152.66,56.31 151.62,57.35 148.84,57.35 145.99,60.2 144.78,60.2 143.99,60.99 143.99,62.77 143.67,63.09 143.67,64.55 143.76,64.65 144,64.65 144.14,64.51 v2(144.14,64.35)
  IN4 w0.091: v2(173.38,60.41) 173.57,60.22 173.57,60.05 173.38,59.85 170.55,59.85 169.52,60.88 167.39,60.88 166.84,60.32 166.84,59.84 165.85,58.86 164.98,58.86 164.51,58.39 164.51,57.75 160.45,53.7 159.64,53.7 159.22,53.28 158.02,53.28 157.48,53.81 156.82,53.81 154.33,56.31 153.85,56.31
  BOTTOM w0.076: v2(144.14,64.35) 143.75,64.74 UC1.AN13
USBP5-: length 100.5
  TOP w0.102: U33.7 163.54,105.89 163.3,106.13 v2(163.25,106.13)
  IN2 w0.132: v2(163.25,106.13) 163.31,106.07 163.31,105.33 163.65,104.99 166.32,104.99 166.73,104.57 166.73,101.95 168.32,100.37 168.32,96.91 173.64,91.59 173.64,88.81 175.12,87.32 175.12,81.72 172.44,79.04 172.44,76.61 172.61,76.44 172.61,67.63 175.24,65.01 175.24,62.31 174.49,61.57 174.49,60.21 174.23,59.95 173.91,59.95 173.8,60.06 173.8,60.25 v2(173.96,60.41)
  IN4 w0.084: 153.85,56.14 153.83,56.14 153.83,56.14 152.59,56.14 151.55,57.18 148.78,57.18 145.92,60.04 144.71,60.04 143.83,60.92 143.83,62.7 143.5,63.03 143.5,64.62 143.7,64.81 143.96,64.81 v2(144.14,65)
  IN4 w0.091: v2(173.96,60.41) 173.74,60.19 173.74,59.98 173.45,59.68 170.48,59.68 169.45,60.71 167.46,60.71 167.01,60.25 167.01,59.77 165.93,58.69 165.05,58.69 164.68,58.32 164.68,57.68 160.52,53.52 159.71,53.52 159.29,53.1 157.95,53.1 157.41,53.64 156.75,53.64 154.26,56.14 153.85,56.14
  BOTTOM w0.076: v2(144.14,65) 143.74,65.39 UC1.AM13
USBP5_D+: length 17.9
  BOTTOM w0.102: JUSB2.3 214.47,97.28 214.47,97.22 213.61,96.37 211,96.37 208.57,93.94 208.15,93.94 208.05,94.04 D16.3 207.32,94.79 207.11,94.59 207.11,94.26 206.74,93.89 206.62,93.89 206.15,93.42 v3(206.15,92.68) 206.15,91.12 205.96,90.93 205.94,90.93 205.56,90.56 205.56,90.54 205.21,90.19 204.54,90.19 204.22,90.51 L39.2 203.6,90.51 R238.2
USBP5_D-: length 18.3
  BOTTOM w0.102: R240.2 203.6,89.66 L39.3 204.22,89.66 204.54,89.97 205.3,89.97 v3(205.91,90.58) 206.36,91.03 206.36,92.41 206.38,92.42 206.38,92.95 206.36,92.96 206.36,93.33 206.71,93.67 206.86,93.67 207.19,93.34 207.19,93.01 207.34,92.86 D16.2 208.05,93.62 208.15,93.72 208.66,93.72 211.09,96.15 213.7,96.15 214.68,97.13 214.68,97.23 JUSB2.2
USBP6+: length 86.2
  IN1 w0.084: 153.85,62.81 153.83,62.81 153.83,62.8 153.78,62.8 153.77,62.8 151.6,62.8 150.3,61.51 148.58,61.51 148.18,61.9 148.18,62.15 147.57,62.77 147.57,63.4 147.18,63.8 144.74,63.8 144.64,63.89 v2(144.64,64.05)
  IN1 w0.091: JMINI2.38 208.13,58.55 207.87,58.29 207.54,58.29 207.04,57.79 207.04,51.33 206.75,51.03 206.75,49.1 205.08,47.43 192.68,47.43 190.91,49.2 189.93,49.2 181.36,57.77 175.23,57.77 174.86,58.14 168.88,58.14 168.01,59.01 167.08,59.01 165.49,60.6 163.2,60.6 162.23,61.57 162.23,63.27 159.91,65.59 156.69,65.59 153.9,62.81 153.85,62.81
  BOTTOM w0.076: UC1.AN11 145.01,64.41 v2(144.64,64.05)
USBP6-: length 86.2
  IN1 w0.084: v2(144.64,63.41) 144.86,63.63 147.11,63.63 147.41,63.34 147.41,62.7 148.02,62.08 148.02,61.83 148.51,61.34 150.37,61.34 151.67,62.64 153.85,62.64
  IN1 w0.091: JMINI2.36 208.11,57.75 207.75,58.11 207.61,58.11 207.21,57.72 207.21,51.25 206.92,50.96 206.92,49.02 205.16,47.26 192.61,47.26 190.84,49.03 189.86,49.03 181.29,57.59 175.16,57.59 174.79,57.96 168.81,57.96 167.94,58.84 167,58.84 165.41,60.43 163.13,60.43 162.06,61.5 162.06,63.2 159.84,65.42 156.76,65.42 153.98,62.64 153.85,62.64
  BOTTOM w0.076: v2(144.64,63.41) 144.99,63.76 UC1.AP11
USBP7+: length 89.1
  IN1 w0.084: 109.91,68.56 109.92,68.56 109.93,68.56 111.17,68.56 111.29,68.67 112.41,68.67 112.83,68.25 115.28,68.25 116.02,67.51 118.37,67.51 119.54,68.68 130.12,68.68 131.16,67.64 136.29,67.64 136.56,67.37 136.93,67.37 137.26,67.7 139.67,67.7 140.18,67.2 140.44,67.2 140.67,67.42 141.22,67.42 142.52,66.13 142.86,66.13 143.39,65.6 143.39,63.84 143.68,63.55 143.91,63.55 v2(144.13,63.77)
  IN1 w0.091: 109.91,68.56 108.16,68.56 106.67,70.05 93.34,70.05 92.99,69.7 87.83,69.7 87.12,70.42 80.56,70.42 80.16,70.81 80.16,71.62 v2(80.4,71.85)
  BOTTOM w0.076: v2(144.13,63.77) 144.01,63.77 UC1.AP13
  BOTTOM w0.102: JEDP1.38 69.66,77.92 69.75,78.1 69.7,78.23 69.7,78.55 70.22,79.07 71.49,79.07 v3(73.88,76.68) 75.17,75.39 75.17,74.54 75.27,74.43 75.53,74.43 75.6,74.51 75.6,74.93 75.77,75.09 D8.3 76.53,74.34 76.63,74.24 77.01,74.24 78.28,72.96 79.85,72.96 80.32,72.49 80.32,71.94 v2(80.4,71.85)
