# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_MINI1: length 121.2
  IN1 w0.084: v2(128.77,91.1) 128.56,90.89 128.56,90.53 131.89,87.21 134.81,87.21 135.32,86.69 139.29,86.69 139.75,87.15 140.8,87.15 141.26,86.69 145.26,86.69 145.56,86.99 149.33,86.99 156.1,80.22 160.8,80.22 161.62,79.4 165.93,79.4 168.43,76.91 169.5,76.91 170.38,76.03 173.73,76.03 174.16,75.6 176.47,75.6 176.98,75.09 178.11,75.09 178.42,74.78 178.42,73.96 v2(178.56,73.82)
  IN2 w0.122: v2(178.56,73.82) 178.4,73.65 178.4,73.18 178.54,73.04 178.54,70.28 181.57,67.25 181.57,51.29 188.44,44.42 190.99,44.42 191.13,44.56 v2(191.13,44.84)
  BOTTOM w0.076: 128.32,85.57 128.32,85.56 128.31,85.55 128.31,84.09 129.4,82.99 129.4,82.73 129.3,82.62 129.15,82.62 129.04,82.73 UC1.A37
  BOTTOM w0.102: v2(191.13,44.84) 191.35,44.84 191.67,45.16 206.34,45.16 206.53,45.35 JMINI2.13 ; 128.32,85.57 128.32,86.97 128.68,87.32 128.68,91 v2(128.77,91.1)
CLK_PCIE_MINI1#: length 121.7
  IN1 w0.084: v2(128.19,91.1) 128.19,91.09 128.39,90.89 128.39,90.46 131.81,87.03 134.73,87.03 135.25,86.52 139.36,86.52 139.82,86.97 140.73,86.97 141.19,86.52 145.33,86.52 145.63,86.81 149.26,86.81 156.03,80.05 160.73,80.05 161.55,79.23 165.86,79.23 168.35,76.73 169.43,76.73 170.31,75.86 173.66,75.86 174.09,75.43 176.4,75.43 176.91,74.92 178.04,74.92 178.25,74.71 178.25,74.09 v2(177.98,73.82)
  IN2 w0.122: v2(177.98,73.82) 178.15,73.65 178.15,73.08 178.29,72.94 178.29,70.18 181.33,67.15 181.33,51.19 188.34,44.18 191.09,44.18 191.31,44.39 v2(191.51,44.39)
  BOTTOM w0.076: UC1.B37 128.91,82.3 128.91,82.51 128.7,82.72 128.7,83.35 128.07,83.99 128.07,85.55 128.05,85.56 128.05,85.57
  BOTTOM w0.102: 128.05,85.57 128.05,87.08 128.41,87.43 v3(128.41,88.43) 128.41,90.87 v2(128.19,91.1) ; v2(191.51,44.39) 191.51,44.62 191.78,44.89 206.36,44.89 206.71,44.55 JMINI2.11
CLK_PCIE_MINI2: length 157.1
  IN1 w0.084: v2(175.58,76.79) 175.78,77 175.78,77.11 175.68,77.21 174.25,77.21 173.6,76.56 170.59,76.56 169.75,77.39 168.65,77.39 166.09,79.95 163.09,79.95 162.35,80.68 156.29,80.68 149.3,87.67 132.25,87.67 129.81,90.11 129.81,91.28 129.5,91.59 127.27,91.59 127.15,91.47 127.15,91.29 v2(127.36,91.09)
  IN2 w0.122: v2(209.72,12.53) 209.91,12.73 209.91,13.63 208.7,14.84 204.39,14.84 203.93,15.3 203.93,19.89 203.73,20.08 203.73,22.13 202.61,23.25 202.61,24.66 201.52,25.74 201.52,26.46 200.48,27.5 200.48,29.76 200.19,30.06 200.19,31.01 199.26,31.94 197.19,31.94 194.86,34.26 194.86,38.7 194.41,39.16 189.44,39.16 176.41,52.18 176.41,57.03 177.84,58.46 177.84,62.78 178.15,63.09 178.15,65.91 176.29,67.77 176.29,68.96 175.2,70.05 175.2,73.62 174.8,74.02 174.8,75.12 175.79,76.12 175.79,76.58 v2(175.58,76.79)
  BOTTOM w0.076: UC1.C37 129.04,81.72 128.71,82.04 128.71,82.37 128.52,82.56 128.52,83.26 127.55,84.24 127.55,85.54 127.56,85.55 127.56,85.57
  BOTTOM w0.102: JMINI1.13 210.81,13.6 210.54,13.33 210.13,13.33 209.88,13.08 209.88,12.69 v2(209.72,12.53) ; v2(127.36,91.09) 127.2,90.93 127.2,89.01 127.32,88.9 127.32,87.21 127.56,86.97 127.56,85.57
CLK_PCIE_MINI2#: length 156.7
  IN1 w0.084: v2(176.16,76.79) 175.96,77 175.96,77.18 175.76,77.38 174.18,77.38 173.53,76.73 170.66,76.73 169.82,77.57 168.72,77.57 166.17,80.12 163.16,80.12 162.42,80.86 156.36,80.86 149.37,87.85 132.32,87.85 129.98,90.19 129.98,91.35 129.57,91.76 127.2,91.76 126.97,91.54 126.97,91.29 v2(126.77,91.09)
  IN2 w0.122: v2(176.16,76.79) 176.04,76.67 176.04,76.01 175.05,75.02 175.05,74.12 175.44,73.73 175.44,70.15 176.54,69.06 176.54,67.87 178.39,66.01 178.39,62.98 178.09,62.68 178.09,58.36 176.65,56.93 176.65,52.29 189.54,39.4 194.51,39.4 195.11,38.8 195.11,34.37 197.29,32.19 199.36,32.19 200.43,31.11 200.43,30.16 200.73,29.86 200.73,27.6 201.77,26.56 201.77,25.84 202.86,24.76 202.86,23.35 203.98,22.23 203.98,20.18 204.18,19.99 204.18,15.4 204.49,15.09 208.81,15.09 210.16,13.73 210.16,12.67 v2(210.3,12.53)
  BOTTOM w0.076: UC1.B38 128.47,82.27 128.28,82.46 128.28,83.16 127.31,84.14 127.31,85.55 127.29,85.56 127.29,85.57
  BOTTOM w0.102: 127.29,85.57 127.29,86.86 127.05,87.1 127.05,88.79 126.94,88.9 126.94,90.92 v2(126.77,91.09) ; v2(210.3,12.53) 210.14,12.69 210.14,12.97 210.24,13.07 210.54,13.07 210.81,12.8 JMINI1.11
CLK_PCIE_MMI: length 230
  TOP w0.102: U27.3 259.39,24.11 259.76,24.47 259.96,24.47 v2(260.08,24.59)
  IN1 w0.084: v2(125.41,92.46) 125.61,92.65 125.61,92.85 125.86,93.1 126.88,93.1 126.94,93.04 132.26,93.04 136.18,89.12 151.36,89.12 152.87,87.62 152.87,87.08 153.32,86.63 155.49,86.63 156.57,87.71 159.92,87.71 165.29,82.34 166.27,82.34 168.44,80.18 169.4,80.18 169.87,79.71 175.81,79.71 176.71,78.81 177.92,78.81 181.53,75.21 181.53,75.09 183.25,73.36 184.75,73.36 185.13,73.74 201.29,73.74 203.64,76.09 203.64,76.76 205,78.12 205.88,78.12 210.16,82.4 211.36,82.4 214.31,85.34 214.51,85.34 215.3,86.13 220.15,86.13 220.67,86.65 236.32,86.65 236.96,86.01 239.65,86.01 244.26,81.4 247.77,81.4 250.19,83.82 254.91,83.82 255.58,83.15 256.27,83.15 257.45,81.97 257.7,81.97 258.92,80.75 258.92,74.94 260.09,73.77 261.16,73.77 262.39,72.55 263.14,72.55 265.48,70.2 265.48,34.71 259.68,28.9 259.68,24.5 259.73,24.45 259.94,24.45 v2(260.08,24.59)
  BOTTOM w0.102: UC1.B39 127.91,82.24 127.06,83.08 127.06,83.72 126.54,84.24 126.54,85.94 125.57,86.92 125.57,92.3 v2(125.41,92.46)
CLK_PCIE_MMI#: length 229.5
  TOP w0.102: v2(260.08,24.01) 260.08,24.15 260.03,24.21 259.87,24.21 259.65,23.99 259.65,23.64 259.79,23.51 U27.2
  IN1 w0.084: v2(260.08,24.01) 259.82,24.27 259.66,24.27 259.5,24.43 259.5,28.98 265.31,34.78 265.31,70.13 263.06,72.38 262.31,72.38 261.09,73.6 260.01,73.6 258.75,74.86 258.75,80.67 257.63,81.79 257.38,81.79 256.2,82.97 255.51,82.97 254.83,83.65 250.26,83.65 247.84,81.23 244.19,81.23 239.57,85.84 236.88,85.84 236.25,86.47 220.74,86.47 220.22,85.95 215.37,85.95 214.58,85.17 214.38,85.17 211.43,82.22 210.23,82.22 205.96,77.95 205.07,77.95 203.81,76.69 203.81,76.02 201.36,73.56 185.2,73.56 184.83,73.19 183.18,73.19 181.35,75.01 181.35,75.14 177.85,78.64 176.63,78.64 175.74,79.54 169.8,79.54 169.33,80 168.36,80 166.2,82.17 165.21,82.17 159.85,87.54 156.64,87.54 155.56,86.46 153.24,86.46 152.69,87.01 152.69,87.54 151.29,88.95 136.11,88.95 132.19,92.87 126.87,92.87 126.8,92.93 125.93,92.93 125.78,92.78 125.78,92.67 v2(126,92.46)
  BOTTOM w0.102: UC1.A39 128.03,82.93 128.03,83.07 127.88,83.22 127.77,83.22 127.58,83.03 127.49,83.03 127.33,83.19 127.33,83.32 127.51,83.5 127.51,83.65 126.81,84.35 126.81,86.05 125.84,87.03 125.84,92.3 v2(126,92.46)
CLK_TP_SIO: length 209
  TOP w0.102: R444.1 191.24,17.26 191.58,17.6 191.58,18.6 191.27,18.91 191.27,19.14 v2(191.06,19.35) ; U38.A37 26.44,20.85 26.94,21.35 v2(26.94,21.39)
  IN1 w0.084: v2(26.94,21.39) 26.68,21.39 26.51,21.21 26.51,20.43 25.96,19.89 25.96,10.7 26.65,10.01 27.86,10.01 29.47,8.4 31.69,8.4 33.02,7.06 34.92,7.06 35.4,6.59 36.68,6.59 37.91,7.82 40.17,7.82 40.58,7.42 42.42,7.42 44.77,9.77 44.77,12.95 49.97,18.14 49.97,20.47 51.71,22.21 51.71,23.09 52.29,23.67 56.59,23.67 58.11,25.19 60.78,25.19 62.54,26.95 98.04,26.95 98.61,26.38 98.61,19.31 99.76,18.16 119.9,18.16 122.57,20.84 122.57,21.91 123.64,22.97 130.69,22.97 135.16,18.5 169.6,18.5 170.45,17.65 190.59,17.65 191.25,18.31 191.25,19.17 v2(191.06,19.35)
CLKRUN#: length 214.4
  TOP w0.102: U25.15 43.77,35.82 41.51,33.56 v2(41.51,32.26) ; v2(30.47,18.87) 30.47,18.49 30.31,18.33 U38.A32 ; v2(24.12,31.44) 24.2,31.52 U37.B20 ; RP6.8 157.25,70.81 155.91,72.15 151.71,72.15 v1(151.57,72.29) 151.3,72.29 150.63,71.62 148.74,71.62 v2(148.17,72.19)
  IN1 w0.084: v2(41.51,32.26) 41.31,32.06 41.31,28.88 41.71,28.49 41.71,24.36 41.35,24 41.35,22.68 40.29,21.62 40.29,17.73 37.3,14.75 34.79,14.75 33.98,15.56 33.98,16.14 33.74,16.37 33.41,16.37 33.2,16.16 31.21,16.16 30.47,16.91 v2(30.47,18.87)
  IN2 w0.089: 153.06,51.41 153.06,52 152.25,52.81 152.25,57.01 150.95,58.31 150.95,60.34 150.84,60.45 150.84,62.38 151.31,62.84 151.31,63.49 151.24,63.56 151.24,66.29 150.88,66.66 150.88,71.01 150.23,71.67 148.64,71.67 148.17,72.14 v2(148.17,72.19)
  IN2 w0.122: 153.06,51.41 153.06,47.69 144.29,38.91 59.54,38.91 58.97,39.48 53.19,39.48 49.2,35.5 48.46,35.5 46.86,33.9 46.86,33.19 45.11,31.44 42.12,31.44 41.52,32.04 41.52,32.26 v2(41.51,32.26)
  IN4 w0.084: v2(41.51,32.26) 40.29,31.04 33.44,31.04 32.4,32.07 29.13,32.07 27.77,30.71 25.17,30.71 24.45,31.44 v2(24.12,31.44)
  BOTTOM w0.076: v2(148.17,72.19) 148.64,72.66 UC1.V5
CODEC_IRQ: length 6.8
  TOP w0.102: v2(151.9,76.45) 152.27,76.82 153.28,76.82 153.73,76.37 v1(153.73,76.22) 153.73,75.84 154.28,75.29 RC154.1
  BOTTOM w0.076: UC1.L4 149.62,76.01 150.86,76.01 150.9,76.05 151.5,76.05 v2(151.9,76.45)
CONTACTLESS_DET#: length 154
  TOP w0.102: JUSH1.17 191.26,4.83 v2(191.27,4.81) ; v2(207.62,6.79) 207.62,5.92 207.28,5.57 v1(207.12,5.57) ; v2(162.23,74.08) RC137.2
  IN1 w0.084: v2(205.14,70.74) 204.79,71.08 204.13,71.08 202.8,69.75 200.46,69.75 200.37,69.67 197.24,69.67 197.09,69.82 192.16,69.82 191.24,70.74 179.92,70.74 179.46,71.2 170.44,71.2 169.17,72.47 164.03,72.47 162.99,73.51 162.8,73.51 v2(162.23,74.08)
  IN2 w0.122: v2(191.27,4.81) 192.34,5.88 203.37,5.88 204.71,7.23 206.5,7.23 206.93,6.79 v2(207.62,6.79)
  IN3 w0.089: v2(148.14,74.09) 148.14,74 148.44,73.7 149.04,73.7 149.44,73.3 151.3,73.3 151.57,73.57 153.1,73.57 153.27,73.39 153.85,73.39
  IN3 w0.122: 153.85,73.39 154.11,73.39 154.49,73.77 157.65,73.77 158.46,72.96 160.69,72.96 161.81,74.08 v2(162.23,74.08) ; v2(205.14,70.74) 206.15,69.72 206.15,68.74 205.71,68.3 205.71,63.23 205.51,63.03 205.51,62.76 204.94,62.19 204.94,56.82 205.84,55.93 206.66,55.93 207.13,55.46 207.13,51.74 206.74,51.35 206.74,47.99 207.26,47.47 207.26,41.56 205.57,39.88 205.57,37.88 204.28,36.59 204.28,32.84 209.78,27.34 209.78,26.38 209.09,25.69 209.09,22.85 208.6,22.37 208.6,10.15 207.62,9.17 v2(207.62,6.79)
  BOTTOM w0.076: UC1.U6 147.99,73.89 148.1,73.99 148.1,74.05 v2(148.14,74.09)
CPPE#: length 124.5
  TOP w0.102: v2(154.83,79.76) 154.87,79.8 160.27,79.8 161.19,80.72 v1(162.53,80.72) 162.81,80.72 163.2,80.34 170.02,80.34 171.06,79.31 171.06,77.43 173.19,75.3 173.19,72.39 172.45,71.65 172.45,68.62 173.11,67.96 175.09,67.96 178.7,64.35 178.7,57.82 178.14,57.27 178.14,53.94 178.7,53.38 178.7,48.85 184.44,43.11 184.44,24.22 183.69,23.47 v2(183.69,23.14)
  IN2 w0.122: v2(183.69,23.14) 184.21,23.14 184.38,22.98 195.43,22.98 197.38,21.03 197.62,21.03 199.76,18.9 v2(201.75,18.9)
  BOTTOM w0.076: UC1.J1 151.45,78.02 152.08,78.02 152.72,78.65 152.72,79.3
  BOTTOM w0.102: RC185.2 158.17,78.19 157.44,77.47 156.9,77.47 156.54,77.83 156.54,77.86 155.7,78.7 155.7,78.9 v2(154.83,79.76) 154.53,79.46 152.88,79.46 152.72,79.3 ; v2(201.75,18.9) 202.63,18.9 203.86,20.13 203.86,21.61 206.53,24.28 208.9,24.28 211.02,26.4 JMINI1.37
CPU_DETECT#: length 154.2
  TOP w0.102: R284.2 17.39,27.83 v2(17.45,27.89) 17.45,28.55 17.43,28.57 U37.A3 ; v2(105.86,93.5) v1(105.86,92.76)
  IN2 w0.089: 110.41,85.57 110.41,82.84 v2(111.11,82.14)
  IN2 w0.122: 110.41,85.57 110.41,87.03 110.7,87.32 110.7,90.79 109.79,91.7 109.79,92.18 109.46,92.51 106.85,92.51 v2(105.86,93.5)
  IN3 w0.122: v2(105.86,93.5) 105.42,93.07 104.94,93.07 104.19,93.81 102.08,93.81 101.54,93.27 99.91,93.27 97.08,90.43 94.82,90.43 93.05,88.67 90.7,88.67 88.74,86.71 85.68,86.71 83.84,84.87 83.84,84.2 82.64,83 79.12,83 77.88,81.76 74.04,81.76 69.37,77.09 67.99,77.09 65.53,74.63 65.53,64.19 64.01,62.67 64.01,60.62 62.02,58.63 62.02,48.99 60.25,47.22 60.25,45.71 56.5,41.96 52.17,41.96 50.45,40.24 49.62,40.24 46.52,37.14 46.52,36.26 44.73,34.47 38.35,34.47 35.36,31.48 32.39,31.48 32.21,31.67 30.09,31.67 29.36,30.94 29.36,29.53 27.61,27.79 26.6,27.79 26.29,27.47 23.99,27.47 23.76,27.24 21.33,27.24 20.81,26.72 20.15,26.72 19.56,27.31 18.03,27.31 v2(17.45,27.89)
  BOTTOM w0.076: UC1.D61 113.89,81.07 112.88,81.07 112.78,81.17 112.5,81.17 112.27,81.39 112.27,81.5 111.62,82.14 v2(111.11,82.14)
CPU_DPB_AUX: length 6.8
  BOTTOM w0.076: UC1.B5 148.2,82.23 148.2,82.3 148.23,82.33 148.23,83.1 148.57,83.45 148.57,83.45 149.24,84.12 149.24,85 148.98,85.25 148.98,85.49 148.97,85.5 148.97,85.51 148.92,85.56 148.92,85.57
  BOTTOM w0.102: RC153.2 149.53,87.62 149.53,87.38 v3(149.18,87.03) 148.92,86.77 148.92,85.57
CPU_DPB_AUX#: length 7.3
  BOTTOM w0.076: 149.15,85.57 149.15,85.32 149.4,85.06 149.4,84.05 148.64,83.29 148.64,83.29 148.39,83.04 148.39,82.39 148.45,82.33 148.45,81.95 148.5,81.9 UC1.C5
  BOTTOM w0.102: 149.15,85.57 149.15,86.67 149.76,87.28 149.76,87.69 RC147.2
CPU_DPB_CTRLCLK: length 81.2
  IN2 w0.132: v2(158.69,97.04) 158.87,96.86 158.87,96.47 158.71,96.3 154.9,96.3 152.67,98.53 148.8,98.53 145.41,95.13 145.41,91.39 146.06,90.74 146.06,88.99 144.77,87.71 144.77,87.44 v2(144.6,87.28)
  IN4 w0.091: v2(158.69,97.04) 158.88,97.23 158.88,97.63 159.29,98.04 166.43,98.04 168.08,96.39 179.5,96.39 182.63,99.52 186.21,99.52 186.66,99.07 196.79,99.07 197.52,99.8 199.88,99.8 200.06,99.97 202.31,99.97 v2(202.95,100.61)
  BOTTOM w0.076: 145.89,85.57 145.89,85.1 145.99,85 145.99,84.73 146.32,84.4 146.32,84.12 146.11,83.91 146.11,82.69 145.59,82.17 UC1.B9
  BOTTOM w0.102: v2(202.95,100.61) 202.95,100.05 203.06,99.94 Q120.1 ; RC139.2 144.79,87.57 144.79,87.46 v2(144.6,87.28) 144.77,87.11 144.77,86.65 144.96,86.46 145.53,86.46 145.89,86.11 145.89,85.57
CPU_DPB_CTRLCLK_R: length 12.6
  TOP w0.102: v1(201.78,100.84) 201.79,100.85 v2(202.36,100.85)
  IN1 w0.091: v2(202.36,100.85) 202.36,100.86 201.87,100.38 200.86,100.38 199.81,101.42 199.81,103.5 199.73,103.58 197.78,103.58 197.65,103.71 JHDMI1.15
  BOTTOM w0.102: R471.1 203.94,100.58 203.43,101.09 202.6,101.09 v2(202.36,100.85) 202.36,100.53 201.77,99.94 Q120.6
CPU_DPB_CTRLDAT: length 80.9
  IN2 w0.132: v2(145.19,87.28) 145.02,87.44 145.02,87.6 146.3,88.89 146.3,90.84 145.65,91.49 145.65,95.03 148.9,98.28 152.57,98.28 154.79,96.06 158.81,96.06 159.12,96.37 159.12,96.89 v2(159.27,97.04)
  IN4 w0.091: v2(159.27,97.04) 159.06,97.26 159.06,97.56 159.36,97.87 166.35,97.87 168,96.22 179.57,96.22 182.7,99.34 186.14,99.34 186.59,98.9 196.86,98.9 197.59,99.62 199.95,99.62 200.13,99.8 201.57,99.8 201.79,99.58 202.06,99.31 v2(202.06,98.68)
  BOTTOM w0.076: 146.1,85.57 146.1,85.56 146.06,85.52 146.06,85.5 146.05,85.49 146.05,85.17 146.15,85.07 146.15,84.8 146.48,84.47 146.48,84.05 146.28,83.85 146.28,82.62 145.92,82.27 UC1.C9
  BOTTOM w0.102: v2(202.06,98.68) 202.02,98.64 Q120.4 ; 146.1,85.57 146.1,86.2 145.62,86.68 145.05,86.68 144.98,86.74 144.98,87.07 v2(145.19,87.28) 145,87.46 145,87.57 RC141.2
CPU_DPB_CTRLDAT_R: length 11.7
  IN1 w0.091: v2(204.06,99.31) 204.06,99.34 203.2,100.2 200.79,100.2 199.33,101.66 199.33,101.79 JHDMI1.16
  BOTTOM w0.102: v2(204.06,99.31) 204.14,99.24 204.14,97.89 203.81,97.56 R470.1 203.76,98.07 203.76,98.53 203.65,98.64 Q120.3
CPU_DPC_AUX: length 36.1
  TOP w0.102: U19.14 169.64,89.04 169.72,89.13 169.83,89.13 169.92,89.22 169.92,89.47 169.67,89.73 v2(169.65,89.73)
  IN2 w0.132: v2(169.65,89.73) 169.65,89.74 169.99,90.08 169.99,90.29 168.79,91.49 158.18,91.49 157.58,92.09 155.36,92.09 155.19,92.26 153.71,92.26 153.38,91.93 153.38,90.67 152.71,90 152.21,90 147.82,85.61 147.82,85.01 v2(147.93,84.89)
  BOTTOM w0.076: UC1.A6 147.52,82.69 147.63,82.59 147.75,82.59 147.88,82.71 147.88,83.03 147.75,83.16 147.62,83.16 147.56,83.22 147.56,83.35
  BOTTOM w0.102: 147.56,83.35 147.56,84.37 147.62,84.43 147.84,84.43 147.94,84.53 147.94,84.88 v2(147.93,84.89) 147.82,85.01 147.82,87.59 RC155.2
CPU_DPC_AUX#: length 36.1
  TOP w0.102: v2(170.24,89.73) 170.14,89.63 U19.13
  IN2 w0.132: v2(170.24,89.73) 170.24,90.39 168.89,91.74 158.28,91.74 157.68,92.33 155.46,92.33 155.29,92.51 153.61,92.51 153.13,92.03 153.13,90.77 152.61,90.25 152.11,90.25 147.57,85.71 147.57,85.11 v2(147.35,84.89)
  BOTTOM w0.076: 147.34,83.43 147.35,83.43 147.35,83.1 147.19,82.95 147.19,82.21 UC1.B6
  BOTTOM w0.102: 147.34,83.43 147.34,84.89 v2(147.35,84.89) 147.6,85.15 147.6,87.68 RC149.2
CPU_DPC_CTRLCLK: length 121
  TOP w0.102: v2(232.85,88.49) 232.81,88.49 232.65,88.33 232.65,87.96 233.13,87.48 233.41,87.48 233.77,87.83 233.77,88.34 233.94,88.51 U49.12 ; v2(145.48,85.38) 145.3,85.56 145.3,85.99 144.15,87.15 144.15,87.6 RC143.2
  IN2 w0.122: v2(232.85,88.49) 232.81,88.49 232.73,88.58 232.73,89.04 232.33,89.44 221.29,89.44 221.16,89.57 209.91,89.57 208.37,91.11 207.82,91.11 207.57,90.86 207.57,90.58 v2(207.4,90.41) ; v2(149.85,97.79) 149.6,97.54 149.6,97.43 148.26,96.09 148.26,90.4 147.85,89.98 147.85,88.84 145.31,86.31 145.31,85.55 v2(145.48,85.38)
  BOTTOM w0.076: UC1.D9 146.09,81.03 145.59,81.53 145.59,81.68 145.24,82.03 145.24,82.27 145.53,82.56 145.53,83.58 145.31,83.8 145.31,85.22 v2(145.48,85.38)
  BOTTOM w0.102: v2(207.4,90.41) 207.58,90.23 207.58,89.84 206.59,88.85 199.92,88.85 199.51,89.26 190.89,89.26 190.7,89.06 189.91,89.06 187.97,91 187.97,94.95 187.19,95.73 182.96,95.73 182.87,95.64 169.28,95.64 165.54,99.39 153.51,99.39 151.37,97.26 149.92,97.26 149.72,97.45 149.72,97.66 v2(149.85,97.79)
CPU_DPC_CTRLDAT: length 120.8
  TOP w0.102: RC145.2 143.92,87.62 143.92,87.05 145.07,85.9 145.07,85.56 v2(144.89,85.38) ; v2(232.27,88.49) 232.42,88.34 232.42,87.86 232.63,87.66 233.04,87.25 233.14,87.25 233.14,87.25 233.82,86.56 U49.9
  IN2 w0.122: v2(149.27,97.79) 149.35,97.71 149.35,97.54 148.01,96.2 148.01,90.5 147.6,90.09 147.6,88.94 145.06,86.41 145.06,85.55 v2(144.89,85.38) ; v2(232.27,88.49) 232.48,88.7 232.48,88.94 232.23,89.19 221.18,89.19 221.05,89.32 209.81,89.32 208.27,90.86 207.93,90.86 207.82,90.75 207.82,90.58 v2(207.99,90.41)
  BOTTOM w0.076: UC1.D11 145.48,80.97 145.6,80.97 145.69,81.06 145.69,81.19 145.42,81.46 145.42,81.62 145.07,81.97 145.07,82.34 145.36,82.63 145.36,83.51 145.15,83.73 145.15,85.13 v2(144.89,85.38)
  BOTTOM w0.102: v2(149.27,97.79) 149.49,97.56 149.49,97.36 149.82,97.03 151.47,97.03 153.6,99.16 165.44,99.16 169.19,95.41 182.96,95.41 183.05,95.5 187.1,95.5 187.74,94.86 187.74,90.9 189.81,88.84 190.8,88.84 190.99,89.03 199.42,89.03 199.82,88.62 206.68,88.62 207.81,89.75 207.81,90.23 v2(207.99,90.41)
CPU_PWR_DEBUG#: length 87.9
  TOP w0.102: v2(71.16,60.31) 71.15,60.31 70.79,60.31 RC108.1 ; v1(110.64,91.62) 110.32,91.94 v2(110.22,91.94)
  IN2 w0.089: v2(111.51,79.16) 111.3,79.37 111.3,81.7 111.49,81.88 111.49,82.53 111,83.02 111,85.57
  IN2 w0.122: v2(71.16,60.31) 71.98,60.31 72.5,60.84 72.5,64.24 73.44,65.18 73.44,68.88 73.14,69.19 73.14,73.26 73.48,73.6 73.48,76.38 79.35,82.25 81.64,82.25 85.28,85.9 92.73,85.9 95.4,88.57 98.73,88.57 104.38,94.22 107.62,94.22 109.09,92.76 109.67,92.76 110.22,92.21 v2(110.22,91.94) 110.22,91.75 111.43,90.54 111.43,86 111,85.57
  BOTTOM w0.076: UC1.H59 114.95,78.96 113.9,78.96 113.77,79.09 113,79.09 112.84,78.92 111.75,78.92 v2(111.51,79.16)
  BOTTOM w0.102: v2(110.22,91.94) 109.79,92.37 108.51,92.37 108.13,91.99 108.13,90.64 RC253.2 RC258.1
CPU_PWR_DEBUG#_R: length 3.1
  TOP w0.102: JXDP1.45 67.54,60.63 67.56,60.65 68.21,60.65 68.51,60.96 69.23,60.96 RC108.2
CPU_VTT_ON: length 5.1
  TOP w0.102: R305.2 28.44,29.18 28.05,28.8 27.04,28.8 v1(26.82,29.03) 26.66,29.18 24.69,29.18 24.18,29.69 U37.B17
CPU_XDP_PRDY#: length 85.5
  TOP w0.102: JXDP1.5 65.48,50.63 v2(65.31,50.8)
  IN2 w0.089: 119.02,61.14 119.35,61.47 119.35,63.35 119.74,63.73 119.74,66.83 119.02,67.54 119.02,71.15 117.15,73.02 116.81,73.02 116.61,73.23 116.18,73.23 116.03,73.08 113.46,73.08 113.02,73.52 113.02,75.86 111.43,77.44 v2(111.43,78.02)
  IN2 w0.122: v2(65.31,50.8) 65.69,50.8 66.62,51.73 68.65,51.73 69.24,51.15 73.53,51.15 74,51.62 106.19,51.62 109.27,54.71 111.55,54.71 115.91,59.07 115.91,59.72 116.76,60.57 118.46,60.57 119.02,61.14
  BOTTOM w0.076: UC1.J62 113.06,77.88 112.77,77.59 111.86,77.59 v2(111.43,78.02)
CPU_XDP_PREQ#: length 82.1
  TOP w0.102: RC120.2 68.7,50.06 68.63,50.13 JXDP1.3 65.72,50.13 65.45,50.4 65.13,50.4 64.8,50.73 64.8,51.85 v2(64.53,52.12)
  IN2 w0.089: 109.91,77.63 110.67,77.63 112.76,75.54 112.76,71.48 112.52,71.23 112.52,71.12 111.66,70.26 109.91,70.26
  IN2 w0.122: v2(108.64,78.21) 108.66,78.21 109.23,77.63 109.91,77.63 ; 109.91,70.26 109.77,70.26 109.07,69.56 109.07,66.17 106.89,63.98 106.89,60.47 99.03,52.62 75.97,52.62 75.46,53.13 66.75,53.13 65.34,51.72 64.93,51.72 v2(64.53,52.12)
  BOTTOM w0.076: UC1.K62 113.29,77.13 112.84,76.67 112.46,76.67 112.26,76.87 111.2,76.87 110.87,77.2 110.21,77.2 109.91,77.51
  BOTTOM w0.102: v2(108.64,78.21) 109.21,78.21 109.91,77.51
CPU_XDP_TCLK: length 81.6
  TOP w0.102: JXDP1.57 65.04,63.63 64.87,63.8 64.87,70.34 68.64,74.11 70.87,74.11 72.23,72.75 72.81,72.75 75.26,70.29 v5(77.41,70.29) 78.28,71.17 80.37,71.17 v2(81.06,71.87)
  IN4 w0.084: v2(114.26,80.59) 114.09,80.42 113.19,80.42 112.45,79.68 110.24,79.68 109.48,78.92 106.92,78.92 106.25,78.26 94.97,78.26 94.43,78.79 91.69,78.79 89.9,80.58 84.04,80.58 82.68,81.94 82.68,83.32 v2(82.21,83.78)
  BOTTOM w0.076: UC1.E60 114.6,80.25 v2(114.26,80.59)
  BOTTOM w0.102: v2(82.21,83.78) 82.21,83.61 81.25,82.65 81.25,80.38 81.59,80.05 81.59,78.71 80.52,77.64 80.52,76.89 81.2,76.2 81.2,72.01 v2(81.06,71.87) 80.37,71.17 RC127.2 RC124.1 RC97.1
CPU_XDP_TDI: length 58.4
  TOP w0.102: v2(82.04,72.85) v5(81.34,72.85) 79.65,72.85 78.89,72.08 78.56,72.08 78.33,72.31 UC6.6
  IN2 w0.122: v2(108.81,85.42) 108.81,88.42 105.73,91.5 104.69,91.5 103.12,89.93 103.12,88.51 99.39,84.77 99.39,82.73 97.31,80.64 94.62,80.64 91.66,77.69 86.15,77.69 85.83,77.37 85.83,74.78 84.58,73.53 83.39,73.53 82.7,72.85 v2(82.04,72.85)
  BOTTOM w0.076: UC1.F63 112.55,79.38 112.39,79.55 111.92,79.55 111.71,79.76 110.87,79.76 110.18,80.44 110.1,80.44 109.95,80.59 109.91,80.59
  BOTTOM w0.102: RC119.2 108.64,85.6 v2(108.81,85.42) 108.81,83.01 109.65,82.17 109.65,80.84 109.91,80.59
CPU_XDP_TDO: length 65.4
  TOP w0.102: UC6.3 76.83,72.18 v2(76.57,71.92) 75.91,71.26 v5(75.5,71.26)
  IN2 w0.122: v2(76.57,71.92) 77.29,72.64 81.04,72.64 81.42,73.02 81.42,76.58 83.02,78.19 91.46,78.19 94.41,81.14 97.1,81.14 98.89,82.94 98.89,84.98 102.63,88.71 102.63,90.14 104.64,92.15 108.52,92.15 v2(108.74,91.93) 109.47,91.19 109.47,89.99 109.87,89.6 109.87,82.34 v2(108.83,81.3)
  BOTTOM w0.076: UC1.F62 113.06,79.38 112.77,79.09 112.1,79.09 111.67,79.53 110.85,79.53 110.17,80.2 109.91,80.2
  BOTTOM w0.102: v2(108.74,91.93) 108.64,91.82 RC122.2 ; v2(108.83,81.3) 108.83,81.19 109.82,80.2 109.91,80.2
CPU_XDP_TMS: length 57.1
  TOP w0.102: v2(82.04,73.43) 81.43,73.43 v5(80.42,74.45) 80.29,74.57 UC6.8
  IN2 w0.122: v2(109.42,85.43) 109.42,88.16 105.83,91.75 104.59,91.75 102.88,90.03 102.88,88.61 99.14,84.88 99.14,82.83 97.2,80.89 94.51,80.89 91.56,77.94 86.05,77.94 85.58,77.47 85.58,74.91 84.45,73.78 82.88,73.78 82.52,73.43 v2(82.04,73.43)
  BOTTOM w0.076: UC1.E61 113.67,80.17 113.42,80.42 112.86,80.42 112.77,80.51 112.08,80.51 109.91,82.68
  BOTTOM w0.102: RC118.2 109.59,85.6 v2(109.42,85.43) 109.42,83.16 109.91,82.68
CPU_XDP_TRST#: length 49.6
  TOP w0.102: v2(80.62,81.84) 80.62,81.62 v5(80.32,81.32) 80.07,81.08 RC131.2 ; RC135.1 77.39,76.84 v2(77.24,76.68) 77.24,76.14 77.33,76.05 UC6.11
  IN4 w0.084: v2(77.24,76.68) 77.9,77.35 77.9,81.25 78.92,82.27 80.19,82.27 v2(80.62,81.84) 82.49,81.84 83.95,80.37 89.81,80.37 91.61,78.58 94.34,78.58 94.88,78.04 106.34,78.04 107.01,78.71 112,78.71 113.44,80.15 114.47,80.15 v2(114.91,80.59)
  BOTTOM w0.076: v2(114.91,80.59) 115.25,80.25 UC1.E59
CPUSB#: length 131.6
  TOP w0.102: v2(150.31,76.72) 150.37,76.72 151.41,77.76 152.51,77.76 152.91,77.37 156.46,77.37 157.2,76.63 v1(157.2,76.62) 157.91,76.62 RC191.2
  IN2 w0.122: v2(205,75.12) 204.14,75.12 201.57,72.54 201.57,70.26 203.27,68.56 203.27,67.26 202.88,66.87 202.88,62.28 203.51,61.65 203.51,55.49 203.21,55.19 203.21,53.64 204.03,52.83 204.03,51.78 203.76,51.52 203.76,47.08 203.17,46.49 203.17,45.06 201.8,43.69 201.8,33.98 202.27,33.5 203.34,33.5 203.81,33.03 203.81,31.77 206.15,29.44 206.15,27.83 206.55,27.43 207.45,27.43 208.31,26.57 210.78,26.57 211.81,27.6 JMINI1.40
  IN4 w0.084: v2(150.31,76.72) 150.96,76.72 151.24,77.01 152.78,77.01 153.23,77.46 158,77.46 159.42,78.88 162.49,78.88 163.68,77.69 165.1,77.69 165.32,77.91 167.87,77.91 168.55,77.23 169.85,77.23 170.51,76.57 172.08,76.57 173.96,74.69 174.96,74.69 177.01,72.63 181.31,72.63 182.2,71.75 191.31,71.75 192.71,73.14 202.76,73.14 204.51,74.9 204.78,74.9 v2(205,75.12)
  BOTTOM w0.076: UC1.K3 149.97,77.05 150.31,76.71 v2(150.31,76.72)
CS_1.35V: length 2.6
  TOP w0.203: PU11.13 v1(115.81,13.35) 115.81,13.54 116.21,13.93 PR201.2
CSN1: length 15.7
  TOP w0.203: PU500.18 92.61,72.44 93,72.05
  TOP w0.254: v2(93.04,62.06) 93.08,62.1 PR514.2 PR515.2 94.54,63.59 94.54,66.86 94.25,67.16 PC513.1 PC502.1 94.25,70.8 v1(93.33,71.72) 93,72.05
  BOTTOM w0.254: v2(93.04,62.06) 93.29,62.31 PL500.2
CSP1: length 10.5
  TOP w0.203: PU500.17 92.4,72.04 92.81,71.63
  TOP w0.254: 92.81,71.63 93.33,71.11 PC502.2 PC513.2 93.87,69.13 93.87,67.36 v1(93.65,67.14) 93.65,65.38 PH501.1 93.05,63.96 PR514.1 PR512.1
CSS_GC: length 48.1
  TOP w0.254: PR702.1 38.61,5.64 v2(38.59,5.62) ; v2(10.85,25.69) 10.66,25.69 10.24,26.1 PU800.10
  IN2 w0.254: v2(10.85,25.69) 11.48,25.69 12.15,25.02 12.15,21.67 11.57,21.08 11.57,19.13 12.38,18.31 12.38,9.61 13.01,8.99 13.55,8.99 14.65,7.89 18.18,7.89 19.44,6.62 21.34,6.62 22.09,5.88 22.09,5.58 22.58,5.08 28.6,5.08 29.05,5.53 38.5,5.53 v2(38.59,5.62)
CSSN_1: length 18.3
  TOP w0.254: PR707.1 44.49,10.32 44.37,10.44 PQ703.2 ; PR707.1 44.49,9.32 44.42,9.26 44.42,8.58 44.65,8.36 45.28,8.36 PR703.1 45.63,8.69 PR705.1 ; PR707.1 44.46,9.78 43.54,9.78 v1(43.43,9.68) 43.17,9.41 43.17,8.65 ; 43.17,8.65 43.17,7.89 42.89,7.6 PR748.2 43.74,6.26 43.74,5.99 43.22,5.47 PU703.5 ; 43.17,8.65 43.16,8.65 42.28,8.65 41.75,8.11 39.54,8.11 38.72,8.93 38.72,9.5 38.2,10.02 PQ701.3
CSSP_1: length 26
  TOP w0.102: v1(43.93,14.87) 44.37,14.43 PQ703.5
  TOP w0.254: v2(45.62,7.11) PR703.2 45.63,7.8 PR704.1 ; PQ703.5 44.37,12.93 44.82,12.48 45.26,12.48 46.15,11.59 v2(46.15,10.93) ; PQ702.3 37.59,5.96 38.28,6.64 v2(38.6,6.64) 39.04,6.64 39.2,6.49 39.31,6.49 39.65,6.15 40.05,6.15 40.39,6.49 PR749.1 41.1,6.46 PR706.1
  IN2 w0.254: v2(45.62,7.11) 46.15,7.64 v2(46.15,10.93)
  IN4 w0.254: v2(38.6,6.64) 38.6,6.96 40.31,8.67 42.58,8.67 44.8,10.9 46.12,10.9 v2(46.15,10.93)
D_CLKRUN#: length 172.8
  TOP w0.102: U37.A19 25.94,31.77 26.05,31.88 26.05,31.99 26.36,32.3 v2(27.03,32.3) 27.34,31.98 R299.2
  IN3 w0.122: v2(27.03,32.3) 27.03,32.79 29.1,34.86 36.01,34.86 38.04,36.9 38.04,39.36 38.81,40.13 41.73,40.13 42.65,39.22 45.95,39.22 47.93,41.19 47.93,42.5 50.62,45.2 55.57,45.2 60.53,50.15 60.53,63.25 63.23,65.95 63.23,76.96 66.7,80.43 70.18,80.43 72.71,82.96 72.71,84.18 73.11,84.58 73.51,84.58 75.48,86.56 81.8,86.56 84.78,89.54 88.64,89.54 90.12,91.03 92.44,91.03 93.74,92.33 95.71,92.33 98.15,94.76 100.92,94.76 103.75,97.59 109.55,97.59 109.82,97.32 112,97.32 113.19,98.51 115.26,98.51 115.53,98.78 115.53,100.85 116.62,101.93 128.34,101.93 129.68,100.59 134,100.59 134.51,100.09 134.51,97.99 135,97.5 139.16,97.5 139.76,98.1 141.92,98.1 v2(142.46,98.64)
  BOTTOM w0.102: JDOCK1.111 142.95,99.13 v2(142.46,98.64)
D_DLDRQ1#: length 178.2
  TOP w0.102: v2(23.44,33.1) 23.44,33.24 23.72,33.52 U37.B24 ; v1(145.54,98.84) 145.16,98.84 v2(145.01,98.7) ; R301.2 33.43,30.49 v2(33.43,33.81)
  IN3 w0.122: v2(23.44,33.1) 24.08,32.46 24.26,32.46 25.37,31.34 26.72,31.34 27.38,32.01 27.85,32.01 28.45,32.61 28.45,32.85 29.59,33.99 33.25,33.99 v2(33.43,33.81) 33.78,33.81 34.04,33.55 35.48,33.55 38.82,36.89 44.32,36.89 48.42,40.99 48.42,42.29 50.83,44.7 55.78,44.7 61.03,49.95 61.03,61.97 64.54,65.49 64.54,73.13 63.73,73.94 63.73,76.76 65.47,78.5 67.11,78.5 67.36,78.75 67.36,79.6 67.69,79.93 70.39,79.93 73.55,83.09 73.89,83.09 74.76,83.96 74.76,85 75.79,86.02 81.97,86.02 84.99,89.04 88.85,89.04 90.33,90.53 92.64,90.53 93.94,91.83 95.92,91.83 98.36,94.27 101.13,94.27 101.67,94.81 102.63,94.81 104.1,96.28 104.62,96.28 105.43,97.09 109.34,97.09 109.62,96.82 112.21,96.82 112.34,96.96 129.33,96.96 130.95,95.34 136.02,95.34 136.43,95.75 143.79,95.75 145.38,97.33 145.38,98.04 145.01,98.41 v2(145.01,98.7)
  BOTTOM w0.102: v2(145.01,98.7) 144.45,99.25 JDOCK1.117
D_LAD0: length 178.9
  TOP w0.102: U37.B29 24.47,36.02 24.27,35.81 v2(23.3,35.81)
  IN3 w0.122: v2(23.3,35.81) 23.09,35.6 23.09,35 23.33,34.76 25.11,34.76 26.25,35.9 27.06,35.9 27.23,35.74 27.88,35.74 28.04,35.9 31.89,35.9 34.56,38.57 34.56,40.93 39.89,46.27 55.22,46.27 58.67,49.72 58.67,57.81 57.91,58.57 57.91,59.78 58.67,60.54 58.67,62.8 62.24,66.36 62.24,76.41 61.39,77.25 61.39,79.59 64.88,83.07 71.14,83.07 71.68,83.61 71.68,85.4 72.79,86.52 72.79,87.57 73.74,88.52 75.15,88.52 75.96,89.33 83.16,89.33 84.37,90.54 88.23,90.54 91.01,93.32 95.3,93.32 97.74,95.76 100.51,95.76 103.34,98.59 110.01,98.59 110.22,98.37 111.64,98.37 116.26,102.98 128.7,102.98 129.98,101.7 138.76,101.7 139.34,101.12 139.34,99.31 138.93,98.89 136.89,98.89 v2(136.66,99.12)
  BOTTOM w0.102: v2(136.66,99.12) 136.66,98.48 137.12,98.02 v1(137.99,98.02) 138.74,98.02 139.45,98.73 JDOCK1.97
D_LAD1: length 172.2
  TOP w0.102: v2(23.52,35.18) 23.92,35.58 24.37,35.58 24.44,35.52 U37.B28 ; v2(139.93,99.29) 139.93,99.07 v1(140.22,98.78)
  IN3 w0.122: v2(139.93,99.29) 139.93,100.89 138.87,101.95 130.12,101.95 128.84,103.23 116.15,103.23 111.54,98.62 110.33,98.62 110.11,98.84 103.23,98.84 100.41,96.01 97.63,96.01 95.2,93.57 90.91,93.57 88.12,90.79 74.42,90.79 71.75,88.11 71.75,86.99 69.1,84.34 63.6,84.34 59.76,80.5 59.76,73.49 58.83,72.57 58.83,69.7 60.19,68.34 60.19,66.9 60.53,66.56 60.53,65.01 58.42,62.9 58.42,60.68 57.51,59.76 57.51,56.39 58.42,55.48 58.42,49.82 55.11,46.51 39.79,46.51 34.13,40.85 34.13,38.49 31.78,36.15 27.94,36.15 27.77,35.99 27.33,35.99 27.17,36.15 25.8,36.15 25.36,35.71 24.05,35.71 v2(23.52,35.18)
  BOTTOM w0.102: v2(139.93,99.29) 139.95,99.31 JDOCK1.99
D_LAD2: length 169.9
  TOP w0.102: v2(27.03,34.18) 27,34.18 26.41,34.77 U37.A25
  IN3 w0.122: v2(27.03,34.18) 28.46,35.61 31.95,35.61 35.52,39.18 35.52,40.38 37.71,42.56 37.71,43.28 40.37,45.94 47.36,45.94 48.16,45.14 49.51,45.14 50.31,45.94 55.25,45.94 58.92,49.62 58.92,57.92 58.6,58.24 58.6,60.03 58.92,60.35 58.92,62.7 62.48,66.26 62.48,77.46 63.56,78.53 63.56,81.24 65.14,82.82 71.24,82.82 71.93,83.51 71.93,85.24 73.05,86.36 73.05,87.43 73.84,88.21 75.26,88.21 76.12,89.08 83.26,89.08 84.47,90.29 88.33,90.29 91.12,93.07 95.4,93.07 97.84,95.51 100.61,95.51 103.44,98.34 109.9,98.34 110.12,98.12 111.75,98.12 116.31,102.68 128.65,102.68 129.99,101.34 135.27,101.34 136.07,100.54 136.07,98.83 136.65,98.25 138.82,98.25 139.45,98.87 140.72,98.87 141.1,99.25 v2(141.1,99.31)
  BOTTOM w0.102: v1(140.7,97.97) 140.7,98.84 141.1,99.24 v2(141.1,99.31) 140.95,99.46 JDOCK1.103
D_LAD3: length 169.8
  TOP w0.102: v2(26.38,34.18) 26.29,34.27 U37.A24 ; v1(142.63,97.88) 141.71,98.8 v2(141.38,98.8)
  IN3 w0.122: v2(26.38,34.18) 26.81,33.76 27.29,33.76 28.9,35.36 35.8,35.36 37.54,37.1 37.54,39.57 38.61,40.63 41.94,40.63 42.85,39.71 45.74,39.71 47.43,41.4 47.43,42.71 50.42,45.69 55.35,45.69 59.17,49.51 59.17,52.71 60.03,53.57 60.03,63.45 62.73,66.16 62.73,77.36 65.13,79.75 65.13,80.87 66.84,82.57 71.34,82.57 72.21,83.45 72.21,84.86 72.66,85.31 73.53,85.31 75.28,87.06 81.59,87.06 84.57,90.04 88.43,90.04 91.22,92.82 95.5,92.82 97.94,95.26 100.71,95.26 103.54,98.09 109.75,98.09 110.03,97.81 111.79,97.81 116.41,102.43 128.54,102.43 129.89,101.09 134.24,101.09 135.13,100.2 135.13,98.65 135.78,98 138.93,98 139.55,98.62 141.2,98.62 v2(141.38,98.8)
  BOTTOM w0.102: v2(141.38,98.8) 141.38,98.8 141.38,98.81 141.5,98.93 141.5,99.61 141.45,99.66 JDOCK1.105
D_LFRAME#: length 171.9
  TOP w0.102: v2(24.05,33.09) 24.7,33.09 U37.B23
  IN3 w0.122: v2(24.05,33.09) 24.42,33.46 27.35,33.46 29,35.11 35.9,35.11 37.79,37 37.79,39.46 38.71,40.38 41.84,40.38 42.75,39.47 45.85,39.47 47.68,41.3 47.68,42.6 50.52,45.45 55.47,45.45 60.28,50.26 60.28,63.35 62.98,66.05 62.98,77.07 66.59,80.68 70.08,80.68 72.46,83.06 72.46,84.76 72.76,85.06 73.63,85.06 75.38,86.81 81.69,86.81 84.68,89.79 88.54,89.79 91.32,92.58 95.61,92.58 98.05,95.01 100.82,95.01 103.64,97.84 109.65,97.84 109.92,97.57 111.9,97.57 113.09,98.76 114.12,98.76 114.54,99.17 114.54,100.21 116.51,102.18 128.44,102.18 129.79,100.84 134.11,100.84 134.75,100.19 134.75,98.09 135.1,97.75 139.03,97.75 139.63,98.35 141.62,98.35 141.86,98.59 141.86,98.96 142.13,99.22 v2(142.38,99.22)
  BOTTOM w0.102: JDOCK1.109 142.45,99.29 v2(142.38,99.22)
D_SERIRQ: length 168.4
  TOP w0.102: R300.2 28.12,32.87 v2(27.67,32.42) 27.36,32.74 26.78,32.74 26.59,32.55 26.29,32.55 26.01,32.27 U37.A20 ; v2(143.92,99.04) 143.92,99.36 v1(144.12,99.57)
  IN3 w0.122: v2(143.92,99.04) 143.92,98.44 143.4,97.92 143.4,96.91 142.98,96.5 136.12,96.5 135.71,96.08 131.29,96.08 129.67,97.7 115.63,97.7 115.08,98.26 113.29,98.26 112.1,97.07 109.72,97.07 109.44,97.34 105.31,97.34 104.5,96.53 103.04,96.53 101.02,94.52 98.25,94.52 95.81,92.08 93.84,92.08 92.54,90.78 90.23,90.78 88.74,89.29 84.88,89.29 81.9,86.31 75.69,86.31 73.72,84.33 73.22,84.33 72.96,84.08 72.96,82.86 70.29,80.18 66.8,80.18 63.48,76.86 63.48,65.85 60.78,63.15 60.78,50.05 55.67,44.95 50.73,44.95 48.17,42.4 48.17,41.09 44.22,37.13 38.71,37.13 35.38,33.8 34.15,33.8 33.71,34.24 29.49,34.24 v2(27.67,32.42)
  BOTTOM w0.102: v2(143.92,99.04) 143.91,99.04 143.95,99.09 JDOCK1.115
DAI_12MHZ#: length 219.2
  TOP w0.102: R137.1 281.29,29.69 281.32,29.72 v2(281.41,29.72) ; v2(180.85,90.22) 180.85,89.88 180.7,89.72 180.21,89.72 179.92,89.43 177.85,89.43 177.56,89.72 175.49,89.72 171.67,93.55 168.14,93.55 163.48,98.21 153.31,98.21 v1(152.07,99.44) 148.21,103.3 148.21,105.54 147.83,105.92 137.47,105.92 136.78,105.23 v2(136.78,103.99)
  IN2 w0.122: v2(180.85,90.22) 180.86,90.22 182.29,91.66 184.42,91.66 184.82,92.06 185.15,92.06 185.93,92.84 187.39,92.84 188.52,93.97 196.76,93.97 197.74,92.99 203.06,92.99 203.23,93.16 212.4,93.16 v2(213.18,93.94)
  IN3 w0.122: v2(281.41,29.72) 281.41,29.99 278.75,32.65 278.75,40.74 276.92,42.57 276.92,48.14 271.21,53.85 270.26,53.85 269.23,54.88 269.23,74.05 268.7,74.58 268.7,82.58 266.2,85.08 262.68,85.08 259.89,87.87 243.83,87.87 240.97,90.73 235.84,90.73 235.45,91.12 235.45,91.62 v2(235.71,91.88)
  IN4 w0.084: v2(213.18,93.94) 213.35,93.94 214.4,95 220.92,95 222.43,93.48 225.32,93.48 225.49,93.32 225.49,92.54 225.72,92.32 226.4,92.32 227.34,93.26 233.64,93.26 235.01,91.88 v2(235.71,91.88)
  BOTTOM w0.102: v2(136.78,103.99) 136.45,103.66 JDOCK1.89 136.45,99.52 135.79,98.86 135.79,98.4 RE4.1
DAI_BCLK#: length 213.4
  TOP w0.102: R139.1 v2(281.41,30.58)
  IN1 w0.084: v2(230.37,91.88) 230.64,91.88 231.2,92.44 239.55,92.44 239.95,92.04 239.95,91.33 v2(239.84,91.21)
  IN3 w0.122: v2(133.63,98.58) 133.63,97.28 134.08,96.83 135.4,96.83 135.82,97.25 139.31,97.25 139.92,97.86 142.28,97.86 142.96,98.54 142.96,99.5 144.23,100.77 147.33,100.77 148.49,99.62 148.49,98.84 148.82,98.51 151.71,98.51 153.39,96.84 156.87,96.84 158,95.71 166.68,95.71 169.04,93.35 180.62,93.35 181.07,93.8 182.34,93.8 184.47,95.93 187.38,95.93 188.18,96.73 199.92,96.73 202.84,93.8 205.43,93.8 205.74,93.49 217.15,93.49 217.5,93.84 220.75,93.84 221.38,93.2 226.46,93.2 227.78,91.88 v2(230.37,91.88) ; v2(281.41,30.58) 279,32.99 279,40.84 277.6,42.24 277.17,42.67 277.17,48.25 269.48,55.94 269.48,74.15 268.95,74.68 268.95,82.79 266.41,85.33 262.78,85.33 259.99,88.12 243.93,88.12 240.84,91.21 v2(239.84,91.21)
  BOTTOM w0.102: JDOCK1.77 133.45,98.76 v2(133.63,98.58) 133.63,98.06 133.19,97.61 132.73,97.61 RE5.1
DAI_DI: length 198.5
  TOP w0.102: R144.1 278.54,40.31 277.85,40.31 277.58,40.58 277.58,41.24 277.13,41.69 v2(276.72,41.69) ; v2(134.95,104.04) 134.56,103.64 v1(134.3,103.64)
  IN3 w0.122: v2(276.72,41.69) 276.42,41.99 276.42,46.93 275.37,47.98 275.37,48.98 271.01,53.35 270.06,53.35 268.73,54.68 268.73,73.84 268.2,74.37 268.2,81.53 268.2,81.53 268.2,82.24 265.94,84.5 261.55,84.5 260.17,85.87 242.68,85.87 240.62,87.93 240.62,89.01 239.47,90.16 233.88,90.16 233.28,90.77 231.42,90.77 230.98,91.21 230.98,92.07 230.75,92.3 227.71,92.3 226.56,93.46 221.48,93.46 220.65,94.28 217.48,94.28 217.08,94.68 212.89,94.68 212.35,94.14 202.85,94.14 200.02,96.98 188.07,96.98 187.28,96.18 184.37,96.18 182.24,94.05 180.97,94.05 180.51,93.6 169.14,93.6 166.42,96.33 161.12,96.33 161.1,96.34 158.07,96.34 157.29,97.12 153.51,97.12 147.64,102.99 136,102.99 v2(134.95,104.04)
  BOTTOM w0.102: v2(134.95,104.04) JDOCK1.83
DAI_DO#: length 208
  TOP w0.102: v1(135.97,104.57) 135.59,104.19 v2(135.59,104.01) ; R142.1 v2(281.42,31.47)
  IN2 w0.122: v2(278.02,40.72) 278.52,40.72 279.2,40.04 279.2,33.69 v2(281.42,31.47)
  IN3 w0.122: v2(135.59,104.01) 135.59,103.94 136.28,103.24 147.75,103.24 153.61,97.37 157.39,97.37 158.17,96.59 161.21,96.59 161.23,96.57 166.52,96.57 169.25,93.85 180.41,93.85 180.86,94.3 182.14,94.3 184.27,96.43 187.18,96.43 187.97,97.22 200.12,97.22 202.96,94.39 212.25,94.39 212.79,94.93 217.32,94.93 217.72,94.53 220.76,94.53 221.25,94.04 224.41,94.04 224.96,94.59 225.8,94.59 227.82,92.56 233.15,92.56 233.5,92.21 233.5,91.52 234.02,90.99 235.15,90.99 235.7,90.45 240.77,90.45 245.08,86.13 260.3,86.13 261.65,84.78 266.09,84.78 268.45,82.42 268.45,74.47 268.98,73.95 268.98,54.78 270.16,53.6 271.11,53.6 276.67,48.04 276.67,42.47 278.02,41.12 v2(278.02,40.72)
  BOTTOM w0.102: JDOCK1.85 135.45,103.88 v2(135.59,104.01)
DAI_LRCK#: length 212.3
  TOP w0.102: R143.1 v2(281.43,32.36) ; v1(134.01,105.55) 134.44,105.12 v2(134.44,104.95)
  IN3 w0.122: v2(134.44,104.95) 135.43,105.94 143.71,105.94 145.4,104.25 147.17,104.25 153.8,97.62 160.7,97.62 161.49,96.82 166.69,96.82 169.42,94.1 180.23,94.1 180.76,94.63 182.1,94.63 185.68,98.21 200.22,98.21 201.5,96.92 204.1,96.92 205.24,95.78 213.31,95.78 213.75,95.35 217.47,95.35 217.98,94.83 222.46,94.83 223.28,95.65 223.87,95.65 224.68,94.84 225.9,94.84 227.93,92.81 232.06,92.81 232.12,92.87 239.53,92.87 244.03,88.37 260.09,88.37 262.89,85.57 266.58,85.57 270.02,82.14 270.02,77.61 269.39,76.99 269.39,74.59 269.73,74.26 269.73,56.04 273.88,51.89 274.88,51.89 275.36,51.41 275.36,50.41 277.42,48.35 277.42,42.78 279.25,40.95 279.25,33.37 280.26,32.36 v2(281.43,32.36)
  BOTTOM w0.102: v2(134.44,104.95) 134.44,103.78 133.95,103.29 JDOCK1.79
DAT_DDC2_DOCK: length 118.2
  TOP w0.102: v2(214.77,81.67) 214.82,81.62 R81.2
  IN1 w0.084: v2(124.41,110.01) 124.62,109.8 124.62,107.49 125.26,106.85 139,106.85 140.38,105.47 140.38,104.54 141.82,103.1 144.32,103.1 148.32,99.1 148.32,97.81 150.54,95.59 155.16,95.59 156.47,94.29 165.35,94.29 167.43,92.2 181.97,92.2 185.11,95.34 187.3,95.34 188.87,96.91 194.45,96.91 195.76,95.59 195.76,95.23 196.24,94.76 200.75,94.76 204.05,91.46 204.05,90.31 206.95,87.42 206.95,85.79 206.1,84.94 206.1,83.06 205.76,82.71 205.5,82.71 v2(205.35,82.87)
  IN2 w0.122: v2(214.77,81.67) 214.89,81.55 214.89,81.23 214.79,81.13 213.22,81.13 211.65,82.7 205.51,82.7 v2(205.35,82.87)
  BOTTOM w0.102: JDOCK1.46 124.45,109.6 124.59,109.74 124.59,109.83 v2(124.41,110.01)
DAT_KBD: length 205.8
  TOP w0.102: U38.B41 25.69,18.89 25.55,18.76 25.55,18.39 25.46,18.3 v2(25.46,18.07) ; R355.2 37.45,21.88 v2(37.71,21.63)
  IN1 w0.084: v2(45.94,21.77) 46.09,21.92 46.41,21.92 46.75,22.27 46.75,24.99 49.23,27.46 49.23,28.31 50.24,29.33 51.91,29.33 52.42,28.82 54.68,28.82 56.4,30.54 58.23,30.54 59.23,31.54 59.23,38.13 57.64,39.72 57.64,47.54 58.94,48.83 58.94,55.11 60.89,57.06 60.89,64.62 62.54,66.27 62.54,69.25 59.92,71.87 59.92,77.78 63.38,81.25 63.91,81.25 67.62,84.96 67.62,86.87 72.14,91.38 83.14,91.38 83.9,90.63 88.33,90.63 91.26,93.56 102.9,93.56 105.24,95.9 114.52,95.9 117.04,98.42 117.04,107.26 115.06,109.24 112.24,109.24 112.04,109.04 112.04,108.47 v2(111.84,108.27)
  IN4 w0.084: v2(25.46,18.07) 25.46,18.35 26.66,19.54 28.85,19.54 29.73,20.42 31.84,20.42 32.12,20.14 36.48,20.14 37.71,21.37 v2(37.71,21.63) 37.71,21.84 37.92,22.05 38.81,22.05 38.91,21.95 45.76,21.95 v2(45.94,21.77)
  BOTTOM w0.102: v2(111.84,108.27) 112.04,108.47 112.04,111.27 112.63,111.86 132.89,111.86 133.81,110.94 133.81,109.74 133.95,109.6 JDOCK1.80
DAT_MSE: length 182.9
  TOP w0.102: R357.2 36.06,21.93 v2(36.06,21.75) ; U38.B42 25.19,18.43 24.23,17.47 v2(23.93,17.47)
  IN1 w0.084: v2(64.08,80.5) 64.3,80.73 64.3,81.17 67.83,84.7 67.83,86.78 72.22,91.17 82.97,91.17 83.73,90.42 88.41,90.42 91.35,93.35 102.99,93.35 105.04,95.4 114.69,95.4 121.58,102.29 126.96,102.29 129.01,100.24 131.81,100.24 132.25,99.8 132.25,98.3 v2(132.47,98.09)
  IN4 w0.084: v2(23.93,17.47) 24.04,17.47 24.99,18.42 24.99,19.31 25.58,19.9 25.58,21.5 26.12,22.05 28.28,22.05 29.06,21.26 32.19,21.26 32.47,20.98 35.51,20.98 36.06,21.53 v2(36.06,21.75) 36.38,21.75 37.54,22.92 38.69,22.92 40.07,24.3 42.91,24.3 43.46,23.75 45.7,23.75 48.71,26.76 48.71,28.69 50.78,30.77 50.78,34.27 60.89,44.38 61.51,44.38 63.16,46.04 63.16,48.62 61.36,50.42 61.36,64.71 63.21,66.57 63.21,73.94 65.78,76.51 65.78,77.05 64.2,78.63 64.2,80.34 64.2,80.35 64.2,80.38 v2(64.08,80.5)
  BOTTOM w0.102: JDOCK1.73 132.45,99.75 132.29,99.6 132.29,98.27 v2(132.47,98.09)
DAT_TP_SIO: length 206.1
  TOP w0.102: U38.B40 26.19,18.99 25.87,18.67 25.87,17.89 v2(25.46,17.47) ; v2(191.65,19.35) 191.5,19.21 191.5,19 191.81,18.7 191.81,17.6 192.04,17.37 R441.1
  IN1 w0.084: v2(191.65,19.35) 191.46,19.17 191.46,18.22 190.68,17.44 170.36,17.44 169.51,18.29 135.07,18.29 130.6,22.76 123.72,22.76 122.78,21.82 122.78,20.75 119.98,17.95 99.68,17.95 98.4,19.23 98.4,26.29 97.95,26.74 62.62,26.74 60.86,24.98 58.2,24.98 56.67,23.46 52.38,23.46 51.92,23 51.92,22.12 50.18,20.38 50.18,18.05 44.98,12.86 44.98,9.68 42.51,7.21 40.49,7.21 40.08,7.61 38,7.61 36.77,6.38 35.31,6.38 34.84,6.85 32.94,6.85 31.6,8.19 29.38,8.19 27.78,9.8 26.56,9.8 25.75,10.61 25.75,17.18 v2(25.46,17.47)
DC_BLOCK_GC: length 56.4
  TOP w0.254: PU800.7 v2(7.78,24.23) ; v2(45.16,36.19) 45.16,35.39 v1(48.05,32.5) 48.76,31.79 v2(49.56,31.79)
  BOTTOM w0.254: PR701.2 49.56,30.47 v2(49.56,31.79) ; v2(7.78,24.23) 9.32,24.23 10.25,25.16 11.25,25.16 13.3,23.11 23.71,23.11 24.42,22.4 29.45,22.4 32.08,25.03 32.08,25.74 33.08,26.75 33.08,29.83 36.75,33.5 42.28,33.5 44.97,36.19 v2(45.16,36.19)
DC_IN_SS: length 1.5
  TOP w0.254: PU800.34 2.37,27.1 PR831.2
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.076: UC1.A3 150.02,82.69 UC1.B3
DC_TEST_A4: length 6.2
  BOTTOM w0.076: 149.97,85.57 149.97,83.92 149.38,83.33 UC1.A4
  BOTTOM w0.102: RC254.1 150.93,88.33 150.93,87.25 150.53,86.85 v1(150.53,86.74) 150.53,86.19 149.97,85.64 149.97,85.57
DC_TEST_A60: length 5.4
  BOTTOM w0.076: UC1.A60 114.55,82.91 112.57,84.89 112.57,85.57
  BOTTOM w0.102: 112.57,85.57 v1(112.57,86) 112.57,86.09 RC266.1
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.076: UC1.A61 113.89,82.22 UC1.B61
DC_TEST_A62: length 4
  BOTTOM w0.076: UC1.A62 113.24,82.81 112.07,83.98 112.07,85.57
  BOTTOM w0.102: 112.07,85.57 112.07,85.69 RC266.2
DC_TEST_AV1: length 5.2
  BOTTOM w0.076: 153.85,59.55 153.8,59.5 152.11,59.5 151.87,59.74 151.87,61.35 151.72,61.5 UC1.AV1
  BOTTOM w0.102: RC268.1 153.85,59.55
DC_TEST_AW1: length 5
  BOTTOM w0.076: 153.85,59.09 153.53,58.78 152.96,58.78 152.9,58.71 152.64,58.71 152.51,58.84 151.82,58.84 151.27,59.38 UC1.AW1
  BOTTOM w0.102: 153.85,59.09 153.96,59.21 RC268.2
DC_TEST_AW63: length 8
  BOTTOM w0.076: UC1.AW63 112.65,58.99 111.23,57.57 110.99,57.57 109.81,56.39 109.81,55.96 RC269.1
  BOTTOM w0.102: v1(108.19,55.96) 108.55,55.6 RC269.1
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.076: UC1.AY2 150.61,60.3 UC1.AW2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.076: UC1.AW3 150.01,60.79 UC1.AY3
DC_TEST_AY60: length 8.8
  BOTTOM w0.076: v1(112.51,55.65) 112.46,55.6 RC269.2 110.21,55.75 110.21,56.22 111.14,57.16 111.33,57.16 114.36,60.19 UC1.AY60
DC_TEST_AY61_AW61: length 0.7
  BOTTOM w0.076: UC1.AY61 113.87,60.76 UC1.AW61
DC_TEST_AY62_AW62: length 0.7
  BOTTOM w0.076: UC1.AY62 113.21,60.75 UC1.AW62
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.076: UC1.B63 112.78,82.09 UC1.B62
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.076: UC1.C1 151.15,81.56 UC1.C2
DDI1_LANE_N0: length 100.2
  IN1 w0.091: v2(190.8,91.22) 190.7,91.12 190.3,91.12 189.3,90.12 189.3,89.23 188.62,88.55 188.62,87.69 186.54,85.62 186,85.62 185.58,86.03 183.72,86.03 183.48,85.79 170.61,85.79 169.45,86.95 166.39,86.95 165.04,88.3 163.71,88.3 162.34,89.67 154.6,89.67 152.02,92.25 149.24,92.25 146.05,95.44 144.99,95.44 144.75,95.68 123.09,95.68 121.86,94.45 121.86,91.21 122.33,90.73 122.33,89.91 121.98,89.55 119.36,89.55 117.48,87.68 117.48,85.53 117.66,85.34 117.98,85.34 v2(118.12,85.2)
  BOTTOM w0.076: v2(118.12,85.2) 118.08,85.24 117.15,85.24 116.83,84.92 116.83,84.07 117.59,83.3 117.59,82.74 117.65,82.62 117.65,82.4 117.62,82.32 117.61,82.31 117.59,82.25 117.59,82.12 117.62,82.01 117.83,81.81 118,81.81 118.17,81.63 UC1.C54
  BOTTOM w0.102: C272.2 189.93,93.7 189.93,91.39 190.21,91.11 190.69,91.11 v2(190.8,91.22)
DDI1_LANE_N1: length 100.6
  IN1 w0.084: v2(115.11,84.55) 115.11,84.56 114.82,84.85 114.73,84.85 114.54,85.04 114.54,85.32 114.42,85.44 114.42,85.44 114.31,85.55 114.31,85.57
  IN1 w0.091: 114.31,85.57 114.31,89.28 115.7,90.67 115.7,92.77 120.55,97.62 137.71,97.62 138.39,98.29 142.14,98.29 142.35,98.08 142.88,98.08 143.1,98.29 144.96,98.29 145.88,97.38 146.86,97.38 149.95,94.28 154.31,94.28 156.14,92.45 157.73,92.45 157.94,92.24 164.48,92.24 167.62,89.1 173.9,89.1 175.27,87.73 182.41,87.73 182.65,87.97 184.87,87.97 185.58,88.67 185.58,88.93 187.36,90.71 187.36,91.62 189.63,93.9 191.88,93.9 192.08,93.7 192.08,93.5 v2(192.27,93.31)
  BOTTOM w0.076: v2(115.11,84.55) 115.24,84.68 115.48,84.68 115.75,84.42 115.75,83.6 116.04,83.31 116.04,81.94 UC1.B58
  BOTTOM w0.102: v2(192.27,93.31) 192.09,93.49 192.09,93.65 192.38,93.94 C270.2
DDI1_LANE_N2: length 101.8
  IN1 w0.084: v2(117.46,84.82) 117.32,84.67 117.07,84.67 116.93,84.81 116.93,85.17 116.93,85.18 116.93,85.5 116.93,85.5 116.93,85.55 116.94,85.55 116.94,85.57
  IN1 w0.091: v2(196.86,93.03) 196.76,92.93 196.76,92.39 196.39,92.02 190.53,92.02 188.83,90.31 188.83,89.43 188.15,88.75 188.15,88.14 187.56,87.56 186.55,87.56 185.49,86.5 183.48,86.5 183.24,86.26 171.62,86.26 170.26,87.63 166.98,87.63 164.47,90.14 154.81,90.14 152.14,92.81 149.35,92.81 146.25,95.91 145.23,95.91 144.98,96.15 121.45,96.15 117.91,92.61 117.91,89.7 116.94,88.73 116.94,85.57
  BOTTOM w0.076: v2(117.46,84.82) 117.6,84.68 117.94,84.68 118.13,84.5 118.13,83.26 118.36,83.03 118.36,82.57 118.19,82.4 117.96,82.4 117.88,82.32 UC1.B55
  BOTTOM w0.102: v2(196.86,93.03) 196.86,93.35 C209.2
DDI1_LANE_N3: length 100.5
  IN1 w0.091: v2(194.3,93.29) 194.11,93.09 194.11,92.89 193.88,92.66 189.56,92.66 188.18,91.28 188.18,89.7 187.42,88.93 186.74,88.93 186.42,88.62 186.42,88.36 185.22,87.15 183.21,87.15 182.97,86.91 174.94,86.91 173.56,88.28 167.28,88.28 164.19,91.37 157.62,91.37 157.36,91.63 155.79,91.63 153.96,93.46 149.61,93.46 146.52,96.56 145.49,96.56 145.25,96.8 120.96,96.8 116.62,92.46 116.62,90.35 116.19,89.93 116.19,86.66 115.63,86.1 115.48,86.1 115.16,85.79 v2(115.16,85.77)
  BOTTOM w0.076: 116.17,83.81 116.17,83.8 116.18,83.79 116.18,83.73 116.3,83.61 116.32,83.61 116.83,83.1 116.83,82.81 116.67,82.65 116.55,82.65 116.5,82.7 UC1.A57
  BOTTOM w0.102: v2(115.16,85.77) 115.16,85.78 115.44,86.05 115.59,86.05 115.86,85.79 v3(115.86,85.43) 115.86,84.97 116.17,84.67 116.17,83.81 ; C191.2 194.3,93.44 v2(194.3,93.29)
DDI1_LANE_P0: length 100.2
  IN1 w0.091: v2(190.8,90.63) 190.8,90.64 190.48,90.95 190.37,90.95 189.47,90.05 189.47,89.16 188.79,88.48 188.79,87.62 186.61,85.45 185.93,85.45 185.51,85.86 183.79,85.86 183.55,85.62 170.54,85.62 169.38,86.78 166.32,86.78 164.97,88.13 163.63,88.13 162.27,89.5 154.53,89.5 151.95,92.08 149.17,92.08 145.98,95.27 144.91,95.27 144.67,95.51 123.16,95.51 122.03,94.38 122.03,91.28 122.5,90.8 122.5,89.84 122.05,89.38 119.43,89.38 117.65,87.6 117.65,85.6 117.73,85.52 117.86,85.52 v2(118.12,85.78)
  BOTTOM w0.076: 117.91,85.57 117.8,85.45 117.07,85.45 116.64,85.02 116.64,83.99 117.42,83.2 117.42,82.7 117.48,82.54 117.48,82.43 117.44,82.31 117.42,82.28 117.42,82.09 117.47,81.94 117.56,81.79 UC1.C55
  BOTTOM w0.102: 117.91,85.57 v2(118.12,85.78) ; C271.2 189.71,93.45 189.71,91.3 190.12,90.89 190.53,90.89 v2(190.8,90.63)
DDI1_LANE_P1: length 100.8
  IN1 w0.084: 114.53,85.57 114.71,85.39 114.71,85.11 114.8,85.01 114.99,85.01 v2(115.11,85.13)
  IN1 w0.091: 114.53,85.57 114.48,85.62 114.48,89.21 115.88,90.6 115.88,92.69 120.63,97.44 137.78,97.44 138.46,98.12 142.07,98.12 142.28,97.91 142.96,97.91 143.17,98.12 144.89,98.12 145.81,97.2 146.78,97.2 149.88,94.1 154.24,94.1 156.07,92.28 157.66,92.28 157.87,92.07 164.4,92.07 167.54,88.93 173.83,88.93 175.2,87.56 182.49,87.56 182.72,87.79 184.95,87.79 185.75,88.6 185.75,88.86 187.53,90.63 187.53,91.55 189.7,93.73 191.81,93.73 191.88,93.65 191.88,93.5 v2(191.69,93.31)
  BOTTOM w0.076: UC1.C58 115.94,81.38 116.26,81.7 116.26,81.95 116.21,82 116.21,83.41 115.94,83.68 115.94,84.5 115.56,84.87 115.37,84.87 v2(115.11,85.13)
  BOTTOM w0.102: C269.2 191.87,93.57 191.87,93.49 v2(191.69,93.31)
DDI1_LANE_P2: length 101.9
  IN1 w0.084: 116.76,85.57 116.76,85.11 116.77,85.1 116.77,84.74 117.01,84.51 117.26,84.51 117.46,84.3 v2(117.46,84.23)
  IN1 w0.091: v2(196.27,93.03) 196.59,92.71 196.59,92.46 196.31,92.19 190.46,92.19 188.65,90.39 188.65,89.5 187.97,88.82 187.97,88.22 187.49,87.73 186.48,87.73 185.42,86.68 183.41,86.68 183.17,86.43 171.7,86.43 170.33,87.8 167.05,87.8 164.54,90.31 154.88,90.31 152.21,92.99 149.42,92.99 146.32,96.09 145.3,96.09 145.06,96.33 121.38,96.33 117.73,92.68 117.73,89.77 116.76,88.8 116.76,85.57
  BOTTOM w0.076: UC1.A55 117.88,82.65 117.96,82.58 118.13,82.58 118.2,82.64 118.2,82.96 117.94,83.22 117.94,84.42 117.86,84.49 117.72,84.49 v2(117.46,84.23)
  BOTTOM w0.102: C199.2 196.63,93.47 196.63,93.39 v2(196.27,93.03)
DDI1_LANE_P3: length 100.6
  IN1 w0.091: v2(115.16,86.35) 115.25,86.27 115.56,86.27 116.02,86.73 116.02,90 116.45,90.43 116.45,92.53 120.88,96.97 145.32,96.97 145.57,96.73 146.59,96.73 149.69,93.63 154.03,93.63 155.86,91.8 157.43,91.8 157.7,91.54 164.26,91.54 167.35,88.45 173.63,88.45 175.01,87.08 182.9,87.08 183.14,87.32 185.14,87.32 186.25,88.43 186.25,88.69 186.67,89.1 187.34,89.1 188.01,89.77 188.01,91.35 189.49,92.83 193.81,92.83 193.93,92.96 193.93,93.08 v2(193.72,93.29)
  BOTTOM w0.076: 116.38,83.81 117.02,83.17 117.02,82.73 116.5,82.21 UC1.B57
  BOTTOM w0.102: v2(193.72,93.29) 193.85,93.42 C103.2 ; v2(115.16,86.35) 115.25,86.27 115.68,86.27 116.08,85.88 116.08,85.06 116.38,84.76 116.38,83.81
