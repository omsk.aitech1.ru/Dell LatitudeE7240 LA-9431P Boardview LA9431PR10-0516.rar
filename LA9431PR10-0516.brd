# Allegro board LA9431PR10-0516.brd (continued)
## Nets (continued)
Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JEDP1 10 23 28; JHDMI1 14; JKBTP1 6 13; JMEDIA 1 2; JMINI1 3 5 6 8 10 12 28 30 48; JMINI2 3 5 6 17 19 28 37 40 45 46 47 48 49; JMINI3 1 3 5 6 7 11 13 20 22 28 30 32 36 38 42 43 45 46 47 48 49; JSF1 2 4; JTAA1 5 6 15 16; JUSH1 11 12; JXDP1 40 42; PQ802 3 4 5; PRP2 4 5; PU400 7; PU500 5; PU700 4; PU800 20 30 31 36; Q17 3 4 5; Q20 1 2 6; Q28 3 4 5; Q33 3 4 5; RP2 5; U5 1; U6 A5 K2 L2 L10 L11 L12 L13 M1 M2 M10 M11; U17 19 20 30; U23 5; U25 6 7 9 12 13 14; U27 19 39 40 44 46; U33 8 13 17; U37 A2 A15 A16 A23 A32 A42 A49 A52 A55 A56 A57 A59 A60 B1 B11 B68; U38 A15 A45 B15 B16; UC1 A21 A23 A31 A35 A41 A43 A49 AC2 AC20 AD5 AL2 AL32 AP32 AU12 AV10 AV50 AW10 AW49 AY8 AY42 AY43 B14 B21 B22 B23 B31 B35 B41 B49 C4 C15 C21 C42 C43 C46 C47 E6 E8 F6 F8 F15 G1 G2 G10 G15 H6 H10 J2 J4 J6 K4 K18 L3 M20 R5 V21 Y20; UC4 1; YC2 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 760 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 5039 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 465 vias
v4: diameter 0.432, hole 0.178, TOP to BOTTOM, 60 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 134 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.675V_DDR_VTT_ON: length 41.6
  TOP w0.254: 127.18,29.45 127.19,29.44 R28.2 128.63,29.44 R32.2 ; 127.18,29.45 127.18,30.1 124.43,32.84 QD1.2 ; 127.18,29.45 126.76,29.45 v2(126.44,29.13) 126.31,29.01 126.31,27.32 126.81,26.82 U5.4 ; v2(121.41,9.73) 121.6,9.54 v1(121.6,8.81) 120.97,8.18 PR210.1
  IN4 w0.254: v2(121.41,9.73) 121.1,9.73 120.14,10.69 120.14,15.86 121.11,16.82 121.11,21.21 120.34,21.98 120.34,23.81 121.55,25.02 122.43,25.02 123.91,26.5 123.91,26.6 v2(126.44,29.13)
1.05V_A_PWRGD: length 287.1
  TOP w0.102: U38.B28 29.17,15.58 28.64,15.05 v2(28.51,15.05) ; v2(240.24,81.38) 240.24,80.96 v1(240,80.72)
  TOP w0.254: PR300.2 238.82,72.15 v2(238.91,72.23) 238.99,72.31 238.99,72.95 238.86,73.08 PU300.1
  IN3 w0.122: v2(240.24,81.38) 239.99,81.64 224.31,81.64 223.08,80.41 214.18,80.41 210.12,76.35 209.66,76.35 209.6,76.42 208.98,76.42 207.85,75.28 206.62,75.28 205.54,74.2 204.14,74.2 202.15,72.21 201.88,72.21 200.51,70.84 200.51,68.03 201.05,67.49 201.93,67.49 202.76,66.66 202.76,63.95 202.88,63.83 202.88,56.5 202.18,55.8 202.18,51.54 203.79,49.92 203.79,46.78 204.35,46.23 204.35,44.67 200.98,41.3 199.2,41.3 198.52,40.62 197.83,40.62 194.22,37.01 190.56,37.01 189.57,36.02 187.88,36.02 187.62,35.76 186.54,35.76 185.73,36.57 137.2,36.57 133.03,32.4 133.03,31.07 131.86,29.9 131.17,29.9 129.89,28.62 128.77,28.62 126.62,26.47 122.54,26.47 122.04,26.97 122.04,29.87 117.25,34.66 62.63,34.66 61.84,33.87 56.88,33.87 55.87,32.87 52.84,32.87 50.31,30.33 47.64,30.33 45.95,28.65 45.01,28.65 42,25.65 42,24.82 39.45,22.27 39.45,19.63 37.55,17.72 35.75,17.72 34.49,16.47 34.49,15.75 34.29,15.54 33.13,15.54 32.64,15.05 v2(28.51,15.05)
  BOTTOM w0.102: v2(240.24,81.38) 240.24,78.14 239.7,77.6 239.7,73.02 v2(238.91,72.23)
1.05V_MODPHY_EN: length 11.8
  TOP w0.102: C412.1 158.45,91.08 158.74,91.37 Q124.3 158.74,92.48 158.86,92.61 R445.2 158.86,93.61 158.18,94.3 v1(157.07,94.3) 153.61,94.3 152.98,93.67 Q125.3
1.5VSP: length 1.1
  BOTTOM w0.102: v1(92.41,93.78) 92.48,93.85 PC403.1
1.35V_B+: length 2.1
  TOP w0.508: PR206.1 v2(121.13,11.73)
  BOTTOM w0.102: v5(105.36,6.93) 105.47,7.05 PC202.1
  vias: v2(108.65,11.16) v2(109.26,11.16) v2(109.42,7.9)
1.35V_FB: length 6.2
  TOP w0.203: PU11.6 117.79,9.64 118.08,9.35 118.08,8.31 v1(118.58,7.81) 118.99,7.4 118.99,6.87 PR205.2
  TOP w0.254: PR209.2 119.49,4.62 PC213.2 PR205.2
1.35V_SUS_PWRGD: length 131.8
  TOP w0.102: v2(24.44,10.64) 24.69,10.39 U38.B9
  TOP w0.203: PR204.2 118.55,12.62 118.19,12.26 118.19,11.44 117.99,11.24 PU11.10
  TOP w0.254: v2(118.99,16.29) 121.27,16.29 121.59,15.98 v1(121.59,15.43) 121.59,13.77 121.13,13.31 120.13,13.31 119.52,12.7 PR204.2
  IN3 w0.122: v2(118.99,16.29) 118.96,16.29 118.05,17.21 114.64,17.21 113.77,18.08 99.03,18.08 98.6,18.52 98.6,24.76 98.29,25.08 66.93,25.08 66.7,24.85 57.85,24.85 57.37,24.37 54.65,24.37 51.6,21.33 50.25,21.33 47.55,18.63 47.55,13.39 50.14,10.79 50.14,9.55 49.93,9.34 49.47,9.34 47.18,11.63 40.28,11.63 38.79,10.13 35.64,10.13 34.21,8.71 29.13,8.71 28.88,8.96 26.12,8.96 v2(24.44,10.64)
3.3V_CAM_EN#: length 109.3
  TOP w0.102: v2(91.05,96.62) 90.78,96.35 88.38,96.35 RC211.1 87.48,95.45 85.95,95.45 85.28,96.13 84.86,96.13 84.56,96.43 84.11,96.43 R106.1
  IN1 w0.084: v2(148.88,65.6) 149.28,66 149.28,67.54 148.82,67.99 146.73,67.99 145.13,69.59 144.65,69.59 144.3,69.93 143.08,69.93 141.84,71.18 140.39,71.18 139.74,70.53 138.36,70.53 138.21,70.39 137.42,70.39 136.63,69.6 135.65,69.6 135.28,69.97 117.46,69.97 117.43,69.99 116.15,69.99 115.82,70.33 113.15,70.33 112.12,71.36 110.88,71.36 110.76,71.49 109.37,71.49 108.6,72.27 108.6,73.3 107.14,74.76 94.9,74.76 91.53,78.13 89.51,78.13 88.61,79.03 82.16,79.03 81.27,79.92 v2(80.86,79.92)
  BOTTOM w0.076: v2(148.88,65.6) 149.32,65.16 UC1.AM4
  BOTTOM w0.102: v2(80.86,79.92) 80.56,79.92 80.32,80.16 80.32,80.89 79.55,81.65 79.55,82.33 80.66,83.44 80.66,86.3 85.2,90.84 86.35,90.84 88.19,92.68 88.19,93.76 v1(90.11,95.69) v2(91.05,96.62)
3.3V_HDD_EN: length 246.6
  TOP w0.102: v2(164.46,81.25) 165.15,80.57 170.12,80.57 171.31,79.38 171.31,77.5 173.42,75.39 173.42,72.3 172.68,71.56 172.68,68.8 173.29,68.19 175.19,68.19 178.93,64.44 178.93,57.73 178.37,57.17 178.37,54.03 178.93,53.47 178.93,48.94 184.67,43.2 184.67,27.57 185.29,26.95 v2(185.29,24.55) ; v1(51.32,25.88) 51.32,26.17 v2(51,26.49) ; R129.1 203.43,22.54 v2(203.85,22.96)
  IN2 w0.122: v2(185.29,24.55) 182.88,26.96 129.37,26.96 128.95,26.55 84.09,26.55 83.88,26.34 58.75,26.34 57.97,27.11 54.54,27.11 53.92,26.49 v2(51,26.49)
  IN3 w0.122: v2(185.29,24.55) 185.29,24.55 186.46,23.38 190.3,23.38 190.66,23.02 197.01,23.02 197.22,22.81 203.7,22.81 v2(203.85,22.96) ; v2(162.23,80.05) 162.23,80.03 161.71,79.51 161.18,79.51 160.77,79.92 156.13,79.92 155.24,79.03 v2(153.72,79.03)
  BOTTOM w0.076: UC1.K2 150.92,77.38 151.27,77.38 151.74,77.85 152.54,77.85 152.96,78.27
  BOTTOM w0.102: RC295.2 161.91,77.81 161.91,79.73 v2(162.23,80.05) 163.26,80.05 v2(164.46,81.25) ; 152.96,78.27 v2(153.72,79.03)
3.3V_TP_EN: length 20
  TOP w0.102: v2(163.83,78.12) 163.83,78.73 v1(164.16,79.06) 164.42,79.32 RP8.5
  IN3 w0.089: 153.85,77.77 153.71,77.77 153.61,77.67 152.78,77.67 152.52,77.93 151.16,77.93 150.53,77.3 149.69,77.3 149.28,76.9 v2(148.88,76.9)
  IN3 w0.122: v2(163.83,78.12) 163.79,78.12 163.55,78.36 161.63,78.36 160.57,79.43 156.34,79.43 154.69,77.77 153.85,77.77
  BOTTOM w0.076: UC1.L5 148.64,76.66 v2(148.88,76.9)
3.3V_TS_EN: length 52.1
  TOP w0.102: v2(147.52,76) 148.02,76.5 148.96,76.5 149.15,76.31 151.09,76.31 151.77,77 152.16,77 152.3,77.14 156.36,77.14 156.81,76.7 156.81,76.28 156.96,76.12 157.59,76.12 157.86,75.86 161.62,75.86 161.85,76.09 161.85,76.45 162.34,76.95 164.35,76.95 165.22,77.82 RP8.8 ; v2(150.44,97.79) 150.44,99.59 149.91,100.13 v1(149.54,100.13) Q17.2
  IN2 w0.089: v2(147.52,76) 147.94,76.43 149.1,76.43 149.26,76.59 149.26,77.22 149.17,77.3 149.17,78.45 148.79,78.83 148.02,78.83 147.75,79.1 147.75,80.17 147.39,80.54 147.39,81.88 146.16,83.11 146.16,85.57
  IN2 w0.122: 146.16,85.57 146.16,86.45 148.09,88.38 148.09,89.88 148.51,90.3 148.51,95.66 150.44,97.59 v2(150.44,97.79)
  BOTTOM w0.076: v2(147.52,76) 147.34,75.82 UC1.N7
+0.9V_LAN: length 15.2
  TOP w0.203: U21.8 256.02,78.17 256.25,78.4 v2(256.65,78.4) ; U21.43 252.73,73.66 v2(252.73,73.66) ; U21.16 253.53,81.72 253.8,81.99 C177.1 ; U21.40 251.53,72.98 251.83,72.68 251.83,72.31 C185.1 ; U21.37 250.33,73.72 v2(250.22,73.61) ; v2(256.72,79.54) 256.21,79.54 256.04,79.37 U21.11 ; U21.22 251.13,82.45 C183.1
  TOP w0.508: v2(251.13,72.68) 251.26,72.55 251.26,72.12 C185.1 ; v2(250.5,82.45) C183.1 ; C186.1 v2(248.72,73.51) ; v2(254.43,82.51) C177.1
  vias: v1(254.69,71.48) v2(254.32,73.61) v2(254.74,73.21)
+0.675V_DDR_VTT: length 87.4
  IN4 w1.016: 197.76,22.81 194.79,22.81 191.54,26.06 158.67,26.06 158.27,25.65 158.27,19.35 157.35,18.44 135.31,18.44 133.97,19.77 129.24,19.77 128.89,20.12 127.53,20.12 126.04,18.62 124.59,18.62 123.65,19.56 123.62,19.53
  BOTTOM w0.356: JDIMM2.203 199,24.86 v3(199.31,24.55) ; 199.31,19.53 199.3,19.52 JDIMM2.204
  vias: v2(112.19,4.9) v2(112.83,4.9) v2(116.95,15.85) v2(117.58,15.8) v2(122.43,19.74) v2(122.69,24.26) v2(122.69,23.62) v2(122.94,20.17) v3(199,20.93) v3(199,20.29) v3(199.31,23.91) v5(199.5,21.44)
+0.675V_P:
  vias: v1(113.72,7.72)
+1.2V_LDO: length 8.4
  TOP w0.203: C217.2 263.54,19.02 262.05,19.02 261.77,19.3 U27.41 ; v2(256.4,25.07) 256.4,24.55 v1(256.59,24.36) U27.10
  TOP w0.508: C217.2 263.6,17.96 C223.2 263.68,17.33 v2(263.96,17.06) ; L36.1 v2(265.67,24.74) ; C218.2 v2(256.4,25.07)
+1.2V_LDO_AIN: length 13.4
  TOP w0.203: U27.28 256.99,16.28 256.27,15.57 C232.2 ; U27.31 258.19,16.19 258.25,16.13 v1(258.25,15.75) 258.25,14.92 C233.2
  TOP w0.508: C233.2 257.11,14.78 v2(256.97,14.64) 256.83,14.78 C232.2 ; v2(263.97,26.86) 263.51,26.4 C230.2 ; C234.2 261.47,14.97 261.67,15.18 v2(261.67,16.15) ; v2(262.12,24.87) 261.95,25.03 261.95,25.5 C231.2 261.3,25.34 261.3,24.1 ; v2(262.81,24.74) L36.2
+1.05V_M: length 70.6
  TOP w0.127: v5(225.96,84.63) 225.78,84.81 v2(225.78,85.32)
  TOP w0.508: v2(142.95,69.14) 142.95,69.25 142.55,69.65 CC46.1 142.56,69.89 RC272.1
  IN3 w0.508: v2(80.98,78.78) 81.93,78.78 84.23,81.08 86.84,81.08 91.35,85.58 94.22,85.58 95.05,86.41 97.48,86.41 100.18,89.12 103.12,89.12 103.35,88.89 103.98,88.89 104.72,89.64 105.37,89.64 105.84,89.17 107.07,89.17 109.21,87.03 111.47,87.03 112.15,87.71 126.99,87.71 128.7,86 130.57,86 131.17,86.6 v2(133.72,86.6)
  BOTTOM w0.203: UC1.AG13 144,68.68 144.2,68.88 v2(144.2,69.19) ; UC1.AG14 143.18,68.91 v2(142.95,69.14)
  BOTTOM w0.254: UC1.AG8 146.75,67.9 146.93,68.08 v2(146.93,68.38) ; UC1.AF9 UC1.AE9
  BOTTOM w0.33: v2(146.93,68.38) UC1.AF9
  BOTTOM w0.508: v2(80.98,78.78) 80.98,78.71 80.04,77.77 80.04,76.66 80.57,76.12 RC16.1
  vias: v2(137.06,92.57) v2(137.06,91.95) v2(156.34,92.89) v2(156.97,92.89) v2(157.61,92.89) v2(158.24,92.89) v2(210.27,73.48) v2(210.48,72.83) v2(210.58,74.02) v2(210.87,73.27) v2(210.88,72.36) v2(211.11,74.38) v2(211.13,73.8) v2(211.28,72.8) v2(211.49,73.34) v2(211.62,72.3) v2(221.31,76) v2(221.31,75.36) v2(221.31,74.7) v2(221.31,74.07) v2(221.95,76) v2(221.95,75.36) v2(221.95,74.7) v2(221.95,74.07) v2(226.42,85.32) v2(227.05,85.32) v2(227.64,85.32)
+1.05V_M_JTAG: length 5.3
  TOP w0.508: v2(80.92,77.09) 80.52,77.49 RC17.2 RC20.2
  BOTTOM w0.127: v2(73.85,69.32) 73.19,69.32 v1(73,69.51)
  BOTTOM w0.508: v2(73.85,69.32) RC18.2 ; RC16.2 80.09,74.36 79.73,74.71 v2(79.73,75.09) ; v2(77.32,68.74) RC10.2
+1.05V_MODPHY: length 4.3
  IN3 w2.032: 150.62,85.01 147.57,88.06
  vias: v2(145.48,89.59) v2(146.41,92.38) v2(146.85,91.93) v2(147.04,92.51) v2(147.45,91.95) v2(153.15,84.6) v2(153.34,85.18) v2(153.7,84.37) v2(153.9,84.92) v5(147.02,93.29)
+1.05V_MODPHY_PCH: length 4.3
  BOTTOM w0.254: v2(145.12,75.94) 145.19,76 ; 145.19,76 145.66,76.48 UC1.L10 146.24,76.92 UC1.K9 146.24,77.9 v2(146.29,77.95) v2(146.29,78.59) ; 145.19,76 UC1.M9
  vias: v1(146.42,81.32)
+1.05V_MP: length 19.8
  TOP w0.127: v2(225.58,79.73) 225.58,79.65 v5(225.06,79.13)
  TOP w0.508: PR307.1 241.14,75.22 241.53,74.83 v2(241.53,74.82)
  IN1 w0.254: v2(241.53,74.82) 241.26,75.08 240.84,75.08 236.69,79.23 234.68,79.23 234.04,79.88 225.73,79.88 v2(225.58,79.73)
+1.05V_RUN: length 290.7
  TOP w0.279: CC11.1 69.46,59.49 68.86,59.49 68.21,60.13 JXDP1.43 ; CC10.1 59,59.78 59.66,59.78 60.02,60.13 JXDP1.44
  TOP w0.457: CC11.1 69.51,59.66 68.97,60.2 v2(68.97,60.35)
  TOP w0.508: v2(69.3,52.21) 69.27,52.17 RC120.1 ; CC64.1 143.46,75.32 v2(143.18,75.6) 142.94,75.6 142.57,75.23 CC63.1 ; v2(18.45,23.72) R374.2 ; v2(34.52,19.46) R403.1 ; v2(146.86,76) 146.61,75.74 CC60.1 ; CC31.1 138.37,74.24 139.13,74.24 v2(139.22,74.16) ; CC37.1 138.66,68.55 v2(139.18,68.55) 139.18,68.05 C461.2 ; v2(141.96,67.65) 141.83,67.53 CC33.1 ; LC5.1 153.19,87.68 152.78,87.28 152.78,86.16 151.75,85.13 v5(151.75,81.25) v2(151.75,80.62) ; v2(15.4,23.69) 15.8,23.29 R335.1 ; v2(59.41,60.46) 59.26,60.31 58.75,60.31 CC10.1 ; RC280.1 57.66,62.84 v2(57.01,62.84) ; C458.2 v2(133.07,74.47)
  IN1 w0.508: v2(68.97,60.35) 68.97,58.29 70.1,57.16 70.1,55.07 69.4,54.36 69.4,52.31 v2(69.3,52.21) ; v2(139.22,74.16) 136.12,74.16 135.85,73.89 133.66,73.89 v2(133.07,74.47) ; v2(34.52,19.46) 34.6,19.38 37.72,19.38 39.04,20.7 39.04,23.91 40.16,25.03 40.16,28.9 40.89,29.62 40.89,34.71 40.72,34.88 40.72,35.43 42.25,36.97 43.59,36.97 48.1,41.49 48.1,42.44 52.69,47.03 52.69,48.87 54.97,51.14 54.97,55.55 55.52,56.11 55.52,60.24 56.24,60.95 56.24,62.45 56.63,62.84 v2(57.01,62.84) ; v2(136.06,92.77) 136.06,91.55 137.29,90.32 142.13,90.32 v2(142.16,90.3)
  IN2 w0.508: v2(106.99,91.39) 108.7,89.68 v2(108.7,89.51) ; v2(136.06,92.77) 131.03,92.77 130.18,91.93 130.18,87.51 130.35,87.34 v2(130.35,86.78) ; v2(68.97,60.35) 70.13,61.51 70.13,63.77 72.09,65.73 72.09,67.99 72.45,68.35 72.45,73.55 72.79,73.88 72.79,76.68 79.58,83.47 79.58,84.3 80.96,85.69 83.29,85.69 84.19,86.59 92.38,86.59 95.05,89.26 97.01,89.26 100.2,92.46 101.17,92.46 103.66,94.94 107.99,94.94 109.49,93.45 110.57,93.45 112.39,91.63 112.39,91.28 113.67,90 v2(113.67,88.8) ; v2(67.67,64.92) 67.67,64.64 67.17,64.15 65.64,64.15 63.83,62.33 61.28,62.33 v2(59.41,60.46)
  IN3 w0.508: v2(34.52,19.46) 34.52,20.27 34.19,20.6 34.19,21.87 33.25,22.81 31.88,22.81 30.17,24.52 24.3,24.52 23.85,24.08 23.52,24.08 22.46,23.02 19.73,23.02 19.02,23.72 v2(18.45,23.72) 17.68,22.95 16.14,22.95 v2(15.4,23.69) ; v2(151.75,80.62) 151.75,81.64 149.21,84.18 147.05,84.18 146.53,84.7 146.53,85.62 145.95,86.21 144.77,86.21 143.99,86.98 143.99,88.2 144.09,88.3 144.09,90.09 143.56,90.63 142.49,90.63 v2(142.16,90.3) ; v2(109.32,89.5) 109.79,89.03 110.67,89.03 110.87,88.82 113.64,88.82 v2(113.67,88.8) 113.77,88.8 114.22,89.26 115.75,89.26 116.32,88.68 117.65,88.68 118.35,89.38 128.31,89.38 130.35,87.34 v2(130.35,86.78) ; v2(67.67,64.92) 67.67,61.66 v2(68.97,60.35)
  IN4 w0.508: v2(57.01,62.84) 57.46,62.84 59.41,60.88 v2(59.41,60.46) ; v2(141.96,67.65) 141.38,68.24 139.5,68.24 v2(139.18,68.55)
  BOTTOM w0.229: UC1.J11 UC1.H11 144.86,78.24 144.58,78.52 v2(144.45,78.52) ; UC1.H15 142.89,78.24 v2(142.56,78.57)
  BOTTOM w0.254: v2(139.22,74.16) 139.59,73.79 UC1.T21 ; UC1.P9 146.24,75.34 146.42,75.52 UC1.N8 146.69,75.82 146.86,76 v2(146.86,76) ; v2(141.96,67.65) 141.96,67.65 141.96,67.65 v2(141.96,67.65) ; v2(141.96,67.65) 142.33,68.02 UC1.AG16 ; v2(141.96,67.65) 141.59,68.02 UC1.AG17 ; v2(139.18,68.55) 139.18,68.55 138.73,68.55 UC1.AF22 ; v2(146.86,69.33) 146.69,69.16 UC1.AE8 ; UC1.J17 142.19,77.59 v2(142.55,77.95)
  BOTTOM w0.33: v2(139.22,74.16) 139.59,74.52 UC1.R21
  BOTTOM w0.381: v2(106.99,91.39) 107.33,91.05 RC253.1
  BOTTOM w0.508: v2(130.35,86.78) 130.59,87.02 LC6.1 ; RC242.2 114.38,89.51 v2(113.67,88.8) ; v2(142.16,90.3) 142.65,90.3 143.03,90.68 LC3.1
  vias: v2(198.35,71.2) v2(198.74,70.75) v2(198.93,71.34) v2(199.31,70.88) v2(210.19,69.52) v2(210.19,68.94) v2(210.77,69.52) v2(210.77,68.94) v2(211.4,69.52) v2(211.4,68.94) v2(211.99,69.52) v2(211.99,68.94) v2(212.6,69.54) v2(212.6,68.92) v3(185.75,72.45) v3(186.39,72.45) v3(189.46,75.59) v3(190.09,76.31) v3(190.09,75.5) v3(191.02,76.14)
+1.05V_RUN_U43: length 1
  BOTTOM w0.102: 212.76,70.83 212.76,70.22 v1(213.03,69.95)
+1.05V_RUN_VMM: length 1.1
  BOTTOM w0.127: v5(202.93,72.86) 202.53,73.27 202.53,73.81
+1.05V_RUN_VMM_U31: length 1
  BOTTOM w0.127: 200.63,72.85 200.63,72.02 v1(200.72,71.93)
+1.5V_THERMAL: length 58.9
  TOP w0.508: v2(104.98,88.99) 104.98,89.44 v5(100.71,93.71) 96.83,97.59 v2(96.83,98.02)
  IN1 w0.508: v2(143.43,77.89) 143.43,77.7 142.8,77.06 120.19,77.06 119.69,77.57 119.69,79.1 118.92,79.86 117.46,79.86 116.13,81.19 113.92,81.19 110.36,84.75 110.36,85.53 109.37,86.52 107.97,86.52 107.24,87.25 107.24,88.49 106.74,88.99 v2(104.98,88.99)
  BOTTOM w0.229: v2(143.43,77.89) 143.41,77.89 143.12,77.59 UC1.J15
+1.05V_VCCST: length 121.7
  TOP w0.508: CC50.1 135.14,85.46 137.21,83.39 v2(137.24,83.39) ; RC243.2 110.92,92.23 111.77,91.38 v2(111.78,91.38) ; RC255.1 105.88,87.04 v2(106.4,86.52) ; v2(137.34,69.23) 136.95,69.62 CC26.1 ; PR527.1 PR528.1 PR529.1 86.28,78.65 PC511.1 85.4,78.79 84.91,79.27 v2(84.91,79.7)
  IN1 w0.508: v2(111.78,91.38) 111.7,91.38 111.24,90.92 111.24,86.91 115.69,82.45 136.3,82.45 v2(137.24,83.39) ; v2(84.68,81.84) 84.8,81.72 91.01,81.72 94.62,78.1 107.07,78.1 v2(107.24,78.27)
  IN2 w0.508: v2(104.74,90.79) 105.82,89.71 105.82,87.11 v2(106.4,86.52) 106.45,86.47 106.45,79.95 107.24,79.16 v2(107.24,78.27)
  IN3 w0.508: v2(137.34,69.23) 137.83,69.23 138.37,69.76 138.37,76.86 138.04,77.19 138.04,82.59 v2(137.24,83.39) ; v2(111.78,91.38) 111.65,91.24 108.17,91.24 107.65,90.72 106.76,90.72 106.5,90.98 104.93,90.98 v2(104.74,90.79)
  BOTTOM w0.254: v2(137.34,69.23) 137.85,69.23 138.16,68.92 UC1.AE23 138.24,68.89 138.65,69.29 UC1.AE22 UC1.AC22
  BOTTOM w0.381: RC113.1 103.86,88.61 104.32,89.06 104.32,90.37
  BOTTOM w0.508: v2(84.68,81.84) 84.68,79.93 v2(84.91,79.7) ; R24.1 111.35,91.41 111.74,91.41 v2(111.78,91.38) ; 104.32,90.37 v2(104.74,90.79) 104.99,91.05 RC114.1 ; RC249.1 108.29,77.39 RC244.1 107.43,78.08 v2(107.24,78.27)
+1.05V_VMM_VDD: length 11.5
  TOP w0.254: U6.H7 195.35,80.25 v4(195.03,80.57) U6.H6 ; U6.E7 195.35,82.2 v4(195.03,82.52) U6.E6 ; v4(192.43,82.52) 192.75,82.2 U6.E3 ; U6.F12 198.61,81.55 v4(198.93,81.22) U6.G12 ; U6.H9 196.65,80.25 v4(196.33,80.57) U6.H8 ; U6.E5 194.05,82.21 194.04,82.21 193.73,82.52 v4(193.73,82.52) ; v4(193.08,80.58) 193.06,80.58 193.06,80.6 193.04,80.6 193.04,80.62 192.76,80.9 U6.G3 ; U6.E9 196.65,82.2 v4(196.33,82.52) U6.E8 ; U6.C9 196.65,83.5 v4(196.33,83.82) U6.C8
  BOTTOM w0.508: C12.1 199.49,81.22 v4(198.93,81.22) ; C9.1 192.19,82.76 v4(192.43,82.52) ; 195.33,77.2 193.22,75.09 C25.1
  vias: v1(198.82,77.16) v4(196.33,78.62) v4(196.98,78.62) v4(197.63,78.62)
+1.05V_VMM_VDDTX: length 9.9
  TOP w0.254: U6.J2 v4(192.43,79.92) ; v4(192.43,79.92) U6.H3 ; v4(192.43,79.92) 192.75,79.6 U6.J3 ; U6.K9 196.65,78.95 v4(196.33,79.27) U6.K8 ; v4(197.63,80.57) 197.63,80.57 U6.H11 197.96,80.25 v4(198.28,79.92) ; U6.D12 198.7,82.75 198.7,82.75 v4(198.93,82.52) U6.E12 ; U6.D3 193.08,82.53 v4(193.08,82.52) ; U6.J10 197.31,79.6 v4(197.63,79.27) U6.K10 ; U6.E10 197.3,82.2 v4(196.98,82.52) ; U6.C7 195.35,83.5 v4(195.03,83.82) U6.C6 ; U6.F3 v4(193.08,81.87)
  BOTTOM w0.508: v4(193.08,81.87) 192.67,81.87 C24.1 ; C23.1 199.2,82.26 v4(198.93,82.52) ; v4(195.03,83.82) 195.03,84.73 C22.1
  vias: v1(204.18,78.36) v2(202.72,82.31) v2(203.3,82.31) v2(203.89,82.31)
+1.8V_RUN_CARD: length 28.2
  IN3 w1.016: 274.85,4.34 270.69,4.34 269.11,5.92 258.95,5.92 256.29,8.58 256.29,11.29 255.4,12.18 255.4,13.23 253.37,15.26
  vias: v2(252.59,16.48) v2(253.23,16.48) v2(275.65,5.03) v2(276.26,5.03) v5(253.62,17.23)
+1.35V_MEM: length 144
  TOP w0.254: CD23.1 124.61,24.14 125.02,24.55 125.02,24.79 125.51,25.28 U5.5
  TOP w0.508: RC130.1 133.74,29.59 130.9,29.59 130.53,29.22 130.53,26.44 v2(129.83,25.74) ; 117.53,34.39 117.53,32.87 118.52,31.88 QD1.1 124.02,29.48 v2(124.49,29.48) ; RC217.1 54.72,29.25 v2(54.47,29.5) ; CD23.1 123.83,24.14 123.76,24.08 v2(123.8,24.04)
  IN1 w0.508: v2(124.49,29.48) 124.54,29.43 124.54,26.96 124.98,26.52 124.98,25.22 v2(123.8,24.04)
  IN2 w0.508: v2(85.82,27.53) 85.51,27.22 83.81,27.22 83.39,26.79 58.92,26.79 58.16,27.55 56.42,27.55 v2(54.47,29.5)
  IN3 w0.508: v2(123.8,24.04) 124.04,24.28 126.58,24.28 127.84,25.54 129.63,25.54 v2(129.83,25.74)
  BOTTOM w0.178: v2(131.11,64.34) 131.37,64.6 UC1.AN33 ; UC1.AY40 127.28,59.36 v2(127.7,58.93)
  BOTTOM w0.203: UC1.AR48 122.35,63.3 v2(122.03,62.97)
  BOTTOM w0.229: v2(121.39,59.3) 121.33,59.3 120.95,59.68 120.95,60.04 120.98,60.07 UC1.AY50
  BOTTOM w0.254: UC1.AP43 125.21,63.95 v2(124.89,63.62) ; UC1.AY44 124.13,60.05 v2(124.57,59.6) ; UC1.AY35 130.42,59.96 v2(130.86,59.52)
  BOTTOM w0.279: v2(136.05,68.05) UC1.AH26 ; UC1.AJ31 132.8,67.49 133.25,67.94 v2(133.25,68.06) ; UC1.AJ33 131.5,67.5 131.96,67.96 v2(131.96,68.06) ; UC1.AJ37 129.09,67.2 v2(129.35,66.94)
  BOTTOM w0.356: JDIMM1.99 91.3,24.62 v2(91.35,24.57) ; v2(84.63,23.84) 84.37,23.84 84.1,24.12 JDIMM1.75 ; JDIMM2.99 167.8,24.66 v2(167.98,24.48) 168.01,24.45 169.16,24.45 169.6,24.89 JDIMM2.105 ; JDIMM2.87 164.2,27.35 v2(164.25,27.4) 162.84,27.4 162.4,26.96 JDIMM2.81 ; JDIMM1.111 94.9,27.31 v2(95.12,27.53) ; v2(165.99,16.39) 166.3,16.7 JDIMM2.94 ; JDIMM1.124 98.8,16.68 v2(98.29,16.17) ; JDIMM2.118 v2(173.5,16.33) ; v2(93.24,16.16) 93.24,16.55 93.4,16.71 JDIMM1.106 ; JDIMM2.93 166,24.96 166.24,24.72 166.24,24.45 v2(165.61,23.82) ; JDIMM1.87 87.7,24.14 87.94,23.9 v2(88.17,23.9) ; JDIMM2.75 160.6,24.88 160.96,24.52 v2(161.19,24.52) ; JDIMM1.117 96.7,27.06 97.07,27.43 v2(97.07,27.53) ; v2(160.64,16.29) 160.9,16.55 JDIMM2.76 ; JDIMM2.82 162.7,19.64 v2(163.01,19.95) ; v2(89.22,27.53) 89.5,27.25 JDIMM1.93 ; JDIMM1.100 91.6,16.32 v2(91.71,16.21) ; JDIMM2.111 171.4,27.23 v2(171.22,27.4) ; v2(171.37,16.23) 171.7,16.56 JDIMM2.112 ; v2(172.61,21.47) 174.28,21.47 175.3,20.46 JDIMM2.124 ; v2(172.78,27.4) 173.2,26.99 JDIMM2.117 ; JDIMM2.88 164.5,16.36 v2(164.27,16.13) ; JDIMM1.82 86.2,16.32 v2(86.27,16.25) ; JDIMM1.76 84.4,16.34 v2(84.49,16.25) ; JDIMM2.123 175,27.21 v2(174.8,27.4) ; v2(167.95,19.95) 168.1,19.8 JDIMM2.100 ; v2(93.13,24.57) 93.1,24.6 JDIMM1.105 ; v2(85.82,27.53) 85.9,27.45 JDIMM1.81 ; v2(89.71,16.14) 89.8,16.22 JDIMM1.94 ; JDIMM2.106 v2(169.9,16.36) ; JDIMM1.123 98.5,27.51 v2(98.52,27.53) ; JDIMM1.88 88,16.65 87.68,16.33 v2(87.68,16.23) ; JDIMM1.112 95.2,16.23 v2(95.16,16.19) ; v2(96.94,16.19) 97,16.25 JDIMM1.118
  vias: v5(107.67,48.13)
+1.35V_MEN_P: length 71.2
  TOP w0.203: v2(117.42,8.28) 116.79,8.28 116.61,8.46 PU11.5
  TOP w0.254: PC214.1 120.45,6.32 PR205.1 PC213.1 121.62,5.47 121.84,5.24 121.84,4.39 121.46,4.01 113.19,4.01 112.68,3.5 95.14,3.5 94.16,4.48 94.16,10.07
  TOP w0.508: 94.67,10.07 94.67,4.69 95.35,4.01 110.72,4.01 111.05,4.34 111.05,7.29 111.28,7.52
  IN1 w0.508: v2(111.87,7.78) 112.95,8.86 116.84,8.86 v2(117.42,8.28)
  vias: v1(89.85,10.1) v3(91.16,11.45) v3(91.16,10.82) v3(91.8,11.45) v3(91.8,10.82) v3(92.46,11.45) v3(92.46,10.82) v3(93.09,11.45) v3(93.09,10.82) v3(93.73,11.45) v3(93.73,10.82) v3(94.36,11.45) v3(94.36,10.82) v3(95.05,11.43) v3(95.05,10.79) v3(95.68,11.43) v3(95.68,10.79)
+3.3V_ALW: length 413.5
  TOP w0.254: PC801.2 132.66,8.55 v2(132.7,8.55) ; PC801.2 131.9,8.04 PU801.5 ; PC801.2 132.04,7.9 PR807.1 ; U36.10 79.48,82.84 C322.1 ; JSH1.12 268.04,4.94 268.26,4.71 269.21,4.71 269.67,5.17 269.67,5.69
  TOP w0.381: PU3.5 100.48,88.97 100.23,88.72 PR740.1 ; v2(11.43,40.8) 11.62,40.99 U47.5 ; CC24.1 111.46,96.51 UC4.5
  TOP w0.406: PC805.2 126.67,12.18 PU804.5
  TOP w0.432: v2(123.31,9.7) 122.85,9.23 PR810.1
  TOP w0.457: R402.1 33.06,19.91 v2(33.58,19.39) ; v2(41.45,15.67) 41.02,15.67 40.69,15.34 R440.1
  TOP w0.508: R452.1 23.8,6.2 24.05,5.94 v2(24.05,5.63) 24.05,4.94 R386.1 ; R380.1 11.07,18.47 10.46,18.47 v2(10.4,18.41) ; v2(13.02,16.93) 13.21,17.12 R345.1 ; 269.67,5.69 270.04,6.06 C50.1 269.23,6.32 268.53,7.02 v2(268.04,7.02) ; R359.1 20.75,6.18 v2(20.75,5.69) 20.75,5.05 20.93,4.88 R364.1 ; R363.1 R353.1 28.69,23.72 v2(28.5,23.91) ; R339.1 16.01,15.67 v2(15.76,15.92) ; C328.1 16.18,42.52 v2(16.78,43.12) 17.23,42.66 R281.1 ; RC267.1 166.54,62.44 v2(166.19,62.1) ; R293.1 30.09,27.34 30.99,26.44 32.41,26.44 33.58,27.61 ; R365.1 v2(19.99,5.63) 20.05,5.56 R361.1 ; v2(30.67,4.51) 30.67,4.91 30.9,5.14 R387.1 ; v2(126.85,11.26) PC805.2 ; v2(21.2,24.04) 21.13,23.97 R348.1 ; R451.1 21.9,6.2 v2(21.45,5.75) ; R432.1 R428.1 195.28,95.41 v2(195.33,95.47) ; v2(186.23,82.03) 186.03,82.03 185.68,82.37 v5(185.68,87.05) 185.68,90.73 184.95,91.46 v2(184.95,91.57) ; v2(10.87,7.86) 11.14,8.14 R393.1 ; PR300.1 237.36,71.48 v2(237.29,71.55) ; R288.1 R282.1 25.83,42.91 v2(26,42.75) ; v2(80.18,83.98) 79.67,83.47 C322.1 ; R298.1 22.4,26.12 22.4,25.65 v2(22.42,25.64) ; PR868.2 v2(12.76,31.67) ; v2(147.8,110.44) 147.65,110.44 147.12,109.91 147.12,109.08 R272.2 ; R284.1 R289.1 R287.1 15.55,25.82 15.77,25.59 v2(16.4,25.59) ; PR2.1 155.99,10.88 156.52,11.4 156.52,13.06 156.2,13.37 v2(155.88,13.37) ; R453.1 22.91,5.44 v2(22.72,5.63) ; v2(26.57,3.58) 26.57,3.68 26.34,3.91 R392.1 ; PR726.1 55.82,3.33 v2(55.93,3.21) ; C348.1 16.24,5.63 v2(16.8,6.18) ; PR801.1 v2(126.24,4.98) ; R343.1 22.86,24.31 v2(22.53,23.98) 22.34,23.79 R401.1 ; PR204.1 v2(121.13,12.62) ; CC24.1 111.65,96.86 109.63,98.88 v2(101.24,98.88) 100.03,100.1 97.7,100.1 96.19,98.59 96.19,96.82 97.46,95.55 97.46,93.16 95.81,91.51 95.81,89.67 96.48,89 98.55,89 PC728.2 98.88,88.72 PR740.1 ; PR107.2 v2(201.75,47.85) ; R344.1 v2(34.98,13.32) ; PR8.2 83.62,92.04 v2(83.81,92.23) ; C452.2 158.98,16.42 v2(159.13,16.27) ; v2(20.42,43.15) 20.42,43.04 20.04,42.66 R295.1
  TOP w1.524: 53,64.53 54.41,63.12 54.41,58.58 58.23,54.76 58.23,45.22 61.34,42.11 61.34,38.71 62.36,37.7 62.36,34.91 61.6,34.15 61.6,26.57 60.92,25.89 60.92,18.97 60.93,18.96
  IN1 w0.508: v2(52.44,65.44) 57.66,70.66 57.66,77.42 59.49,79.25 59.49,80.85 71.92,93.28 74.75,93.28 v2(75.39,93.92) 76.82,93.92 78.51,92.23 v2(83.81,92.23) ; v2(36.22,24.15) 36.22,23.29 36.7,22.81 36.7,21.18 35.81,20.29 33.83,20.29 33.58,20.04 v2(33.58,19.39)
  IN2 w0.508: v2(266.85,16.41) 266.18,15.73 266.18,8.88 v2(268.04,7.02) ; 188.21,79.83 187.99,79.6 187.99,73.16 189.14,72 189.14,66.85 189.34,66.65 192.76,66.65 v2(193.17,66.24)
  IN2 w1.016: 221.84,70.69 236.35,70.69
  IN3 w0.508: v2(184.95,91.57) 185.14,91.57 186.16,92.58 187.05,92.58 189.15,94.69 194.89,94.69 195.33,95.12 v2(195.33,95.47) ; v2(101.24,98.88) 99.81,97.45 97.04,97.45 94.6,95.01 76.48,95.01 v2(75.39,93.92)
  IN3 w1.016: 205.31,73.28 204.22,73.28 202.45,71.51 202.17,71.51 201.59,70.93 201.59,69.49 202.79,68.29 202.79,67.72 203.16,67.35
  IN4 w0.508: v2(147.8,110.44) 147.57,110.44 147.32,110.18 147.32,109.38 146.96,109.02 144.5,109.02 142.61,107.14 132.14,107.14 128.08,103.07 116,103.07 112.75,99.82 110.3,99.82 109.36,98.88 v2(101.24,98.88)
  BOTTOM w0.508: R291.1 15.46,42.67 15.9,43.12 v2(16.78,43.12) ; PR895.1 4.52,42.35 v2(5.18,43.01) ; R285.1 25.72,42 26,42.28 v2(26,42.75) ; v2(80.18,83.98) 80.18,86.61 82.35,88.77 82.35,90.77 v2(83.81,92.23) ; RC264.1 166.78,65.23 166.78,62.69 v2(166.19,62.1)
  BOTTOM w1.016: 265.1,32.92 263.73,32.92 263.04,32.23 263.04,26.16 ; 265.75,43.29 265.76,43.31 265.76,70.74
  vias: v2(6.87,6.12) v2(8.22,6.91) v2(9.45,11.89) v2(9.45,11.26) v2(11.79,38.61) v2(15.74,20.86) v2(16.19,20.49) v2(34.26,27.94) v2(42,11.01) v2(55.74,18.33) v2(56.12,17.82) v2(56.44,18.33) v2(56.82,17.82) v2(192.38,65.37) v2(192.85,65.72) v2(192.84,35.29) v2(192.84,34.66) v2(193.17,65.23) v2(193.24,64.41) v2(193.55,63.84) v2(193.62,65.59) v2(193.62,64.86) v2(193.81,66.23) v2(194.22,65.79) v2(194.22,32.05) v2(194.47,31.51) v2(194.59,66.26) v2(194.93,65.76) v2(198.92,38.92) v2(198.91,37.14) v2(198.91,36.55) v2(199.5,38.92) v2(200.81,8.15) v2(201.59,24.1) v2(202.18,24.09) v2(202.46,7.73) v2(202.46,7.15) v2(203.31,66.04) v2(203.3,65.46) v2(204.15,24.13) v2(204.75,24.12) v2(206.18,73.56) v2(206.63,74) v2(208.39,66.32) v2(208.39,65.74) v2(238.18,72.11) v2(266.85,17.07) v5(57.53,18.52) v5(192.52,66.33)
+3.3V_ALW2: length 646.5
  TOP w0.102: 53.16,4.39 v2(53.16,4.43)
  TOP w0.203: 196.77,46.2 196.84,46.27 PU100.3
  TOP w0.406: v2(134.75,14.57) v5(135.31,14.01) 135.96,13.36 136.63,13.36 138.07,11.91 138.07,10.72 137.67,10.31 PU806.5 136.75,10.31 136.4,9.96 PC810.2 ; CC82.1 70.61,69.82 UC7.5 ; v2(134.32,6.17) 134.77,6.63 PU807.5 ; PU808.5 209.6,2.82 PR829.1
  TOP w0.457: PR875.1 10.5,42.75 11.07,42.18 v2(11.07,41.87)
  TOP w0.508: PR829.1 PC814.2 v2(210.52,2.07) ; PC812.2 132.82,4.2 v2(133.23,4.61) ; PR751.1 53.16,4.39 ; v2(10.71,24.64) 10.21,24.64 9.95,24.37 9.95,23.48 10.15,23.28 PR846.1 9.98,22.85 9.32,22.19 PR862.1 ; 196.77,46.2 196.58,46.01 PR103.1 197.71,45.07 PC100.2 197.73,45.57 v2(197.41,45.88) ; PR730.1 v2(95.12,89.99) ; v2(161.11,88.32) 161.11,89.01 R442.1 ; CC82.1 70.68,69.84 71.3,70.46 v2(71.36,70.46) ; R367.2 16.69,23.46 v2(16.43,23.71) ; PR816.2 177.7,5.13 178.11,4.72 v2(178.71,4.72) 179.25,4.72 179.93,5.41 PR849.1 ; PC810.2 136.4,8.71 v2(135.92,8.23)
  IN1 w0.508: v2(69.09,46.79) 69.09,48.45 69.3,48.67 69.3,50.49 70.04,51.23 70.04,53.1 70.59,53.66 71.08,53.66 71.65,54.23 71.65,55.05 70.83,55.88 70.83,57.34 70.04,58.13 70.04,63.29 70.47,63.73 70.47,69.85 71.08,70.46 v2(71.36,70.46) ; v2(197.41,45.88) 197.41,44.17 198.92,42.66 198.92,40.67 199.51,40.08 199.82,40.08 200.55,39.34 200.55,36.45 201.14,35.86 201.14,33.59 201.63,33.11 201.63,28.33 202.91,27.05 204.01,27.05 204.91,26.15 204.91,25.46 205.75,24.62 205.75,22.9 204.42,21.56 204.42,20.99 203.91,20.48 203.91,12.65 204.46,12.1 204.46,7.38 204.17,7.09 v2(204.17,2.7)
  IN2 w0.508: v2(130.4,16.97) 129.93,17.44 128.91,17.44 127.99,18.35 123.75,18.35 123.03,17.63 75.54,17.63 74.7,16.78 74.7,15.66 75.21,15.15 75.21,13.35 76.11,12.44 76.11,7.24 74.87,6 71.88,6 70.15,4.27 59.47,4.27 59.33,4.42 55.64,4.42 54.72,3.5 53.61,3.5 53.16,3.95 v2(53.16,4.43) ; v2(71.36,70.46) 71.82,70.91 71.82,73.81 72.15,74.15 72.15,76.95 78.94,83.74 78.94,84.64 80.68,86.38 82.78,86.38 86.11,89.71 93.09,89.71 93.37,89.99 v2(95.12,89.99)
  IN3 w0.508: v2(16.43,23.71) 16.28,23.71 15.63,24.36 14.54,24.36 13.93,24.97 12.22,24.97 11.89,24.64 v2(10.71,24.64) 9.86,25.49 9.86,29.42 7.46,31.82 7.46,32.5 6.4,33.55 5.88,33.55 4.81,34.62 4.81,35.43 5.72,36.35 5.72,38.78 v2(5.18,39.32) 5.14,39.36 5.14,41.08 5.93,41.87 7.44,41.87 7.63,41.68 9.28,41.68 9.47,41.87 v2(11.07,41.87) 11.8,42.6 15.53,42.6 16.15,41.97 22.19,41.97 23.55,43.33 25.35,43.33 25.79,43.78 28.27,43.78 29.64,45.15 30.48,45.15 31.8,46.46 33.66,46.46 39.02,51.82 41.66,51.82 41.76,51.92 43.19,51.92 43.55,51.56 45.91,51.56 46.96,50.52 49.24,50.52 v2(49.76,51.04) ; v2(140.01,6.07) 139.45,6.63 138.38,6.63 137.92,6.17 v2(134.32,6.17) ; v2(96.01,79.93) 94.59,79.93 92.25,77.6 92.25,71.79 92.48,71.56 92.48,69.19 89.97,66.67 86.8,66.67 83.02,70.46 v2(71.36,70.46) ; v2(161.11,88.32) 155.77,88.32 155.22,87.77 153.54,87.77 151.54,89.78 151.52,89.78 150.68,90.62 150.68,91.97 148.61,94.04 137.1,94.04 136.72,93.65 130.19,93.65 129.26,94.58 126.71,94.58 126.35,94.22 123.9,94.22 123.38,94.74 122.62,94.74 122.1,94.22 120.15,94.22 119.92,94.45 117.02,94.45 116.53,93.96 113.27,93.96 112.76,93.46 107.71,93.46 107.13,92.88 106.37,92.88 105.99,92.5 100.39,92.5 97.3,89.41 95.71,89.41 v2(95.12,89.99)
  IN4 w0.508: v2(130.4,16.97) 130.78,17.35 132.93,17.35 134.75,15.53 v2(134.75,14.57)
  BOTTOM w0.508: v2(133.23,4.61) 133.21,4.61 134.32,5.71 v2(134.32,6.17) 134.32,6.63 v2(135.92,8.23) ; PR738.1 v2(96.01,79.93) ; v2(5.18,39.32) 4.92,39.59 PR894.1 ; v2(49.76,51.04) 50.2,50.6 51.99,50.6 53.05,49.53 53.05,48.26 53.74,47.58 57.75,47.58 58.12,47.95 66.23,47.95 66.87,47.32 67.79,47.32 68.33,46.79 v2(69.09,46.79) 69.09,47.75 69.46,48.13 73.45,48.13 73.97,48.64 130.63,48.64 137.63,41.65 138,41.27 138,32.17 134.24,28.41 134.24,23.71 135.56,22.39 135.56,19.75 134.96,19.15 134.96,16.75 134.49,16.28 134.49,14.83 v2(134.75,14.57) ; v2(210.52,2.07) 210.01,2.58 204.29,2.58 v2(204.17,2.7) 202.89,1.43 180,1.43 178.71,2.72 v2(178.71,4.72) 177.95,5.49 159,5.49 156.48,8.01 153.02,8.01 151.74,9.3 148.21,9.3 147.23,10.27 PR808.1 143.52,10.71 142.41,9.59 v2(142.43,9.59) 141.77,8.93 141.77,7.84 v2(140.01,6.07)
+3.3V_ALW_PCH: length 330.9
  TOP w0.305: v2(254.96,7) JNFC1.15 ; JNFC1.2 248.46,7.5 v2(248.96,8) JNFC1.3
  TOP w0.381: v2(145.15,71.37) 145.52,71.37 RC205.2
  TOP w0.406: C388.2 248.97,14.01 249.65,13.32 U29.5
  TOP w0.508: RC39.1 168.96,67.4 169.14,67.22 v2(169.14,66.46) ; RC102.2 71.62,63.22 72.28,62.56 72.28,61.81 72.49,61.6 72.49,60.23 v2(72.47,60.21) ; C1.1 248.65,8.6 248.96,8.29 v2(248.96,8) ; RC205.2 145.78,71.08 RC265.1 ; v2(247.96,15.06) 248.62,14.4 C388.2 ; v2(253.73,8.6) 254.23,9.09 R38.1 ; v2(55.03,49.49) 54.71,49.81 v5(53.2,49.81) 50.01,49.81 49.4,49.2 43.21,49.2 42.72,48.71 42.72,48.7 40.93,46.91 ; v2(141.47,70.52) CC28.1 ; RC3.1 164.63,50.52 v2(165.15,51.04) ; CC44.1 140.08,69.63 140.39,69.63 v2(140.51,69.76) ; v2(163.82,68.68) 163.96,68.82 RC28.1 RC30.1
  IN1 w0.508: v2(72.33,51.92) 73.19,52.78 73.19,59.49 v2(72.47,60.21)
  IN1 w1.016: 168.68,59.94 170.23,59.94 171.07,59.11 174.51,59.11 175.26,59.85 175.26,61.29 179.12,65.15 185.9,65.15 188.14,62.92 194.95,62.92 195.61,63.58 198.09,63.58 199.06,62.61 202.58,62.61 204.27,64.3 205.55,64.3 206.95,65.7 206.97,65.68
  IN3 w1.016: 249.75,8.69 249.76,8.7 249.76,13.91 248.6,15.06 v2(247.96,15.06) 247.96,15.93 249.25,17.22 249.25,19.91 249.69,20.36 249.69,25.06 248.98,25.77 248.98,27.95 252.44,31.41 262.63,31.41 265.72,34.51 265.72,70.49 265.5,70.71 254.11,70.71 253.1,71.73 248.93,71.73 246.38,74.28 244.25,74.28 243.87,73.9 243.87,72.75 241.79,70.67 221.44,70.67
  BOTTOM w0.229: UC1.AE20 140.09,69.35 140.51,69.77 v2(140.51,69.76) ; v2(142.78,67.65) 143.09,67.34 UC1.AH14
  BOTTOM w0.254: UC1.AE20 139.69,68.89 UC1.AE21 ; UC1.AC9 UC1.AA9 145.28,71.24 v2(145.15,71.37)
  BOTTOM w0.508: v2(71.72,51.92) 71.72,51.91 68.63,48.82 57.77,48.82 57.4,48.44 56.08,48.44 v2(55.03,49.49) ; RC261.1 168.29,66.2 v2(168.53,66.45)
  BOTTOM w1.016: 155.75,51.92 153.78,51.92 152.13,50.27 77.9,50.27 76.31,51.85 73.27,51.85
  vias: v2(150.67,55.32) v2(151.88,54.71) v2(154.39,53.57) v2(155.61,52.83) v2(156.26,52.83) v2(159.65,70.17) v2(159.98,68.36) v2(165.14,65.65) v2(167.59,60.22) v2(167.59,59.64) v2(208.23,68.71) v2(208.23,68.11) v2(220.6,71.77) v2(220.6,71.11)
+3.3V_ALW_PCH_U43:
  vias: v1(205.91,72.73)
+3.3V_ALW_U37: length 10.8
  TOP w0.279: C331.1 12.95,35.41 14.01,35.41 14.37,35.77 U37.A54 ; U37.A17 v1(26.94,30.77) 27.19,30.52 27.91,30.52 28.36,30.07 ; U37.A43 18.93,40.43 19.43,40.93 v2(19.43,40.97)
  TOP w0.305: v2(24.09,36.22) 24.39,36.52 U37.B30
  TOP w0.318: v2(18.49,30.63) 18.49,30.52 18.18,30.21 U37.B5
  TOP w0.508: v2(13.97,32.89) 13.94,32.92 C330.1 ; v2(27.48,29.57) 27.67,29.76 28.04,29.76 28.36,30.07 C332.1 ; v2(12.6,34.45) 12.6,34.45 12.6,34.62 12.76,34.78 C331.1
  vias: v2(30.95,28.22) v2(31.32,28.68)
+3.3V_ALW_U38: length 42.8
  TOP w0.127: v1(11.93,13.12) 11.54,13.5 10.47,13.5
  TOP w0.279: U38.A52 18.93,16.83 18.58,17.18 C355.1 ; C350.1 31.74,15.98 31.09,15.33 U38.A26 ; C356.1 24.44,21.99 U38.A41 ; U38.A11 25.94,7.33 C351.1
  TOP w0.305: U38.B3 21.68,9.99 21.68,10.4 21.59,10.49 v2(21.59,10.64) ; 29.13,19.91 28.69,19.47 U38.B35
  TOP w0.457: v2(26.53,7.29) C351.1
  TOP w0.508: v2(23.55,22.5) 23.8,22.25 C356.1 ; R490.1 18.53,7.96 v2(19.17,7.96) 19.17,7.36 C349.1 ; v2(31.61,21.95) 31.31,22.25 C354.1 29.58,21.61 29.13,21.17 29.13,19.91 ; v2(17.34,16.53) C355.1 ; C350.1 31.98,16.14 32.22,16.38 v2(32.22,16.61) ; v2(34.6,12.41) R336.1
  IN1 w0.508: v2(17.34,16.53) 17.34,15.01 18.75,13.6 18.75,8.39 19.17,7.97 v2(19.17,7.96)
  IN2 w0.508: v2(19.17,7.96) 19.76,7.38 22.3,7.38 22.57,7.11 23.4,7.11 23.71,6.8 26.04,6.8 v2(26.53,7.29)
  BOTTOM w0.508: v2(21.59,10.64) 21.59,9.95 20.25,8.6 19.66,8.6 19.17,8.11 v2(19.17,7.96)
  vias: v2(10.11,14.4) v2(10.13,13.77)
+3.3V_ALWP: length 24.8
  TOP w0.254: 200.81,64.01 202.78,64.01 203.02,63.77 203.02,62.94 203.37,62.6 203.37,49.67 203.87,49.16 203.87,47.43 203.11,46.67 203.11,45.64 202.53,45.06 PR100.1
  vias: v1(199.39,66.59) v2(197.31,66.01) v2(197.28,65.38) v2(197.99,66.01) v2(198.01,65.37) v2(198.68,66.01) v2(198.68,65.38) v2(199.31,66.01) v2(199.31,65.38) v2(199.95,66.01) v2(199.95,65.38) v2(200.58,66.01) v2(200.58,65.38)
+3.3V_CAM: length 62.3
  TOP w1.016: 66.66,76.56 63.45,73.34 61.76,73.34 61.53,73.57 60.16,73.57 59.14,74.59 59.14,75.89 58.48,76.56 57.18,76.56 57.04,76.69
  IN1 w1.016: 93.65,95.72 75.04,95.72 74.12,94.8 71.28,94.8 61.86,85.38 59.16,85.38 55.61,81.84 55.61,78.08
  BOTTOM w0.254: JEDP1.33 67.36,76.94 67.03,77.76 v2(67.03,77.77)
  vias: v1(56.25,77.44) v2(55.68,77.14) v2(55.68,76.56) v2(66.47,77.44) v2(93.24,96.62) v2(93.82,96.62)
+3.3V_CAM_Q:
  vias: v1(93.74,94.88)
+3.3V_HDD: length 5.8
  TOP w0.508: v2(45.87,32.79) 45.87,32.08 45.57,31.77 v5(45.57,30.97) R155.1
  BOTTOM w0.254: v2(45.87,32.79) 46.36,32.31 46.36,31.65 45.69,30.99 45.69,30.89
  vias: v2(41.43,20.34) v2(41.4,19.74) v2(41.45,19.07) v2(45.57,18.41) v2(46.18,18.41) v2(46.76,18.44) v2(199.24,29.74) v2(199.29,31.18) v2(199.25,30.38) v2(199.76,30.82)
+3.3V_HDD_U3: length 1.8
  TOP w0.102: PJP22.2 v1(200.62,31.75)
+3.3V_LAN: length 229.5
  TOP w0.254: U24.5 243.27,82.99 243.03,82.75 C198.1
  TOP w0.508: 260.08,73.89 260.29,74.09 261.39,74.09 261.58,73.9 261.58,72.59 R173.1 ; C198.1 241.71,81.94 241.33,81.56
  TOP w1.016: 241.33,81.56 241.33,80.57 240.75,80 240.75,78.4 242.02,77.13 244.33,77.13
  IN1 w1.016: 261.73,75.54 262.28,76.09 263.61,76.09 265.26,77.73 265.26,80.84 262.62,83.48 261.72,83.48
  IN3 w1.016: 179.73,62.74 179.73,66.41 180.9,67.58 184.18,67.58 185.22,68.62 188.85,68.62 189.81,69.58 190.44,69.58 192.43,71.56 197.49,71.56 198.31,72.39 200.02,72.39 202.12,74.48 202.37,74.48 203.87,75.98 203.87,76.58 204.94,77.65 205.99,77.65 208.47,80.12 210.63,80.12 213.08,82.57 217.78,82.57 218.48,81.88 222.5,81.88 223.71,83.08 234.75,83.08 234.91,83.25
  IN4 w0.508: v2(225.96,92.79) 225.96,93.05 228.82,95.91 v2(229.31,95.91)
  IN4 w1.016: 241.82,97.46 241.85,97.46 244.72,94.59 244.72,91.04 245.47,90.29 249.62,90.29 250.23,89.68 253.71,89.68 255.11,88.28 261.23,88.28 262.32,89.37 262.32,100.48 261.65,101.15 259.4,101.15 258.77,100.53 JLOM1.12
  BOTTOM w0.254: U23.4 229.33,101.09 v2(229.41,101) ; U23.21 225.93,92.81 v2(225.96,92.79) ; U23.1 228.78,102.59 228.97,102.78 v2(228.97,103.62) ; v2(223.11,99.03) 223.73,98.41 224.09,98.41 224.27,98.59 U23.30 ; U23.14 229.13,96.09 v2(229.31,95.91) ; U23.8 229.43,99.09 v2(229.53,99.19) ; v2(225.83,104.46) 225.83,104.08 225.93,103.98 U23.39
  BOTTOM w0.508: v2(229.53,99.19) 230,99.19 230.23,99.42 C193.1
  BOTTOM w1.016: 240.34,83.16 240.34,83.08 242.98,80.44 242.98,77.98 245.77,75.18 248.88,75.18 249.29,74.78 255.19,74.78 ; 198.82,41.88 198.82,40.97 194.65,36.8 192.56,36.8 190.16,39.2 187.74,39.2 187.25,38.71 182.79,38.71 176.61,44.89 176.61,57.25 177.27,57.91 177.27,60.88 178,61.62 178.61,61.62 ; 240.54,97.23 240.97,96.8 240.97,90.97 240.04,90.04 240.04,85.83
  vias: v2(180.05,61.87) v2(180.05,61.24) v2(200.04,42.32) v2(200.63,42.32) v2(239.65,97.6) v2(239.83,84.51) v2(240.27,97.57) v2(240.27,84.06) v2(260.4,74.78) v2(260.66,84) v2(260.73,83.41) v2(261.04,74.78) v5(235.45,100.37)
+3.3V_LAN_OUT: length 3.3
  TOP w0.203: U21.19 252.33,81.69 v2(252.43,81.79) ; v2(254.1,81.51) 254.1,81.43 253.93,81.26 U21.15 ; v2(248.59,78.27) 248.69,78.17 U21.29
  vias: v1(257.12,81.86) v2(256.34,81.32) v2(256.4,77) v2(256.97,81.32) v2(256.98,77.02)
+3.3V_LAN_U22: length 1.6
  TOP w0.102: v1(203.51,42.33) 203.31,42.14 PJP20.2
+3.3V_M: length 75
  TOP w0.508: v2(145.06,73.77) 145.06,73.41 CC40.1
  IN1 w0.508: v2(146.86,72.19) 146.86,72.29 145.38,73.77 v2(145.06,73.77)
  IN2 w0.508: v2(176.83,83.43) 176.83,83.09 176.14,82.41 176.14,81.37 174.33,79.56 174.33,77.47 173.79,76.92 173.79,76.33 174.09,76.02 v2(174.57,76.02)
  IN2 w1.016: 175.21,57.14 175.21,51.69 184.26,42.63 184.26,41.09 186.62,38.73 187.55,38.73 187.91,38.38 187.91,37.45 188,37.36
  IN3 w0.254: 147.18,71.73 146.86,72.04 v2(146.86,72.19) 147.36,72.68 150.93,72.68 151.12,72.49 151.12,71.98 150.87,71.73 147.18,71.73
  IN3 w0.508: v2(174.57,76.02) 173.35,74.8 169.06,74.8 v2(168.92,74.66) 167.16,72.9 165.35,72.9 164.73,72.28 164.3,72.28 163.97,72.61 161.26,72.61 160.33,71.68 156.18,71.68 155.5,72.36 153.28,72.36 152.98,72.07 152.02,72.07 151.85,72.24 151.12,72.24
  BOTTOM w0.254: v2(146.86,72.19) 146.69,72.01 UC1.Y8
  BOTTOM w0.381: R1.1 v2(168.92,74.66)
  vias: v2(173.72,68.83) v2(174.32,68.83) v2(188.94,37.2) v2(189.33,36.75) v5(174.76,70.84)
+3.3V_M_U45: length 1.2
  TOP w0.102: v1(188.16,36.25) 188.77,35.64 C399.1
+3.3V_MSATA_WWAN: length 88.6
  TOP w0.508: v2(205.03,50.46) 205.46,50.89 R217.1 ; R216.1 205.47,48.22 v2(205.08,48.62) ; JMINI2.24 207.62,52.95 207.11,53.45 C252.1 206.44,53.45 205.92,52.94 v2(205.92,52.54)
  IN2 w0.508: v2(165.66,53.73) 165.66,55.05 164.5,56.21 164.5,57.94 163.17,59.27 163.17,61.01 162.55,61.63 162.55,63.48 159.37,66.66 159.37,69.51 158.41,70.47 158.41,75.29 157.1,76.61 v2(156.29,76.61)
  IN4 w0.508: v2(190.58,49.75) 190.58,49.43 182.59,41.44 171.21,41.44 168.16,44.49 168.16,51.23 v2(165.66,53.73)
  BOTTOM w0.508: R160.1 155.82,76.83 156.05,76.61 v2(156.29,76.61) ; v2(205.08,48.62) 201.59,48.62 199.72,46.75 191.57,46.75 190.58,47.74 v2(190.58,49.75)
  vias: v2(202.63,34.85) v2(202.64,34.15) v2(205.88,62.27) v2(205.88,61.68) v2(205.96,62.85) v2(208.32,40.22) v2(208.32,39.64) v2(208.32,39.05) v5(207.82,65.19)
+3.3V_MSATA_WWAN_U22: length 1.8
  TOP w0.102: PJP21.2 v1(198.23,35.28)
+3.3V_RTC_LDO: length 134.1
  TOP w0.508: PR103.2 196.72,44.02 196.72,42.76 197.15,42.34 197.74,42.34 198.86,43.46 200.32,43.46 v2(200.67,43.81) ; PD3.3 267.81,57.06 268.17,57.42 268.17,69.55 267.2,70.52 267.2,73.59 266.56,74.22 266.56,79 262.15,83.41 262.15,84.3 261.39,85.06 v1(258.13,85.06) 246.71,85.06 245.64,86.13 240.02,86.13 238.82,84.94 238.82,83.79 237.72,82.69 237.72,80.68 v2(236.91,79.87)
  IN1 w0.508: v2(236.91,79.87) 234.94,79.87 234.32,80.49 225.35,80.49 224.26,79.4 217.58,79.4 217.55,79.38 215.76,79.38 212.34,75.96 212.34,72.07 211.79,71.51 209.68,71.51 207.09,68.92 207.09,68.34 v2(206.83,68.08)
  IN4 w0.508: v2(206.83,68.08) 206.39,68.08 205.82,67.51 205.82,66.01 204.32,64.51 204.32,56.12 203.49,55.29 203.49,49.54 202.36,48.41 202.36,47.29 203.04,46.62 203.04,44.79 201.7,43.46 201.03,43.46 v2(200.67,43.81)
+3.3V_RUN: length 794.7
  TOP w0.203: PU500.20 92.68,73.24 v2(92.86,73.43) 92.65,73.64 PU500.21 ; C210.1 263.12,20.1 262.56,20.1 262.16,19.7 U27.42
  TOP w0.254: UC6.14 74.5,74.57 CC41.1 ; U19.34 174.14,84.19 v2(174.45,83.88) ; C411.1 235.27,91.08 235.64,90.72 235.64,89.95 235.49,89.81 U49.14 ; v2(170.82,89.52) 170.82,89.45 170.64,89.27 U19.12 ; 166.29,85.57 166.69,85.97 U19.21
  TOP w0.381: UC2.5 169.77,74.51 169.04,73.77 RC116.1
  TOP w0.406: C341.2 255.39,29.45 U26.5 253.75,29.45 v2(253.67,29.37) ; U30.5 194.55,41.81 C338.1 ; UC3.5 CC9.1
  TOP w0.432: QC1.2 163.88,71.16 164.07,71.35 164.07,71.86 163.88,72.05 QC1.5 163.88,74.46 v2(164.26,74.84)
  TOP w0.508: R122.1 R123.1 124.3,27.9 v2(123.55,27.15) 123.43,27.27 123.43,27.28 123.05,27.66 122.03,27.66 121.6,27.23 CD25.1 CD24.1 ; v2(106.57,87.99) 106.57,88.13 106.83,88.39 RC259.1 ; v2(143.88,104.94) 143.88,104.88 144.44,104.32 Q1.3 145.71,104.32 146.24,103.78 C61.1 R94.1 ; v2(154.98,87.06) 155.16,87.25 155.16,88.91 RC283.1 ; RC181.1 122.91,106.72 124.1,105.52 v2(124.1,104.09) ; C152.1 166.17,85.45 166.29,85.57 ; C152.1 166.61,83.3 167.07,82.84 R161.1 ; C152.1 C153.1 164.38,83.3 C151.1 163.94,83.73 v2(162.83,83.73) ; v2(205.4,97.33) 205.4,97.07 204.86,96.53 202.7,96.53 202.62,96.46 201.54,96.46 201.13,96.86 201.13,97.32 200.61,97.84 Q121.2 199.92,97.84 199.67,98.09 R473.1 199.14,97.89 198.22,96.98 R475.2 ; CC41.1 74.47,75.18 75.04,75.75 v2(75.04,76.87) ; RC189.1 159.88,77.38 159.85,77.35 v2(159.77,77.35) 159.76,77.35 159.75,77.34 159.7,77.34 159.66,77.38 RC201.1 ; v2(31.14,32.92) 31.15,32.93 32.37,32.93 32.74,32.56 R301.1 ; v2(262.69,19.53) 263,19.85 C210.1 ; v2(12.95,18.01) 12.95,18.01 13.13,18.2 R360.1 ; CC59.1 141.53,75.48 v2(141.91,75.09) 141.41,74.6 CC45.1 ; v2(198.43,28.01) 198.77,28.01 199.12,28.36 CD60.1 CD61.1 ; RC116.1 168.71,73.98 168.14,74.55 CC8.1 168.1,74.74 v2(166.93,74.74) ; v2(195.63,42.66) 195.42,42.44 194.92,42.44 194.6,42.13 C338.1 ; v2(59.41,54.69) 59.41,55.22 58.64,55.99 58.64,57.7 55.65,60.68 55.65,64.32 53.21,66.76 C64.1 53.21,68.16 v2(53.42,68.36) ; v2(198.3,24.42) 198.23,24.49 RD10.2 ; RC193.1 160.4,76.39 v2(159.75,76.39) 159.11,76.39 RC191.1 ; v2(165.63,88.39) 165.93,88.69 C154.1 ; R35.1 31.1,24.91 30.77,25.25 v2(30.71,25.25) ; R358.1 16.69,4.67 17.43,5.42 v2(17.43,6.14) ; R212.1 v2(251.1,20.14) ; R67.1 236.89,90.28 v2(235.95,91.22) 235.92,91.26 C411.1 ; C383.1 269.35,82.36 U50.1 v2(269.35,84.64) ; 43.78,27.25 43.78,26.43 43.26,25.91 41.56,25.91 v2(40.82,25.16) ; v2(164.26,74.84) 164.85,75.42 RC178.1 ; v2(35.81,15.21) 35.69,15.09 R408.1 ; RC145.1 RC143.1 144.51,89.4 v2(144.71,89.6) ; R460.1 184.26,91.12 185.05,90.34 185.05,88.74 v2(184.68,88.38) ; C459.2 v2(134.38,74.51) ; RC218.1 163.72,76.49 163.32,76.1 v2(163.09,76.1) ; v2(23.23,25.64) R304.1 ; RC284.1 159.69,78.33 159.71,78.36 v2(159.75,78.36) 159.79,78.36 159.82,78.33 RC203.1 ; v2(143.26,72.49) 142.74,72.49 CC43.1 ; R163.1 237.68,86.34 238.12,86.78 v2(238.12,86.99) ; v2(167.41,71.96) 168.15,71.96 RC81.1 168.5,70.33 172.43,66.41 174.47,66.41 177.18,63.7 177.18,58.48 176.62,57.92 176.62,55.7 176.03,55.12 171.45,55.12 170.23,56.34 CC9.1 ; v2(38.18,13.97) 38.18,13.16 37.43,12.41 R376.1 36.75,11.34 35.44,10.02 33.97,10.02 33.58,9.63 33.58,8.38 33.81,8.15 33.81,6.81 33.03,6.03 R362.1 ; v2(146.86,74.1) 146.13,74.1 RC216.2 ; RC282.1 161.66,79.73 161.6,79.79 v2(161.6,79.98)
  TOP w1.016: 87.52,82.18 90.87,85.54 90.87,92.77 90.21,93.43 Q3.3
  TOP w1.27: 181.6,74.27 181.6,76.87 182.49,77.76 ; 182.83,73.02 183.39,73.02 185.15,71.26 185.97,71.26
  IN1 w0.254: v2(146.86,73.14) 147.33,72.68 150.17,72.68 150.61,73.13 150.61,74.46 150.48,74.33 149.56,74.33 149.16,73.94 149.16,73.81 148.98,73.63 147.3,73.63 146.86,74.07 v2(146.86,74.1)
  IN1 w0.508: v2(255.45,25.07) 255.45,25.76 255.89,26.2 255.89,28.55 255.07,29.37 v2(253.67,29.37) ; v2(201.35,44.4) 201.93,43.82 201.93,33.71 202.26,33.38 202.26,29.77 203.16,28.87 203.33,28.87 205.6,26.59 205.6,25.73 206.43,24.9 206.43,23.48 207.2,22.71 207.42,22.71 208.06,22.07 208.06,15.41 205.18,12.53 205.18,7.67 v2(205.18,7.67) ; v2(59.56,46.66) 59.56,43.31 60.8,42.07 60.8,40.91 59.87,39.98 v2(59.87,39.34) 61.34,37.87 61.34,35.93 v2(61.18,35.76) ; v2(20.18,19.14) 20.18,21.58 21.84,23.24 21.84,24.17 23.23,25.55 v2(23.23,25.64) ; v2(35.81,15.21) 36.9,15.21 37.29,15.61 37.29,16.94 39.68,19.33 39.68,23.59 40.82,24.74 v2(40.82,25.16) ; v2(92.86,73.43) 92.53,73.43 90.55,75.41 86.35,75.41 85.28,76.48 v2(83.73,76.48) 83.46,76.48 82.93,77.01 81.76,77.01 81.23,76.48 80.2,76.48 79.39,77.29 75.46,77.29 v2(75.04,76.87) 73.71,76.87 71.16,74.32 v2(71.16,72.08) ; v2(134.38,74.51) 135.39,74.51 136.46,75.58 137.88,75.58 138.7,74.76 139.74,74.76 140.23,75.26 141.74,75.26 v2(141.91,75.09) ; v2(12.95,18.01) 12.95,18 12.95,17.88 13.87,16.97 13.87,15.54 15.1,14.31 15.1,9.28 15.66,8.72 15.68,8.72 17.43,6.98 v2(17.43,6.14) ; v2(108.32,82.78) 108.32,83.63 108.05,83.9 107.48,83.9 106.45,84.92 106.45,85.46 105.74,86.17 105.74,87.16 v2(106.57,87.99) ; 150.61,74.46 151.24,75.09 155.65,75.09 156.95,76.39 v2(159.75,76.39)
  IN2 w0.508: v2(166.93,74.74) 166.93,73.13 167.41,72.64 v2(167.41,71.96) ; v3(183.19,78.78) 181.66,77.25 181.66,71.86 182.47,71.04 v2(182.47,69.86) 182.47,68.38 182.52,68.33 182.52,52.03 187.67,46.89 190.81,46.89 192.42,45.27 193.6,45.27 194.67,44.21 194.67,43.26 195.03,42.89 195.4,42.89 v2(195.63,42.66) 195.86,42.89 196.41,42.89 197.13,43.61 198.76,43.61 199.16,43.2 200.97,43.2 201.35,43.59 v2(201.35,44.4) ; v2(59.41,54.69) 59.41,56.29 60.43,57.3 60.43,58.25 v2(59.42,59.26) 58.78,59.91 58.78,62.17 59.75,63.14 63.74,63.14 64.52,63.92 64.52,66.52 65.33,67.33 v2(67.97,67.33) ; v2(30.71,25.25) 30.71,24.29 29.51,23.1 25.7,23.1 25.26,23.53 25.26,25.18 24.8,25.64 v2(23.23,25.64) ; v2(177.94,88.53) 177.94,89.23 177.32,89.85 177.32,91.21 170.85,97.68 v2(170.03,97.68) ; v2(143.88,104.94) 141.62,102.68 125.46,102.68 124.1,104.04 v2(124.1,104.09) ; v2(161.6,79.98) 161.6,78.74 161.57,78.71 ; v2(198.3,24.42) 198.3,24.82 199.19,25.71 199.19,27.73 198.92,28.01 v2(198.43,28.01)
  IN2 w1.016: 100.76,97.18 97,93.42 90.12,93.42
  IN3 w0.508: v2(188.21,7.23) 188.61,6.83 189.32,6.83 189.87,7.38 189.87,9.19 190.45,9.78 194.34,9.78 194.84,10.29 v2(196.47,10.29) 197.51,9.25 197.51,7.91 199.17,6.26 203.19,6.26 204.6,7.67 v2(205.18,7.67) ; v2(40.82,25.16) 40.35,25.16 39.12,26.4 37.1,26.4 36.48,25.78 35.33,25.78 33.96,24.41 31.55,24.41 v2(30.71,25.25) ; v2(38.15,32.11) 38.15,31.88 38.51,31.52 39.9,31.52 40.54,32.16 40.54,33.2 41.37,34.03 44.74,34.03 45.1,33.67 46.64,33.67 51.41,38.44 55.99,38.44 56.9,39.34 v2(59.87,39.34)
  IN4 w0.508: v2(20.18,19.14) 20.08,19.24 20.08,19.37 19.19,20.25 17.79,20.25 15.6,18.06 12.99,18.06 v2(12.95,18.01) ; v2(59.56,46.66) 58.34,47.88 58.34,54.08 58.95,54.69 v2(59.41,54.69) ; v2(31.14,32.92) 31.27,33.04 37.21,33.04 v2(38.15,32.11) ; v2(204.71,99.57) 204.71,98.45 205.4,97.76 v2(205.4,97.33) ; v2(143.88,104.94) 144.64,104.18 145.75,104.18 150.68,99.25 152.88,99.25 153.75,98.39 158.68,98.39 159.48,99.19 168.51,99.19 v2(170.03,97.68) ; v2(71.16,72.08) 71.16,72.73 71.09,72.8 70.03,72.8 69.42,72.19 69.42,68.3 68.45,67.33 v2(67.97,67.33) ; v2(205.18,7.67) 204.34,8.51 204.34,11.74 202.84,13.23 202.84,22.15 201.89,23.1 201.28,23.1 199.95,24.43 199.95,25 199.42,25.53 199.42,27.6 199.02,28.01 v2(198.43,28.01) ; v2(38.18,13.97) 37.06,13.97 v2(35.81,15.21)
  BOTTOM w0.254: UC1.W9 146.24,72.22 UC1.V8 146.86,72.84 v2(146.86,73.14) ; v2(142.16,76.17) 142.48,76.49 UC1.K16 UC1.K14 ; JEDP1.1 52.96,69.68 53.42,69.23 v2(53.42,68.36) ; Q120.5 Q120.2 203.35,99.29 203.91,99.85 204.43,99.85 v2(204.71,99.57) ; UC1.T9 v2(146.86,74.1) 146.69,73.92 UC1.U8
  BOTTOM w0.356: v2(123.55,27.15) 122.99,27.15 122.78,27.36 121.79,27.36 121.3,26.86 JDIMM1.199 ; v2(198.43,28.01) 198.18,28.01 197.8,27.63 JDIMM2.199
  BOTTOM w0.457: RC11.2 RC57.1 158.99,75.37 159.27,75.09 v2(159.74,75.09)
  BOTTOM w0.508: RC285.1 153.31,86.04 154.08,86.81 v2(154.08,87.1) ; RC204.1 RC208.1 160.22,78.36 v2(159.75,78.36) 159.71,78.36 159.69,78.33 RC284.1 ; RC149.1 147.31,89.45 v2(147.18,89.57) ; v2(106.57,87.99) 106.57,89.62 106.93,89.99 106.93,90.55 106.3,91.19 106.3,91.9 107.07,92.67 107.07,93.8 106.07,94.8 104.43,94.8 ; v2(123.55,27.15) 123.55,28.98 120.85,31.67 120.85,34.65 119.74,35.76 v2(61.18,35.76) ; v2(182.47,69.86) 183.45,70.84 191.47,70.84 192.01,71.39 194.3,71.39 ; v2(165.63,88.39) 165.85,88.61 165.85,90.4 166.42,90.97 170.23,90.97 170.92,90.28 170.92,89.62 v2(170.82,89.52) ; RC147.1 150.32,88.9 150.8,89.38 v2(150.8,89.57) ; v2(162.02,73.24) 161.97,73.19 RC170.2 ; v2(31.14,32.92) 31.32,32.74 31.32,29.69 30.34,28.72 30.34,27.97 30.96,27.35 30.96,25.5 v2(30.71,25.25) ; RC201.1 159.12,77.34 159.75,77.34 159.76,77.35 v2(159.77,77.35) 160.35,77.35 RC295.1 ; v2(201.3,90.8) 201.3,91.31 201.71,91.73 204.39,91.73 205.09,92.43 205.09,93.55 205.98,94.44 205.98,96.09 205.4,96.67 v2(205.4,97.33) ; v2(270.43,49.76) 270.41,49.73 270.41,49.5 271.12,48.79 R480.1 ; v2(159.74,72.29) 159.74,72.3 ; 159.74,72.3 159.68,72.24 RC12.2 ; 159.74,72.3 159.8,72.24 RC55.1 ; v2(108.32,82.78) 108.56,82.54 RC56.1 ; v2(154.98,87.06) 155.11,87.19 RC289.1 ; RC199.2 159.77,74.21 v2(159.75,74.22) ; RC141.1 RC139.1 144.45,89.34 v2(144.71,89.6)
  vias: v2(87.74,92.84) v2(87.77,93.42) v2(103.73,96.95) v2(104.32,96.95) v2(166.94,77.24) v2(201.4,87.17) v2(202.03,87.17) v2(244.82,73.35) v2(244.82,72.77) v2(251.57,26.07) v2(252.27,26.96) v2(252.26,10.25) v2(252.6,9.75) v2(252.78,17.94) v2(252.84,10.29) v2(253.42,17.94) v3(182.8,79.34) v3(183.5,79.34) v3(183.88,78.78) v5(86.22,81.13)
