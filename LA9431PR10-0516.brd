# Allegro board LA9431PR10-0516.brd (continued)
## Nets (continued)
CFD_PWRBTN#_XDP: JXDP1.41 RC107.2
CFG0: JXDP1.9 RC232.1 UC1.AC60
CFG1: JXDP1.11 RC233.1 UC1.AC62
CFG2: JXDP1.15 UC1.AC63
CFG3: JXDP1.17 RC99.2 UC1.AA63
CFG3_R: JXDP1.60 RC99.1
CFG4: JXDP1.27 RC238.1 UC1.AA60
CFG5: JXDP1.29 UC1.Y62
CFG6: JXDP1.33 UC1.Y61
CFG7: JXDP1.35 UC1.Y60
CFG8: JXDP1.10 RC241.1 UC1.V62
CFG9: JXDP1.12 RC240.1 UC1.V61
CFG10: JXDP1.16 RC239.1 UC1.V60
CFG11: JXDP1.18 UC1.U60
CFG12: JXDP1.28 UC1.T63
CFG13: JXDP1.30 UC1.T62
CFG14: JXDP1.34 UC1.T61
CFG15: JXDP1.36 UC1.T60
CFG16: JXDP1.6 UC1.AA62
CFG17: JXDP1.4 UC1.AA61
CFG18: JXDP1.24 UC1.U63
CFG19: JXDP1.22 UC1.U62
CFG_RCOMP: RC235.1 UC1.V63
CHAGER_SRC: PC707.1 PC711.1 PC712.1 PC741.1 PC742.1 PJP700.2 PL700.1 PQ704.5
CHARGE_EN: R313.2 U37.A45
CHARGE_PBATT: T110.1(TP-1) U37.B16
CHARGER_CELL_PIN: PD818.2 PR750.1
CHARGER_SMBCLK: PU700.9 R350.2 U38.B50
CHARGER_SMBDAT: PU700.8 R348.2 U38.A47
CHG_LGATE: PQ706.4 PU700.15
CHG_UGATE: PQ704.4 PU700.18
CHGVR_DCIN: PR833.2 PU800.35
CLK_27M_IN: R66.1 R107.2 U6.K1
CLK_27M_IN_R: C42.1 R107.1 Y1.1
CLK_27M_OUT: C43.1 R66.2 U6.L1 Y1.3
CLK_BIASREF: RC45.1 UC1.C26
CLK_DDC2_DOCK: JDOCK1.48 R77.2
CLK_KBD: JDOCK1.78 R354.2 U38.A38
CLK_MSE: JDOCK1.71 R356.2 U38.A39
CLK_PCI_5048: R324.1 RC61.2 U37.A28
CLK_PCI_DOCK: JDOCK1.121 R273.1 RC64.2
CLK_PCI_LPDEBUG: JMINI3.19 RC66.2
CLK_PCI_MEC: R382.1 RC63.2 U38.A29
CLK_PCI_TPM_TCM: RC58.2 U25.21
CLK_PCIE_LAN: U21.44 UC1.B42
CLK_PCIE_LAN#: U21.45 UC1.C41
CLK_PCIE_MINI1: JMINI2.13 UC1.A37
CLK_PCIE_MINI1#: JMINI2.11 UC1.B37
CLK_PCIE_MINI2: JMINI1.13 UC1.C37
CLK_PCIE_MINI2#: JMINI1.11 UC1.B38
CLK_PCIE_MMI: U27.3 UC1.B39
CLK_PCIE_MMI#: U27.2 UC1.A39
CLK_TP_SIO: R444.1 U38.A37
CLKRUN#: RP6.8 U25.15 U37.B20 U38.A32 UC1.V5
CODEC_IRQ: RC154.1 UC1.L4
CONTACTLESS_DET#: JUSH1.17 RC137.2 UC1.U6
CPPE#: JMINI1.37 RC185.2 UC1.J1
CPU_DETECT#: R284.2 U37.A3 UC1.D61
CPU_DPB_AUX: RC153.2 UC1.B5
CPU_DPB_AUX#: RC147.2 UC1.C5
CPU_DPB_CTRLCLK: Q120.1 RC139.2 UC1.B9
CPU_DPB_CTRLCLK_R: JHDMI1.15 Q120.6 R471.1
CPU_DPB_CTRLDAT: Q120.4 RC141.2 UC1.C9
CPU_DPB_CTRLDAT_R: JHDMI1.16 Q120.3 R470.1
CPU_DPC_AUX: RC155.2 U19.14 UC1.A6
CPU_DPC_AUX#: RC149.2 U19.13 UC1.B6
CPU_DPC_CTRLCLK: RC143.2 U49.12 UC1.D9
CPU_DPC_CTRLDAT: RC145.2 U49.9 UC1.D11
CPU_PWR_DEBUG#: RC108.1 RC253.2 RC258.1 UC1.H59
CPU_PWR_DEBUG#_R: JXDP1.45 RC108.2
CPU_VTT_ON: R305.2 U37.B17
CPU_XDP_PRDY#: JXDP1.5 UC1.J62
CPU_XDP_PREQ#: JXDP1.3 RC120.2 UC1.K62
CPU_XDP_TCLK: JXDP1.57 RC97.1 RC124.1 RC127.2 UC1.E60
CPU_XDP_TDI: RC119.2 UC1.F63 UC6.6
CPU_XDP_TDO: RC122.2 UC1.F62 UC6.3
CPU_XDP_TMS: RC118.2 UC1.E61 UC6.8
CPU_XDP_TRST#: RC131.2 RC135.1 UC1.E59 UC6.11
CPUSB#: JMINI1.40 RC191.2 UC1.K3
CS_1.35V: PR201.2 PU11.13
CSN1: PC502.1 PC513.1 PL500.2 PR514.2 PR515.2 PU500.18
CSP1: PC502.2 PC513.2 PH501.1 PR512.1 PR514.1 PU500.17
CSS_GC: PR702.1 PU800.10
CSSN_1: PQ701.3 PQ703.2 PR703.1 PR705.1 PR707.1 PR748.2 PU703.5
CSSP_1: PQ702.3 PQ703.5 PR703.2 PR704.1 PR706.1 PR749.1
D_CLKRUN#: JDOCK1.111 R299.2 U37.A19
D_DLDRQ1#: JDOCK1.117 R301.2 U37.B24
D_LAD0: JDOCK1.97 U37.B29
D_LAD1: JDOCK1.99 U37.B28
D_LAD2: JDOCK1.103 U37.A25
D_LAD3: JDOCK1.105 U37.A24
D_LFRAME#: JDOCK1.109 U37.B23
D_SERIRQ: JDOCK1.115 R300.2 U37.A20
DAI_12MHZ#: JDOCK1.89 R137.1 RE4.1
DAI_BCLK#: JDOCK1.77 R139.1 RE5.1
DAI_DI: JDOCK1.83 R144.1
DAI_DO#: JDOCK1.85 R142.1
DAI_LRCK#: JDOCK1.79 R143.1
DAT_DDC2_DOCK: JDOCK1.46 R81.2
DAT_KBD: JDOCK1.80 R355.2 U38.B41
DAT_MSE: JDOCK1.73 R357.2 U38.B42
DAT_TP_SIO: R441.1 U38.B40
DC_BLOCK_GC: PR701.2 PU800.7
DC_IN_SS: PR831.2 PU800.34
DC_TEST_A3_B3: UC1.A3 UC1.B3
DC_TEST_A4: RC254.1 UC1.A4
DC_TEST_A60: RC266.1 UC1.A60
DC_TEST_A61_B61: UC1.A61 UC1.B61
DC_TEST_A62: RC266.2 UC1.A62
DC_TEST_AV1: RC268.1 UC1.AV1
DC_TEST_AW1: RC268.2 UC1.AW1
DC_TEST_AW63: RC269.1 UC1.AW63
DC_TEST_AY2_AW2: UC1.AW2 UC1.AY2
DC_TEST_AY3_AW3: UC1.AW3 UC1.AY3
DC_TEST_AY60: RC269.2 UC1.AY60
DC_TEST_AY61_AW61: UC1.AW61 UC1.AY61
DC_TEST_AY62_AW62: UC1.AW62 UC1.AY62
DC_TEST_B62_B63: UC1.B62 UC1.B63
DC_TEST_C1_C2: UC1.C1 UC1.C2
DDI1_LANE_N0: C272.2 UC1.C54
DDI1_LANE_N1: C270.2 UC1.B58
DDI1_LANE_N2: C209.2 UC1.B55
DDI1_LANE_N3: C191.2 UC1.A57
DDI1_LANE_P0: C271.2 UC1.C55
DDI1_LANE_P1: C269.2 UC1.C58
DDI1_LANE_P2: C199.2 UC1.A55
DDI1_LANE_P3: C103.2 UC1.B57
DDI2_LANE_N0: U19.3 UC1.C51
DDI2_LANE_N1: U19.6 UC1.C53
DDI2_LANE_N2: U19.8 UC1.C49
DDI2_LANE_N3: U19.10 UC1.A53
DDI2_LANE_P0: U19.4 UC1.C50
DDI2_LANE_P1: U19.7 UC1.B54
DDI2_LANE_P2: U19.9 UC1.B50
DDI2_LANE_P3: U19.11 UC1.B53
DDR3_DRAMRST#: CD3.1 CD34.1 JDIMM1.30 JDIMM2.30 RC279.1
DDR3_DRAMRST#_CPU: RC279.2 RD3.2 UC1.AV15
DDR_A_BS0: JDIMM1.109 UC1.AU35
DDR_A_BS1: JDIMM1.108 UC1.AV35
DDR_A_BS2: JDIMM1.79 UC1.AY41
DDR_A_CAS#: JDIMM1.115 UC1.AU34
DDR_A_D0: JDIMM1.129 UC1.AH63
DDR_A_D1: JDIMM1.131 UC1.AH62
DDR_A_D2: JDIMM1.141 UC1.AK63
DDR_A_D3: JDIMM1.140 UC1.AK62
DDR_A_D4: JDIMM1.132 UC1.AH61
DDR_A_D5: JDIMM1.130 UC1.AH60
DDR_A_D6: JDIMM1.143 UC1.AK61
DDR_A_D7: JDIMM1.142 UC1.AK60
DDR_A_D8: JDIMM1.7 UC1.AM63
DDR_A_D9: JDIMM1.4 UC1.AM62
DDR_A_D10: JDIMM1.17 UC1.AP63
DDR_A_D11: JDIMM1.18 UC1.AP62
DDR_A_D12: JDIMM1.6 UC1.AM61
DDR_A_D13: JDIMM1.5 UC1.AM60
DDR_A_D14: JDIMM1.15 UC1.AP61
DDR_A_D15: JDIMM1.16 UC1.AP60
DDR_A_D16: JDIMM1.159 UC1.AP58
DDR_A_D17: JDIMM1.157 UC1.AR58
DDR_A_D18: JDIMM1.146 UC1.AM57
DDR_A_D19: JDIMM1.148 UC1.AK57
DDR_A_D20: JDIMM1.149 UC1.AL58
DDR_A_D21: JDIMM1.147 UC1.AK58
DDR_A_D22: JDIMM1.158 UC1.AR57
DDR_A_D23: JDIMM1.160 UC1.AN57
DDR_A_D24: JDIMM1.24 UC1.AP55
DDR_A_D25: JDIMM1.22 UC1.AR55
DDR_A_D26: JDIMM1.36 UC1.AM54
DDR_A_D27: JDIMM1.34 UC1.AK54
DDR_A_D28: JDIMM1.23 UC1.AL55
DDR_A_D29: JDIMM1.21 UC1.AK55
DDR_A_D30: JDIMM1.33 UC1.AR54
DDR_A_D31: JDIMM1.35 UC1.AN54
DDR_A_D32: JDIMM1.166 UC1.AY58
DDR_A_D33: JDIMM1.165 UC1.AW58
DDR_A_D34: JDIMM1.175 UC1.AY56
DDR_A_D35: JDIMM1.174 UC1.AW56
DDR_A_D36: JDIMM1.163 UC1.AV58
DDR_A_D37: JDIMM1.164 UC1.AU58
DDR_A_D38: JDIMM1.177 UC1.AV56
DDR_A_D39: JDIMM1.176 UC1.AU56
DDR_A_D40: JDIMM1.42 UC1.AY54
DDR_A_D41: JDIMM1.41 UC1.AW54
DDR_A_D42: JDIMM1.50 UC1.AY52
DDR_A_D43: JDIMM1.51 UC1.AW52
DDR_A_D44: JDIMM1.39 UC1.AV54
DDR_A_D45: JDIMM1.40 UC1.AU54
DDR_A_D46: JDIMM1.52 UC1.AV52
DDR_A_D47: JDIMM1.53 UC1.AU52
DDR_A_D48: JDIMM1.69 UC1.AK40
DDR_A_D49: JDIMM1.67 UC1.AK42
DDR_A_D50: JDIMM1.59 UC1.AM43
DDR_A_D51: JDIMM1.57 UC1.AM45
DDR_A_D52: JDIMM1.56 UC1.AK45
DDR_A_D53: JDIMM1.58 UC1.AK43
DDR_A_D54: JDIMM1.68 UC1.AM40
DDR_A_D55: JDIMM1.70 UC1.AM42
DDR_A_D56: JDIMM1.192 UC1.AM46
DDR_A_D57: JDIMM1.194 UC1.AK46
DDR_A_D58: JDIMM1.183 UC1.AM49
DDR_A_D59: JDIMM1.182 UC1.AK49
DDR_A_D60: JDIMM1.191 UC1.AM48
DDR_A_D61: JDIMM1.193 UC1.AK48
DDR_A_D62: JDIMM1.181 UC1.AM51
DDR_A_D63: JDIMM1.180 UC1.AK51
DDR_A_DQS0: JDIMM1.137 UC1.AJ62
DDR_A_DQS1: JDIMM1.12 UC1.AN61
DDR_A_DQS2: JDIMM1.154 UC1.AN58
DDR_A_DQS3: JDIMM1.29 UC1.AN55
DDR_A_DQS4: JDIMM1.171 UC1.AW57
DDR_A_DQS5: JDIMM1.47 UC1.AW53
DDR_A_DQS6: JDIMM1.64 UC1.AL42
DDR_A_DQS7: JDIMM1.188 UC1.AL49
DDR_A_DQS#0: JDIMM1.135 UC1.AJ61
DDR_A_DQS#1: JDIMM1.10 UC1.AN62
DDR_A_DQS#2: JDIMM1.152 UC1.AM58
DDR_A_DQS#3: JDIMM1.27 UC1.AM55
DDR_A_DQS#4: JDIMM1.169 UC1.AV57
DDR_A_DQS#5: JDIMM1.45 UC1.AV53
DDR_A_DQS#6: JDIMM1.62 UC1.AL43
DDR_A_DQS#7: JDIMM1.186 UC1.AL48
DDR_A_MA0: JDIMM1.98 UC1.AU36
DDR_A_MA1: JDIMM1.97 UC1.AY37
DDR_A_MA2: JDIMM1.96 UC1.AR38
DDR_A_MA3: JDIMM1.95 UC1.AP36
DDR_A_MA4: JDIMM1.92 UC1.AU39
DDR_A_MA5: JDIMM1.91 UC1.AR36
DDR_A_MA6: JDIMM1.90 UC1.AV40
DDR_A_MA7: JDIMM1.86 UC1.AW39
DDR_A_MA8: JDIMM1.89 UC1.AY39
DDR_A_MA9: JDIMM1.85 UC1.AU40
DDR_A_MA10: JDIMM1.107 UC1.AP35
DDR_A_MA11: JDIMM1.84 UC1.AW41
DDR_A_MA12: JDIMM1.83 UC1.AU41
DDR_A_MA13: JDIMM1.119 UC1.AR35
DDR_A_MA14: JDIMM1.80 UC1.AV42
DDR_A_MA15: JDIMM1.78 UC1.AU42
DDR_A_RAS#: JDIMM1.110 UC1.AY34
DDR_A_WE#: JDIMM1.113 UC1.AW34
DDR_B_BS0: JDIMM2.109 UC1.AL35
DDR_B_BS1: JDIMM2.108 UC1.AM36
DDR_B_BS2: JDIMM2.79 UC1.AU49
DDR_B_CAS#: JDIMM2.115 UC1.AM33
DDR_B_D0: JDIMM2.132 UC1.AY31
DDR_B_D1: JDIMM2.131 UC1.AW31
DDR_B_D2: JDIMM2.140 UC1.AY29
DDR_B_D3: JDIMM2.141 UC1.AW29
DDR_B_D4: JDIMM2.129 UC1.AV31
DDR_B_D5: JDIMM2.130 UC1.AU31
DDR_B_D6: JDIMM2.142 UC1.AV29
DDR_B_D7: JDIMM2.143 UC1.AU29
DDR_B_D8: JDIMM2.5 UC1.AY27
DDR_B_D9: JDIMM2.6 UC1.AW27
DDR_B_D10: JDIMM2.15 UC1.AY25
DDR_B_D11: JDIMM2.17 UC1.AW25
DDR_B_D12: JDIMM2.4 UC1.AV27
DDR_B_D13: JDIMM2.16 UC1.AU27
DDR_B_D14: JDIMM2.7 UC1.AV25
DDR_B_D15: JDIMM2.18 UC1.AU25
DDR_B_D16: JDIMM2.146 UC1.AM29
DDR_B_D17: JDIMM2.148 UC1.AK29
DDR_B_D18: JDIMM2.160 UC1.AL28
DDR_B_D19: JDIMM2.158 UC1.AK28
DDR_B_D20: JDIMM2.149 UC1.AR29
DDR_B_D21: JDIMM2.147 UC1.AN29
DDR_B_D22: JDIMM2.157 UC1.AR28
DDR_B_D23: JDIMM2.159 UC1.AP28
DDR_B_D24: JDIMM2.24 UC1.AN26
DDR_B_D25: JDIMM2.22 UC1.AR26
DDR_B_D26: JDIMM2.33 UC1.AR25
DDR_B_D27: JDIMM2.35 UC1.AP25
DDR_B_D28: JDIMM2.21 UC1.AK26
DDR_B_D29: JDIMM2.23 UC1.AM26
DDR_B_D30: JDIMM2.34 UC1.AK25
DDR_B_D31: JDIMM2.36 UC1.AL25
DDR_B_D32: JDIMM2.166 UC1.AY23
DDR_B_D33: JDIMM2.165 UC1.AW23
DDR_B_D34: JDIMM2.174 UC1.AY21
DDR_B_D35: JDIMM2.175 UC1.AW21
DDR_B_D36: JDIMM2.163 UC1.AV23
DDR_B_D37: JDIMM2.164 UC1.AU23
DDR_B_D38: JDIMM2.176 UC1.AV21
DDR_B_D39: JDIMM2.177 UC1.AU21
DDR_B_D40: JDIMM2.39 UC1.AY19
DDR_B_D41: JDIMM2.41 UC1.AW19
DDR_B_D42: JDIMM2.53 UC1.AY17
DDR_B_D43: JDIMM2.52 UC1.AW17
DDR_B_D44: JDIMM2.42 UC1.AV19
DDR_B_D45: JDIMM2.40 UC1.AU19
DDR_B_D46: JDIMM2.51 UC1.AV17
DDR_B_D47: JDIMM2.50 UC1.AU17
DDR_B_D48: JDIMM2.191 UC1.AR21
DDR_B_D49: JDIMM2.183 UC1.AR22
DDR_B_D50: JDIMM2.194 UC1.AL21
DDR_B_D51: JDIMM2.180 UC1.AM22
DDR_B_D52: JDIMM2.181 UC1.AN22
DDR_B_D53: JDIMM2.193 UC1.AP21
DDR_B_D54: JDIMM2.192 UC1.AK21
DDR_B_D55: JDIMM2.182 UC1.AK22
DDR_B_D56: JDIMM2.57 UC1.AN20
DDR_B_D57: JDIMM2.59 UC1.AR20
DDR_B_D58: JDIMM2.69 UC1.AK18
DDR_B_D59: JDIMM2.67 UC1.AL18
DDR_B_D60: JDIMM2.58 UC1.AK20
DDR_B_D61: JDIMM2.56 UC1.AM20
DDR_B_D62: JDIMM2.70 UC1.AR18
DDR_B_D63: JDIMM2.68 UC1.AP18
DDR_B_DQS0: JDIMM2.137 UC1.AV30
DDR_B_DQS1: JDIMM2.12 UC1.AW26
DDR_B_DQS2: JDIMM2.154 UC1.AM28
DDR_B_DQS3: JDIMM2.29 UC1.AM25
DDR_B_DQS4: JDIMM2.171 UC1.AV22
DDR_B_DQS5: JDIMM2.47 UC1.AW18
DDR_B_DQS6: JDIMM2.188 UC1.AM21
DDR_B_DQS7: JDIMM2.64 UC1.AM18
DDR_B_DQS#0: JDIMM2.135 UC1.AW30
DDR_B_DQS#1: JDIMM2.10 UC1.AV26
DDR_B_DQS#2: JDIMM2.152 UC1.AN28
DDR_B_DQS#3: JDIMM2.27 UC1.AN25
DDR_B_DQS#4: JDIMM2.169 UC1.AW22
DDR_B_DQS#5: JDIMM2.45 UC1.AV18
DDR_B_DQS#6: JDIMM2.186 UC1.AN21
DDR_B_DQS#7: JDIMM2.62 UC1.AN18
DDR_B_MA0: JDIMM2.98 UC1.AP40
DDR_B_MA1: JDIMM2.97 UC1.AR40
DDR_B_MA2: JDIMM2.96 UC1.AP42
DDR_B_MA3: JDIMM2.95 UC1.AR42
DDR_B_MA4: JDIMM2.92 UC1.AR45
DDR_B_MA5: JDIMM2.91 UC1.AP45
DDR_B_MA6: JDIMM2.90 UC1.AW46
DDR_B_MA7: JDIMM2.86 UC1.AY46
DDR_B_MA8: JDIMM2.89 UC1.AY47
DDR_B_MA9: JDIMM2.85 UC1.AU46
DDR_B_MA10: JDIMM2.107 UC1.AK36
DDR_B_MA11: JDIMM2.84 UC1.AV47
DDR_B_MA12: JDIMM2.83 UC1.AU47
DDR_B_MA13: JDIMM2.119 UC1.AK33
DDR_B_MA14: JDIMM2.80 UC1.AR46
DDR_B_MA15: JDIMM2.78 UC1.AP46
DDR_B_RAS#: JDIMM2.110 UC1.AM35
DDR_B_WE#: JDIMM2.113 UC1.AK35
DDR_CKE0_DIMMA: JDIMM1.73 UC1.AU43
DDR_CKE1_DIMMA: JDIMM1.74 UC1.AW43
DDR_CKE2_DIMMB: JDIMM2.73 UC1.AY49
DDR_CKE3_DIMMB: JDIMM2.74 UC1.AU50
DDR_CS0_DIMMA#: JDIMM1.114 UC1.AP33
DDR_CS1_DIMMA#: JDIMM1.121 UC1.AR32
DDR_CS2_DIMMB#: JDIMM2.114 UC1.AM32
DDR_CS3_DIMMB#: JDIMM2.121 UC1.AK32
DDR_HVREF_RST_GATE: R353.2 U38.A34
DDR_PG_CTRL: U5.2 UC1.AV61
DDR_XDP_SMBCLK_R1: JXDP1.53 RC112.2
DDR_XDP_SMBDAT_R1: JXDP1.51 RC111.2
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 QC1.1 R123.2 R218.2 RC112.1
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 QC1.4 R122.2 R219.2 RC111.1
DEVICE_DET#: R365.2 U38.B1
DGPU_PWROK: RP4.8 UC1.P4
DGPU_SELECT#: T121.1(TP-1) U37.B14
DH_1.35V: PQ200.4 PU11.17
DIS_BAT_PROCHOT#: PR812.1 U37.B51
DISP_ON: D21.1 JEDP1.21 R96.1
DK_AC_OFF: PD815.3 PU800.25
DK_AC_OFF_EN: PR857.1 PU800.22
DK_CSS_GC: PR709.2 PU800.11
DK_PWRBAR: PR832.2 PU800.33
DL_1.35V: PQ201.4 PU11.15
DMIC0: CE2.1 JEDP1.36 U17.4
DMIC_CLK: C130.1 CE1.1 JEDP1.34 R170.2
DMIC_CLK_L: R170.1 U17.2
DOCK_AC_OFF: JDOCK1.2 PD815.1 PR844.1
DOCK_AC_OFF_EC: PR857.2 PR858.1 U37.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ703.6
DOCK_DCIN_IS-: JDOCK1.136 PQ703.4
DOCK_DET#: D19.2 PQ817.2 PR852.1 PR853.1 PR856.1 PU808.2 R272.1 U37.B41
DOCK_DET_R#: D19.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: Q21.2 R158.2 U37.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U23.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U23.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U23.20
DOCK_LOM_TRD0+: JDOCK1.104 U23.36
DOCK_LOM_TRD0-: JDOCK1.106 U23.35
DOCK_LOM_TRD1+: JDOCK1.110 U23.32
DOCK_LOM_TRD1-: JDOCK1.112 U23.31
DOCK_LOM_TRD2+: JDOCK1.122 U23.27
DOCK_LOM_TRD2-: JDOCK1.124 U23.26
DOCK_LOM_TRD3+: JDOCK1.128 U23.23
DOCK_LOM_TRD3-: JDOCK1.130 U23.22
DOCK_MIC_DET: Q21.5 R159.2 U37.B8
DOCK_POR_RST#: C357.1 JDOCK1.140 R369.2 U38.A21
DOCK_PSID: JDOCK1.135 PU111.1
DOCK_PWR_BTN#: C342.1 JDOCK1.139 R330.2
DOCK_PWR_SW#: C344.1 R328.2 R330.1 U38.A63
DOCK_SMB_ALERT#: JDOCK1.133 PD819.2 PQ1.3 R292.2 U37.A51
DOCK_SMB_CLK: JDOCK1.127 R361.2 U38.B4
DOCK_SMB_DAT: JDOCK1.129 R359.2 U38.A3
DOCK_USB3RN3: JDOCK1.84 U33.22
DOCK_USB3RP3: JDOCK1.86 U33.23
DOCK_USB3TN3: JDOCK1.90 U33.24
DOCK_USB3TP3: JDOCK1.92 U33.25
DOCK_USBP0+: L43.1 R269.1 U36.3
DOCK_USBP0-: L43.4 R270.1 U36.4
DOCK_USBP0_D+: JDOCK1.66 L43.2 R269.2
DOCK_USBP0_D-: JDOCK1.68 L43.3 R270.2
DOCK_USBP5+: JDOCK1.72 U33.15
DOCK_USBP5-: JDOCK1.74 U33.14
DOCKED: U19.2 U19.5 U23.13 U31.3 U31.5 U33.10 U33.32 U37.A38
DOCKED_LIO_EN: U36.9 U37.B52
DP12412_AUX: C19.1 U19.20
DP12412_AUX#: C20.1 U19.19
DP12412_AUX#_C: C20.2 U6.H2
DP12412_AUX_C: C19.2 U6.H1
DP12412_HPD: U6.J1 U19.15
DP12412_N0: C156.1 U19.33
DP12412_N0_C: C156.2 U6.G2
DP12412_N1: C158.1 U19.31
DP12412_N1_C: C158.2 U6.F2
DP12412_N2: C160.1 U19.29
DP12412_N2_C: C160.2 U6.E2
DP12412_N3: C162.1 U19.27
DP12412_N3_C: C162.2 U6.D2
DP12412_P0: C155.1 U19.32
DP12412_P0_C: C155.2 U6.G1
DP12412_P1: C157.1 U19.30
DP12412_P1_C: C157.2 U6.F1
DP12412_P2: C159.1 U19.28
DP12412_P2_C: C159.2 U6.E1
DP12412_P3: C161.1 U19.26
DP12412_P3_C: C161.2 U6.D1
DP_HDMI_HPD: T115.1(TP-1) U37.B4
DPB_CA_DET: JDOCK1.6 Q10.2 R120.2 U6.M14 U11.1 U11.4
DPB_CA_DET#: Q10.1 R60.2 U11.10 U11.13
DPB_DOCK_AUX: JDOCK1.34 U11.3 U11.11
DPB_DOCK_AUX#: JDOCK1.36 U11.6 U11.8
DPB_DOCK_HPD: C311.1 JDOCK1.40 R271.1 U6.K14
DPB_DOCK_LANE_N0: JDOCK1.12 R261.1
DPB_DOCK_LANE_N1: JDOCK1.18 R256.1
DPB_DOCK_LANE_N2: JDOCK1.24 R264.1
DPB_DOCK_LANE_N3: JDOCK1.30 R267.1
DPB_DOCK_LANE_P0: JDOCK1.10 R260.1
DPB_DOCK_LANE_P1: JDOCK1.16 R254.1
DPB_DOCK_LANE_P2: JDOCK1.22 R262.1
DPB_DOCK_LANE_P3: JDOCK1.28 R258.1
DPB_HPD: Q121.3 R475.1 UC1.C8
DPB_LANE_N0: C296.1 U6.E14
DPB_LANE_N0_C: C296.2 R261.2
DPB_LANE_N1: C303.1 U6.F14
DPB_LANE_N1_C: C303.2 R256.2
DPB_LANE_N2: C307.1 U6.G14
DPB_LANE_N2_C: C307.2 R264.2
DPB_LANE_N3: C309.1 U6.H14
DPB_LANE_N3_C: C309.2 R267.2
DPB_LANE_P0: C294.1 U6.E13
DPB_LANE_P0_C: C294.2 R260.2
DPB_LANE_P1: C298.1 U6.F13
DPB_LANE_P1_C: C298.2 R254.2
DPB_LANE_P2: C305.1 U6.G13
DPB_LANE_P2_C: C305.2 R262.2
DPB_LANE_P3: C308.1 U6.H13
DPB_LANE_P3_C: C308.2 R258.2
DPB_MB_P14: JMDP1.6 R168.2
DPC_CA_DET: JDOCK1.5 Q6.2 R121.2 U6.A14 U13.1 U13.4
DPC_CA_DET#: Q6.1 R56.2 U13.10 U13.13
DPC_DOCK_AUX: JDOCK1.33 U13.3 U13.11
DPC_DOCK_AUX#: JDOCK1.35 U13.6 U13.8
DPC_DOCK_HPD: C310.1 JDOCK1.39 R268.1 U6.A6
DPC_DOCK_LANE_N0: JDOCK1.11 R252.2
DPC_DOCK_LANE_N1: JDOCK1.17 R255.2
DPC_DOCK_LANE_N2: JDOCK1.23 R263.2
DPC_DOCK_LANE_N3: JDOCK1.29 R266.2
DPC_DOCK_LANE_P0: JDOCK1.9 R259.2
DPC_DOCK_LANE_P1: JDOCK1.15 R253.2
DPC_DOCK_LANE_P2: JDOCK1.21 R257.2
DPC_DOCK_LANE_P3: JDOCK1.27 R265.2
DPC_HPD: C451.1 RC151.2 U19.18 UC1.A8
DPC_LANE_N0: C295.2 U6.A7
DPC_LANE_N0_C: C295.1 R252.1
DPC_LANE_N1: C299.2 U6.A8
DPC_LANE_N1_C: C299.1 R255.1
DPC_LANE_N2: C306.2 U6.A9
DPC_LANE_N2_C: C306.1 R263.1
DPC_LANE_N3: C301.2 U6.A10
DPC_LANE_N3_C: C301.1 R266.1
DPC_LANE_P0: C302.2 U6.B7
DPC_LANE_P0_C: C302.1 R259.1
DPC_LANE_P1: C297.2 U6.B8
DPC_LANE_P1_C: C297.1 R253.1
DPC_LANE_P2: C304.2 U6.B9
DPC_LANE_P2_C: C304.1 R257.1
DPC_LANE_P3: C300.2 U6.B10
DPC_LANE_P3_C: C300.1 R265.1
DSCHRG_MOSFET_GC: PR841.2 PU800.29
DSWODVREN: RC73.1 RC78.2 UC1.AW7
DYN_TUR_CURRNT_SET#: PQ712.2 R363.2 U38.A35
EC5048_TX: JDEG1.2 JMINI1.17 R397.2 U37.B2
EC_32KHZ_ECE5048: R379.1 U37.B35
EC_WAKE#: RC206.1 RC301.2 U38.B23 UC1.AN5
EDID_SELECT#: T118.1(TP-1) U37.B61
EDP_BIA_PWM: D10.3 UC1.B8
EDP_COMP: RC134.2 UC1.D20
EDP_CPU_AUX: C55.1 UC1.B45
EDP_CPU_AUX#: C54.1 UC1.A45
EDP_CPU_AUX#_C: C54.2 JEDP1.9
EDP_CPU_AUX_C: C55.2 JEDP1.8
EDP_CPU_HPD: CC450.1 JEDP1.16 RC158.1 UC1.D6
EDP_CPU_LANE_N0: C56.1 UC1.C45
EDP_CPU_LANE_N0_C: C56.2 JEDP1.6
EDP_CPU_LANE_N1: C57.1 UC1.A47
EDP_CPU_LANE_N1_C: C57.2 JEDP1.4
EDP_CPU_LANE_P0: C59.1 UC1.B46
EDP_CPU_LANE_P0_C: C59.2 JEDP1.7
EDP_CPU_LANE_P1: C60.1 UC1.B47
EDP_CPU_LANE_P1_C: C60.2 JEDP1.5
EN: PC119.1 PR113.1 PU100.6 PU100.20
EN_+V1.05SP: PC308.1 PR303.2 PR304.2 PU300.3
EN_DK_PWRBAR: PQ827.1 PR866.2 PR874.1 PU800.17
EN_DOCK_PWR_BAR: PR866.1 U37.B37
EN_I2S_NB_CODEC#: U17.48 U37.B36
EN_INVPWR: Q4.2 R371.2 U38.A25
EN_LCDPWR: D2.1 R104.2 U9.3
ENVDD_PCH: D2.3 RC152.2 U37.B38 UC1.C6
ERC1: PC815.1 PU800.3
ERC2: PC817.1 PU800.13
ERC3: PC816.1 PU800.12
ESATA_USB_PWR_EN#: R295.2 U32.4 U37.B44
F-IMAX: PR503.1 PR508.2 PU500.10
FAN1_PWM: JFAN1.3 R408.2 U38.A24
FAN1_TACH: JFAN1.2 R376.2 U38.B22
FB_+V1.05SP: PR307.2 PR308.2 PU300.4
FP_POA_EN: T100.1(TP-1) U37.A44
FWP#: R393.2 R399.2 U38.B65
GFB: PR532.1 PU500.23
GPIO_PSID_SELECT: PU111.6 U37.A6
GPU_SMBCLK: RP3.6 U38.B49
GPU_SMBDAT: RP3.7 U38.B48
GREEN_DOCK: JDOCK1.59 R75.2 R312.1
H_CATERR#: RC113.2 UC1.K61
H_CPU_SVIDALRT#: RC248.1 UC1.L62
H_CPUPWRGD: CC90.1 RC106.1 RC115.1 UC1.C61
H_PROCHOT#: CC149.1 PC514.2 PQ805.3 PR534.2 PR728.2 Q9.1 R334.2 RC114.2 RC117.1
H_PROCHOT#_R: RC117.2 UC1.K63
H_THERMTRIP#: CC91.1 Q12.3 R24.2 RC172.1
H_THERMTRIP#_R: RC172.2 UC1.D60
H_VCCST_PWRGD: CC22.1 RC105.1 RC243.1 RC245.1 UC4.4
H_VCCST_PWRGD_XDP: JXDP1.39 RC105.2 RC106.2
H_VR_EN: PR536.1 RC246.1 RC256.2
H_VR_READY: PR539.1 RC247.1 RC255.2 RC256.1 RC259.2
HDD_DET#: JMINI3.51 RC11.1 UC1.U1
HDD_DEVSLP: JMINI3.44 R155.2 UC1.L2
HDD_FALL_INT: RP6.6 UC1.N2
HDMI_CEC: JHDMI1.13 R473.2
HDMI_HPD_SINK: JHDMI1.19 Q121.1 R474.1
HDMI_OB: Q29.1 R462.2 R463.2 R464.2 R465.2 R466.2 R467.2 R468.2 R469.2
HOST_DEB_TX: JDEG1.3 R400.1
HOST_DEBUG_RX: R401.2 U38.B46
HOST_DEBUG_TX: C241.1 JMINI1.16 R400.2 RP1.5 U38.B44
HSYNC_DOCK: JDOCK1.65 R84.2
HW_GPS_DISABLE2#: JMINI2.51 R282.2 U37.B34
I2C0_SCL: RC208.2 UC1.F3
I2C0_SDA: RC204.2 UC1.F2
I2C1_SCL_TCH_PAD: R449.1 RC176.2 RC203.2 UC1.F1
I2C1_SCL_VMM: RC176.1 U6.A2
I2C1_SDA_TCH_PAD: R450.1 RC174.2 RC201.2 UC1.G4
I2C1_SDA_VMM: RC174.1 U6.A1
I2S_BCLK: R139.2 U17.16
I2S_DI#: R144.2 U17.24
I2S_DO: R142.2 U17.17
I2S_LRCLK: R143.2 U17.18
I2S_MCLK: R137.2 U17.15
IMON: PC500.2 PR501.2 PU500.13
IMVP_PWRGD: PR540.1 U37.A62
IMVP_VR_ON: PR537.1 U37.B66
INT_SPK_L+: C124.1 L22.1 U17.40
INT_SPK_L-: C125.1 L23.1 U17.41
INT_SPK_R+: C126.1 L24.1 U17.44
INT_SPK_R-: C127.1 L25.1 U17.43
INT_SPKR_L+: JSPK1.1 L22.2
INT_SPKR_L-: JSPK1.2 L23.2
INT_SPKR_R+: JSPK1.3 L24.2
INT_SPKR_R-: JSPK1.4 L25.2
INTRUDER#: RC7.2 UC1.AU6
IO_LDOSEL: R212.2 R214.1 U27.18
IO_LOOP: JEDP1.29 R108.1
IRQ_SERIRQ: RC178.2 U25.27 U37.B21 U38.A28 UC1.T4
JTAG_CLK: JDEG1.7 RP1.7 U38.B56
JTAG_RST#: C362.1 JTAG1.1 R380.2 R384.1 U38.A57
JTAG_TDI: JDEG1.9 RP1.8 U38.A51
JTAG_TDO: JDEG1.6 R391.2 U38.B55
JTAG_TMS: JDEG1.8 R385.2 U38.A53
KB_DET#: JKBTP1.16 RP10.5 UC1.AT3
LAN_ACTLED_YEL#: Q32.6 R274.1
LAN_ACTLED_YEL_R#: JLOM1.10 R274.2
LAN_DISABLE#_R: R173.2 R180.2 R182.1 U21.3 U37.B47
LAN_RST#: R331.1 U20.1 UC1.Y1
LAN_SMBCLK: R174.1 RC29.1
LAN_SMBCLK_R: R174.2 U21.28
LAN_SMBDATA: R177.1 RC31.1
LAN_SMBDATA_R: R177.2 U21.31
LAN_TEST_EN: R184.1 U21.30
LAN_TX0+: L27.1 U21.13
LAN_TX0+R: L27.2 U23.2
LAN_TX0-: L28.1 U21.14
LAN_TX0-R: L28.2 U23.3
LAN_TX1+: L29.1 U21.17
LAN_TX1+R: L29.2 U23.6
LAN_TX1-: L30.1 U21.18
LAN_TX1-R: L30.2 U23.7
LAN_TX2+: L31.1 U21.20
LAN_TX2+R: L31.2 U23.9
LAN_TX2-: L32.1 U21.21
LAN_TX2-R: L32.2 U23.10
LAN_TX3+: L33.1 U21.23
LAN_TX3+R: L33.2 U23.11
LAN_TX3-: L34.1 U21.24
LAN_TX3-R: L34.2 U23.12
LAN_WAKE#: R179.1 RC301.1 U38.B27
LAN_WAKE#_R: R176.1 R179.2 U21.2
LANCLK_REQ#: R169.1 RP6.7 UC1.AD1
LANCLK_REQ#_R: R169.2 U21.48
LCD_CBL_DET#: JEDP1.2 RC189.2 UC1.J3
LCD_SMBCLK: R387.2 U38.B5
LCD_SMBDAT: R451.2 U38.A4
LCD_TST: JEDP1.13 R309.2 U37.A36
LCD_VCC_TEST_EN: D2.2 U37.A40
LED_10_GRN#: Q33.6 R275.1
LED_10_GRN_R#: JLOM1.11 R275.2
LED_100_ORG#: Q32.3 R276.1
LED_100_ORG_R#: JLOM1.13 R276.2
LED_SATA_DIAG_OUT#: D24.1 U37.A10
LED_WWAN_OUT#: JMINI2.42 Q30.4 R226.1
LG_3V: PQ102.4 PU100.11
LG_5V: PQ103.4 PU100.15
LG_+V1.05SP: PQ301.4 PU300.6
LID_CL#: JSH1.11 R325.1 U47.2
LID_CL_SIO#: C337.1 R322.2 R325.2 U37.B54
LOM_ACTLED_YEL#: U21.26 U23.15
LOM_SPD10LED_GRN#: U21.25 U23.42 U24.2
LOM_SPD100LED_ORG#: U21.27 U23.16 U24.1
LP_CTL: R207.1 U6.B2
LPC_LAD0: JMINI3.16 U25.26 U37.A27 U38.A30 UC1.AU14
LPC_LAD1: JMINI3.14 U25.23 U37.A26 U38.B32 UC1.AW12
LPC_LAD2: JMINI3.12 U25.20 U37.B26 U38.A31 UC1.AY12
LPC_LAD3: JMINI3.10 U25.17 U37.B25 U38.B33 UC1.AW11
LPC_LDRQ1#: R296.2 U37.A22
LPC_LFRAME#: JMINI3.8 U25.22 U37.A21 U38.B31 UC1.AV12
M_CLK_DDR0: JDIMM1.101 UC1.AV37
M_CLK_DDR1: JDIMM1.102 UC1.AY36
M_CLK_DDR2: JDIMM2.101 UC1.AN38
M_CLK_DDR3: JDIMM2.102 UC1.AL38
M_CLK_DDR#0: JDIMM1.103 UC1.AU37
M_CLK_DDR#1: JDIMM1.104 UC1.AW36
M_CLK_DDR#2: JDIMM2.103 UC1.AM38
M_CLK_DDR#3: JDIMM2.104 UC1.AK38
M_ODT0: JDIMM1.116 R29.2
M_ODT1: JDIMM1.120 R30.2
M_ODT2: JDIMM2.116 R31.2
M_ODT3: JDIMM2.120 R33.2
MASK_BASE_LEDS#: Q23.2 Q23.5 Q24.2 Q25.2 Q28.2 Q32.2 Q32.5 Q33.2 U47.4
MASK_SATA_LED#: Q24.5 U37.B9
MCARD_MISC_PWREN: T97.1(TP-1) U37.B53
MCARD_PCIE_SATA#: RC12.1 U37.B3 UC1.AC1
MCARD_WWAN_PWREN: R50.2 U22.5 U37.B42
MCP_TESTLOW1: RC46.1 UC1.C35
MCP_TESTLOW2: RC47.1 UC1.C34
MCP_TESTLOW3: RC50.1 UC1.AK8
MCP_TESTLOW4: RC52.1 UC1.AL8
MDP_AUX: C174.2 U19.23
MDP_AUX#: C175.2 U19.24
MDP_AUX#_C: JMDP1.18 R163.2 U49.6 U49.8
MDP_AUX_C: JMDP1.16 R165.2 U49.3 U49.11
MDP_CA_DET: JMDP1.4 Q31.2 R167.1 U49.1 U49.4
MDP_CA_DET#: Q31.1 R67.2 U49.10 U49.13
MDP_HPD: JMDP1.2 R164.2 U19.16
MDP_LANE_N0: C163.1 U19.42
MDP_LANE_N0_C: C163.2 JMDP1.5
MDP_LANE_N1: C165.1 U19.40
MDP_LANE_N1_C: C165.2 JMDP1.11
MDP_LANE_N2: C168.1 U19.38
MDP_LANE_N2_C: C168.2 JMDP1.17
MDP_LANE_N3: C172.1 U19.36
MDP_LANE_N3_C: C172.2 JMDP1.12
MDP_LANE_P0: C164.1 U19.41
MDP_LANE_P0_C: C164.2 JMDP1.3
MDP_LANE_P1: C166.1 U19.39
MDP_LANE_P1_C: C166.2 JMDP1.9
MDP_LANE_P2: C170.1 U19.37
MDP_LANE_P2_C: C170.2 JMDP1.15
MDP_LANE_P3: C173.1 U19.35
MDP_LANE_P3_C: C173.2 JMDP1.10
ME_FWP: R326.1 RC9.1 U37.A8
ME_RESET#: RC76.1 RC81.2 UC2.2
ME_SUS_PWR_ACK: RC94.1 RP10.8 U38.A8
ME_SUS_PWR_ACK_R: RC82.1 RC94.2 UC1.AV4
MEC_XTAL1: C364.1 U38.A61 Y4.1
MEC_XTAL2: C365.1 R378.2 Y4.2
MEC_XTAL2_R: R378.1 U38.A62
MEDIACARD_IRQ#: RC205.1 U27.16 UC1.AB6
MEDIACARD_PWREN: RP5.5 U27.14 UC1.AP1
MEDIACARD_RST#: RP7.8 U26.2 UC1.AG6
MEM_SMBCLK: QC1.6 RC28.2 UC1.AP2
MEM_SMBDATA: QC1.3 RC30.2 UC1.AH1
MINI1CLK_REQ#: JMINI2.7 RP4.6 UC1.T2
MINI2CLK_REQ#: JMINI1.7 RP4.7 UC1.N1
MINI_CARD_RST#: JMINI1.22 JMINI2.22 R26.1 R131.2 U30.4
MMICLK_REQ#: RC55.2 U27.17 UC1.U5
MODC_EN: T101.1(TP-1) U37.B7
MODULE_BATT_PRES#: T107.1(TP-1) U37.B15
MODULE_ON: T106.1(TP-1) U37.B32
MPCIE_RST#: RP4.5 U30.2 UC1.V1
MPHYP_PWR_EN: R420.1 RC169.1 RC170.1 UC1.Y2
MPHYP_PWR_EN#: Q124.5 Q124.6 R442.2
MSATA_DEVSLP: JMINI2.44 R160.2 UC1.P2
MSCLK: JDEG1.5 JMINI1.19 RP1.6 U38.B43
MSDATA: JDEG1.4 JMINI1.14 R222.2 R366.2 R398.2 U38.A40
NB_LAN_TX0+: JLOM1.1 T94.19
NB_LAN_TX0-: JLOM1.2 T94.20
NB_LAN_TX1+: JLOM1.3 T94.23
NB_LAN_TX1-: JLOM1.6 T94.24
NB_LAN_TX2+: JLOM1.4 T94.13
NB_LAN_TX2-: JLOM1.5 T94.14
NB_LAN_TX3+: JLOM1.7 T94.17
NB_LAN_TX3-: JLOM1.8 T94.18
NB_PSID: PJPDC1.1 PL3.2
NB_PSID_TS5A63157: PD5.1 PR8.1 PR9.2 PU111.3
NFC_DET#: JNFC1.14 R38.2 UC1.AT5
NFC_IRQ: JNFC1.11 RC210.1 UC1.AN3
NFC_RST: JNFC1.6 U29.4
NFC_SMBCLK: JNFC1.8 RC33.1
NFC_SMBDATA: JNFC1.9 RC35.1
O-USR: PR504.1 PR509.2 PU500.9
OCP-I: PR501.1 PR506.2 PU500.12
P33ALW: PR868.1 PU800.18
P33ALW2: PR862.2 PU800.9
PANEL_BKEN_EC: D21.2 U37.A35
PANEL_BKLEN: D21.3 UC1.A9
PANEL_HDD_LED#: JLED1.4 Q26.3
PBAT_PRES#: PD4.1 PQ812.1 PR2.2 PRP2.3 PU804.1 U37.B40
PBAT_SMBCLK: PRP2.1 R339.2 U38.A56
PBAT_SMBDAT: PRP2.2 R345.2 U38.B59
PBATT+_C: PBATT1.1 PBATT1.2 PC2.1 PC3.1 PL1.1 PL2.1
PCH_ALW_ON: R368.2 R416.1 U38.A23
PCH_AUDIO_EN: RC215.1 UC1.P1
PCH_AZ_BITCLK: RC26.2 UC1.AW8
PCH_AZ_CODEC_BITCLK: CC5.1 R149.1 RC26.1 U17.6
PCH_AZ_CODEC_RST#: R213.2 RC25.1 U17.11
PCH_AZ_CODEC_SDIN0: R136.1 UC1.AY10
PCH_AZ_CODEC_SDOUT: R148.1 RC23.1 U17.5
PCH_AZ_CODEC_SYNC: RC24.1 U17.10
PCH_AZ_RST#: RC25.2 UC1.AU8
PCH_AZ_SDIN0_R: R136.2 U17.8
PCH_AZ_SDOUT: RC3.2 RC9.2 RC23.2 UC1.AU11
PCH_AZ_SYNC: RC24.2 UC1.AV11
PCH_BATLOW#: RP9.6 UC1.AN4
PCH_CL_CLK1: JMINI1.45 UC1.AF2
PCH_CL_DATA1: JMINI1.47 UC1.AD2
PCH_CL_RST1#: R223.1 UC1.AF4
PCH_DPWROK: R319.1 RC79.1 UC1.AV5
PCH_GPIO9: RP9.8 UC1.AM3
PCH_GPIO10: T137.1(TP-1) UC1.AM2
PCH_GPIO14: T138.1(TP-1) UC1.AH4
PCH_GPIO15: RC190.2 UC1.AD6
PCH_GPIO17: T139.1(TP-1) UC1.T3
PCH_GPIO36: RP6.5 UC1.V6
PCH_GPIO44: RC200.1 UC1.AK4
PCH_GPIO46: RP7.7 UC1.AG3
PCH_GPIO48: T140.1(TP-1) UC1.U4
PCH_GPIO49: T141.1(TP-1) UC1.Y3
PCH_GPIO66: RC283.2 RC288.1 UC1.D3
PCH_GPIO73: RC34.2 UC1.AU4
PCH_GPIO83: RC292.1 RP2.7 UC1.R6
PCH_GPIO84: RP8.7 UC1.L6
PCH_GPIO85: RP8.6 UC1.N6
PCH_GPIO87: RC216.1 UC1.R7
PCH_INTVRMEN: RC1.2 RC2.1 UC1.AV7
PCH_JTAG_JTAGX: RC10.1 RC97.2 RC123.2 UC1.AE63
PCH_JTAG_TCK: RC22.1 RC124.2 RC142.1 UC1.AE62
PCH_JTAG_TCK_R: JXDP1.55 RC142.2
PCH_JTAG_TDI: RC17.1 RC96.1 UC1.AD61
PCH_JTAG_TDO: RC18.1 RC95.1 RC104.2 UC1.AE61
PCH_JTAG_TMS: RC20.1 RC101.1 UC1.AD62
PCH_JTAG_TRST#: RC135.2 UC1.AU62
PCH_NFC_RST: U29.2 UC1.AD7
PCH_OPI_COMP: RC168.1 UC1.AW15
PCH_PCIE_IREF: RC163.2 UC1.B27
PCH_PCIE_RCOMP: RC161.2 UC1.A27
PCH_PCIE_WAKE#: RC71.2 U38.A44 UC1.AJ5
PCH_PLTRST#: RC89.2 RC90.2 RC91.2 RC92.2 RC300.2 UC1.AG7 UC3.1 UC3.2
PCH_PLTRST#_EC: JMINI3.17 R131.1 RC109.1 U25.16 U30.1 U37.B22 U38.B30 UC3.4
PCH_PWROK: RC88.2 UC1.AY7
PCH_RSMRST#: R377.2 R414.1 U38.B47 U42.1
PCH_RSMRST#_Q: R413.2 R414.2 RC93.1
PCH_RSMRST#_R: RC79.2 RC93.2 RC136.2 UC1.AW6
PCH_RTCRST#: CC4.2 CMOS1.2 JAPS1.9 RC6.2 UC1.AU7
PCH_RTCX1: RC4.2 RC5.1 UC1.AW5
PCH_RTCX1_R: CC1.2 RC4.1 YC1.1
PCH_RTCX2: CC2.2 RC5.2 UC1.AY5 YC1.2
PCH_SATA_MOD_EN#: T123.1(TP-1) U38.B36
PCH_SMB_ALERT#: RP5.6 UC1.AN2
PCH_SPI_CLK: R7.2 R13.1 R18.1 R20.2 UC1.AA3
PCH_SPI_CS0#: R3.1 R10.1 UC1.Y7
PCH_SPI_CS1#: R14.1 R17.1 UC1.Y4
PCH_SPI_DIN: R4.1 R15.1 R22.1 R41.1 UC1.AA4
PCH_SPI_DO: R9.2 R11.1 R12.1 R21.2 UC1.AA2
PCH_SPI_DO2: R1.2 R6.1 R19.1 R58.2 R59.2 UC1.Y6
PCH_SPI_DO3: R2.2 R5.2 R16.2 R43.2 R48.2 UC1.AF1
PCH_TPM_LPC_EN: R198.1 RC56.2 UC1.Y5
PCI_CLK_LPC: RC58.1 RC61.1 RC63.1 RC65.2
PCI_CLK_LPC_0: CC15.2 RC65.1 UC1.AN15
PCI_CLK_LPC_1: CC14.2 RC64.1 RC66.1 UC1.AP15
PCIE_PRX_GLANTX_N3: C176.2 UC1.G11
PCIE_PRX_GLANTX_N3_C: C176.1 U21.39
PCIE_PRX_GLANTX_P3: C179.2 UC1.F11
PCIE_PRX_GLANTX_P3_C: C179.1 U21.38
PCIE_PRX_MMITX_N5: C238.1 UC1.F10
PCIE_PRX_MMITX_N5_C: C238.2 U27.8
PCIE_PRX_MMITX_P5: C237.1 UC1.E10
PCIE_PRX_MMITX_P5_C: C237.2 U27.7
PCIE_PRX_WLANTX_N4: JMINI1.23 UC1.F13
PCIE_PRX_WLANTX_P4: JMINI1.25 UC1.G13
PCIE_PTX_GLANRX_N3: C181.1 UC1.C29
PCIE_PTX_GLANRX_N3_C: C181.2 U21.42
PCIE_PTX_GLANRX_P3: C178.1 UC1.B30
PCIE_PTX_GLANRX_P3_C: C178.2 U21.41
PCIE_PTX_MMIRX_N5: C236.1 UC1.C23
PCIE_PTX_MMIRX_N5_C: C236.2 U27.5
PCIE_PTX_MMIRX_P5: C235.1 UC1.C22
PCIE_PTX_MMIRX_P5_C: C235.2 U27.6
PCIE_PTX_WLANRX_N4: C242.1 UC1.B29
PCIE_PTX_WLANRX_N4_C: C242.2 JMINI1.31
PCIE_PTX_WLANRX_P4: C243.1 UC1.A29
PCIE_PTX_WLANRX_P4_C: C243.2 JMINI1.33
PCIE_WAKE#: JMINI1.1 JMINI2.1 R340.2 U38.B38
PCIECLK_REQ0#: RC57.2 UC1.U2
PE_REXT: R205.2 U27.4
PE_RST#: R27.1 R443.2 U26.4 U27.15
PECI_EC: R375.2 UC1.N62
PECI_EC_R: R375.1 U38.A48
PGOOD_3V_5V: PR107.1 PR108.2 PU100.7
PIRQ#_TPM: RP2.8 UC1.N4
PLT_LAN_RST#: R25.1 R145.2 U20.4 U21.36
PLTRST_LAN#: R145.1 RC91.1 U20.2
PLTRST_MMI#: R443.1 RC90.1 U26.1
PLTRST_NFC#: RC300.1 U29.1
PLTRST_USH#: JUSH1.15 RC89.1
PLTRST_VMM2320#: RC92.1 U6.A13
PM_APWROK: RC144.1 U38.A9 UC7.2
PM_APWROK_R: RC144.2 UC1.AB5 UC7.4
PM_LANPHY_ENABLE: R180.1 RC197.1 UC1.AM7
POA_WAKE#: R346.2 U38.B68
POWER_SW#_MB: C340.1 JAPS1.11 R329.2 SW1.2 SW1.4
POWER_SW_IN#: C343.1 R327.2 R329.1 U38.B67
PROC_OPI_RCOMP: RC237.1 UC1.AY15
PROCHOT#_EC: Q9.2 R334.1 R335.2 R342.2 U38.A46
PROCHOT_GATE: PU3.2 RP11.8 U37.A50
PS_ID: PU111.4 U38.A55
PS_USBP0_D+: L42.4 R249.1 U39.3
PS_USBP0_D-: L42.1 R251.1 U39.2
PSID_DISABLE#: PR13.2 U37.A37
PWM1: PU500.6 PU501.8
PWR_SRC_ON: C66.2 Q2.3 R97.2 R99.1
PWRSHARE_EN: Q7.2 R241.2 U39.1
PWRSHARE_EN#: Q7.1 R243.1 U35.4
RED_DOCK: JDOCK1.53 R73.2 R311.1
REGCTL_PNP10: L26.1 U21.7
REM_DIODE1_N: C358.1 C370.1 Q11.3 U38.B13
REM_DIODE1_P: C358.2 C370.2 Q11.1 Q11.2 U38.A13
REM_DIODE2_N: C359.1 C372.2 Q13.3 U38.B14
REM_DIODE2_P: C359.2 C372.1 Q13.1 Q13.2 U38.A14
REM_DIODE4_N: C361.1 C373.1 Q14.3 U38.A16
REM_DIODE4_P: C361.2 C373.2 Q14.1 Q14.2 U38.B17
RES_BIAS: R185.1 U21.12
RESET_OUT#: R373.2 RC84.1 RC88.1 RC263.2 U38.B39
RF_+V1.05SP: PR305.1 PU300.5
RING2: R187.1 R491.2 U17.28
RING2_L: C443.1 D32.2 JHP1.3 R491.1
RSMRST#: R440.2 U41.3 U42.2
RSVD_AL1: T56.1(TP-1) UC1.AL1
RSVD_AM11: T57.1(TP-1) UC1.AM11
RSVD_AP7: T59.1(TP-1) UC1.AP7
RSVD_AT2: T50.1(TP-1) UC1.AT2
RSVD_AU10: T61.1(TP-1) UC1.AU10
RSVD_AU15: T63.1(TP-1) UC1.AU15
RSVD_AU44: T52.1(TP-1) UC1.AU44
RSVD_AV44: T54.1(TP-1) UC1.AV44
RSVD_AW14: T64.1(TP-1) UC1.AW14
RSVD_AY14: T65.1(TP-1) UC1.AY14
RSVD_D15: T55.1(TP-1) UC1.D15
RSVD_F22: T58.1(TP-1) UC1.F22
RSVD_H22: T60.1(TP-1) UC1.H22
RSVD_J21: T62.1(TP-1) UC1.J21
RSVD_N23: T48.1(TP-1) UC1.N23
RSVD_R23: T49.1(TP-1) UC1.R23
RSVD_T23: T51.1(TP-1) UC1.T23
RSVD_U10: T53.1(TP-1) UC1.U10
RUN_ON: Q5.2 R154.1 R303.2 R418.1 R426.1 U37.A11
RUN_ON#: Q5.5 Q5.6 R36.2
RUNPWROK: Q5.3 R35.2 U37.A4 U38.B26 UC6.1 UC6.4 UC6.10 UC6.13
S5_1.35V: PC215.1 PR207.2 PR208.2 PU11.8
SATA_ACT#: Q24.4 UC1.U3
SATA_COMP: RC19.1 UC1.C12
SATA_IREF: RC14.2 UC1.A12
SATA_LED: LED6.2 R430.2
SATA_PRX_DKTX_N0: C313.2 JDOCK1.56
SATA_PRX_DKTX_N0_C: C313.1 UC1.J5
SATA_PRX_DKTX_P0: C312.2 JDOCK1.54
SATA_PRX_DKTX_P0_C: C312.1 UC1.H5
SATA_PRX_DTX_N1: C109.1 JMINI3.25
SATA_PRX_DTX_N1_C: C109.2 UC1.J8
SATA_PRX_DTX_P1: C108.1 JMINI3.23
SATA_PRX_DTX_P1_C: C108.2 UC1.H8
SATA_PRX_MSATATX_N3: JMINI2.25 UC1.F5
SATA_PRX_MSATATX_P3: JMINI2.23 UC1.E5
SATA_PTX_DKRX_N0: C315.1 JDOCK1.62
SATA_PTX_DKRX_N0_C: C315.2 UC1.B15
SATA_PTX_DKRX_P0: C314.1 JDOCK1.60
SATA_PTX_DKRX_P0_C: C314.2 UC1.A15
SATA_PTX_DRX_N1: C106.1 JMINI3.31
SATA_PTX_DRX_N1_C: C106.2 UC1.A17
SATA_PTX_DRX_P1: C105.1 JMINI3.33
SATA_PTX_DRX_P1_C: C105.2 UC1.B17
SATA_PTX_MSATARX_N3: C244.1 UC1.C17
SATA_PTX_MSATARX_N3_C: C244.2 JMINI2.31
SATA_PTX_MSATARX_P3: C245.1 UC1.D17
SATA_PTX_MSATARX_P3_C: C245.2 JMINI2.33
SB#: R242.2 U39.8
SD/MMCCD#: C256.1 JSD1.18 R493.1 U27.21
SD/MMCCLK: C255.1 JSD1.5 R230.2
SD/MMCCLK_R: R230.1 U27.43
SD/MMCCMD: JSD1.2 U27.45
SD/MMCDAT0: L46.4 R231.1 U27.30 U27.38
SD/MMCDAT0_D: JSD1.7 L46.3 R231.2
SD/MMCDAT1: L46.1 R297.1 U27.29 U27.37
SD/MMCDAT1_D: JSD1.8 L46.2 R297.2
SD/MMCDAT2: R341.1 U27.48
SD/MMCDAT2_R: JSD1.9 R341.2
SD/MMCDAT3: R410.1 U27.47
SD/MMCDAT3_R: JSD1.1 R410.2
SD_UHS2_D0N: L47.1 R315.1 U27.34
SD_UHS2_D0N_D: JSD1.12 L47.2 R315.2
SD_UHS2_D0P: L47.4 R306.1 U27.35
SD_UHS2_D0P_D: JSD1.11 L47.3 R306.2
SD_UHS2_D1N: L48.4 R337.1 U27.33
SD_UHS2_D1N_D: JSD1.15 L48.3 R337.2
SD_UHS2_D1P: L48.1 R333.1 U27.32
SD_UHS2_D1P_D: JSD1.16 L48.2 R333.2
SDWP: JSD1.19 U27.20
SEL: R244.1 U39.4
SIO_EXT_SCI#: RC199.1 U38.A33 UC1.N5
SIO_EXT_SMI#: RP7.5 U38.A6 UC1.AG5
SIO_EXT_WAKE#: RP10.6 U37.B49 UC1.AU2
SIO_PWRBTN#: RC107.1 U38.B58 UC1.AL7
SIO_RCIN#: RP2.6 U38.A27 UC1.V4
SIO_SLP_A#: JAPS1.6 PR303.1 R423.1 U37.B63 UC1.AL5 UC7.1
SIO_SLP_LAN#: R196.2 U37.A5 UC1.AJ7
SIO_SLP_S0#: JAPS1.15 U38.A36 UC1.AF3
SIO_SLP_S3#: JAPS1.2 PR211.1 R417.1 R425.1 U37.B65 UC1.AT4
SIO_SLP_S4#: JAPS1.5 PR207.1 R421.1 T12.1(TP-1) U37.A61 UC1.AJ6
SIO_SLP_S5#: JAPS1.4 T11.1(TP-1) U38.A18 UC1.AP5
SIO_SLP_SUS#: U37.B6 UC1.AP4
SIO_SLP_WLAN#: U37.A14 UC1.AM5
SKIP#: PR520.2 PU500.7
SKIP#1: PR520.1 PU501.1
SL_BAT_PRES#: PR860.1 PU800.21
SLATE_MODE_R: RP9.7 UC1.AL4
SLEEVE: Q123.3 R197.1 R492.2 U17.29
SLEEVE_L: C440.1 D30.3 JHP1.4 R492.1
SLEWA: PR500.1 PR510.2 PU500.15
SLICE_BAT_ON: PQ806.5 PQ812.5 PR850.2 PU801.2 PU807.1 R307.2 U37.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PD820.1 PQ807.5 PR6.1 PR834.2 PR860.2 PR861.1 PU801.1 PU805.1 PU808.1 R285.2 U37.B33
SLICE_PERF_EN: PQ819.2 PQ824.5 PR848.1 PR851.1 U38.B37
SLP_ME_CSW_DEV#: RC289.2 U37.B58 UC1.E2
SM_RCOMP0: RC125.1 UC1.AU60
SM_RCOMP1: RC129.1 UC1.AV60
SM_RCOMP2: RC133.1 UC1.AU61
SML0CLK: RC29.2 RC33.2 RC38.2 UC1.AN1
SML0DATA: RC31.2 RC35.2 RC39.2 UC1.AK1
SML1_SMBCLK: RC36.1 U38.B6 UC1.AU3
SML1_SMBDATA: RC37.1 U38.A5 UC1.AH3
SNUB_1.35V: PC208.2 PR203.1
SOFT_START_GC: PR17.2 PU800.2
SP_TPM_LPC_EN: R193.1 R304.2 U37.B56
SP_TPM_LPC_EN_R: R193.2 R198.2 U25.28
SPI_CLK32: R20.1 R45.2 U2.6
SPI_CLK64: R7.1 R57.2 U1.6
SPI_DIN32: R15.2 U2.2
SPI_DIN64: R4.2 U1.2
SPI_DO32: R21.1 U2.5
SPI_DO64: R9.1 U1.5
SPI_PCH_CS0#_R: R3.2 U1.1
SPI_PCH_CS1#_R: R14.2 U2.1
SPI_PCH_DO2_32: R19.2 R23.1 U2.3
SPI_PCH_DO2_64: R6.2 R8.1 U1.3
SPI_PCH_DO3_32: R16.1 U2.7
SPI_PCH_DO3_64: R5.1 U1.7
SPI_WP#_SEL: R8.2 R23.2 U37.A12
SPKR: R147.2 RC222.2 UC1.V2
SRCDET: R69.1 U6.C2
SRTCRST#: CC3.2 ME1.2 RC8.2 UC1.AV6
STSTART_DCBLOCK_GC: PR811.1 PU800.16
SUS_ON: PR208.1 R422.1 RP11.5 U37.B60
SUS_STAT#/LPCPD#: RC74.2 UC1.AG4
SUSACK#: RC86.1 RP7.6 U37.A58
SUSACK#_R: RC82.2 RC86.2 UC1.AK2
SUSCLK: T10.1(TP-1) UC1.AE6
SW1: PC110.2 PC114.1 PL102.1 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PU100.18
SW2: PC109.1 PC111.1 PL101.1 PQ100.1 PQ100.2 PQ100.3 PQ102.5 PU100.8
SW_1.35V: PC204.1 PC208.1 PL200.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PU11.16
SW_10_GRN#: Q33.1 U23.41
SW_100_ORG#: Q32.4 U23.18
SW_+V1.05SP: PC304.2 PC306.1 PL300.1 PQ300.1 PQ300.2 PQ300.3 PQ301.5 PU300.8
SW_ACTLED_YEL#: Q32.1 U23.17
SW_DPB_AUX: C94.2 R47.1 U6.J13
SW_DPB_AUX#: C95.2 R44.1 U6.J14
SW_DPB_AUX#_C: C95.1 U11.5
SW_DPB_AUX_C: C94.1 U11.2
SW_DPC_AUX: C98.2 R92.1 U6.B11
SW_DPC_AUX#: C99.2 R91.1 U6.A11
SW_DPC_AUX#_C: C99.1 U13.5
SW_DPC_AUX_C: C98.1 U13.2
SW_LAN_TX0+: T94.6 U23.38
SW_LAN_TX0-: T94.5 U23.37
SW_LAN_TX1+: T94.2 U23.34
SW_LAN_TX1-: T94.1 U23.33
SW_LAN_TX2+: T94.12 U23.29
SW_LAN_TX2-: T94.11 U23.28
SW_LAN_TX3+: T94.8 U23.25
SW_LAN_TX3-: T94.7 U23.24
SW_MDP_AUX#_C: C175.1 U49.5
SW_MDP_AUX_C: C174.1 U49.2
SW_USB3RN3: L37.4 R235.1 U33.26
SW_USB3RP3: L37.1 R236.1 U33.27
SW_USB3TN3: C282.2 U33.30
SW_USB3TN3_C: C282.1 L38.4 R237.1
SW_USB3TP3: C283.2 U33.31
SW_USB3TP3_C: C283.1 L38.1 R239.1
SW_USBP0+: U36.1 U39.6
SW_USBP0-: U36.2 U39.7
SW_USBP5+: L39.1 R238.1 U33.19
SW_USBP5-: L39.4 R240.1 U33.18
SYS_LED_MASK#: Q25.5 R310.2 U37.B48 U47.1
SYS_PWROK: RC87.1 RC110.1 U37.B57
SYS_PWROK_R: RC84.2 RC87.2 UC1.AG2
SYS_PWROK_XDP: CC48.1 JXDP1.47 RC102.1 RC110.2
SYS_RESET#: JAPS1.13 RC72.2 UC1.AC3 UC2.4
SYSTEM_ID: C369.1 R386.2 U38.A10
TAA_CLK32: JTAA1.9 R18.2
TAA_CLK64: JTAA1.7 R13.2
TAA_CS0#_R: JTAA1.11 R10.2
TAA_CS1#_R: JTAA1.13 R17.2
TAA_DIN32: JTAA1.19 R41.2
TAA_DIN64: JTAA1.17 R22.2
TAA_DO2_32: JTAA1.14 R59.1
TAA_DO2_64: JTAA1.12 R58.1
TAA_DO3_32: JTAA1.10 R48.1
TAA_DO3_64: JTAA1.8 R43.1
TAA_DO32: JTAA1.3 R12.2
TAA_DO64: JTAA1.1 R11.2
TDI_IREF: RC236.2 UC1.B12
TDI_XDP: JXDP1.56 RC96.2 RC103.1
TDI_XDP_R: RC103.2 RC104.1 UC6.5
TDO_XDP: JXDP1.52 RC95.2 RC123.1 RC280.2 UC6.2
THERMATRIP2#: C371.1 Q12.1 R402.2 U38.B34
THERMATRIP3#: R364.2 U38.A2
THSEL_STRAP: R383.1 U38.B29
TMDS_CLK#_C: C191.1 L10.4 L11.1 R466.1
TMDS_CLK_C: C103.1 L9.1 L10.1 R464.1
TMDS_N0_C: C209.1 L13.4 L14.1 R463.1
TMDS_N1_C: C270.1 L16.4 L17.1 R469.1
TMDS_N2_C: C272.1 L19.4 L20.1 R468.1
TMDS_P0_C: C199.1 L12.1 L13.1 R462.1
TMDS_P1_C: C269.1 L15.1 L16.1 R467.1
TMDS_P2_C: C271.1 L18.1 L19.1 R465.1
TMDSB_CON_CLK: C273.1 JHDMI1.10 L9.2 L10.2
TMDSB_CON_CLK#: C274.1 JHDMI1.12 L10.3 L11.2
TMDSB_CON_N0: C276.1 JHDMI1.9 L13.3 L14.2
TMDSB_CON_N1: C278.1 JHDMI1.6 L16.3 L17.2
TMDSB_CON_N2: C382.1 JHDMI1.3 L19.3 L20.2
TMDSB_CON_P0: C275.1 JHDMI1.7 L12.2 L13.2
TMDSB_CON_P1: C277.1 JHDMI1.4 L15.2 L16.2
TMDSB_CON_P2: C279.1 JHDMI1.1 L18.2 L19.2
TMS_XDP: JXDP1.58 RC101.2 UC6.9
TOUCH_PANEL_INTR#: JLED1.6 RC180.1 RC181.2 UC1.P3
TOUCH_RST_N_GYRO_INT1: RC202.2 UC1.L1
TOUCH_SCREEN_PD#: T98.1(TP-1) U37.B55
TOUCHPAD_INTR#: RC140.2 UC1.U7
TP_CLK: C378.1 C380.1 JKBTP1.3 R405.2 R444.2 R449.2
TP_DATA: C377.1 C379.1 JKBTP1.4 R404.2 R441.2 R450.2
TP_DC_TEST_B2: RC254.2 UC1.B2
TP_LAN_JTAG_TCK: R172.2 U21.35
TP_LAN_JTAG_TDI: T92.1(TP-1) U21.32
TP_LAN_JTAG_TDO: T93.1(TP-1) U21.34
TP_LAN_JTAG_TMS: R171.2 U21.33
TP_NFC_RSVD1: JNFC1.13 T89.1(TP-1)
TP_NFC_RSVD3: JNFC1.10 R37.2
TP_NFC_RSVD4: JNFC1.5 T88.1(TP-1)
TP_NFC_SWP_PWR_RSVD: JNFC1.4 T87.1(TP-1)
TPM_ID0: RC284.2 UC1.E4
TPM_ID1: RC285.2 UC1.C3
TRIP_+V1.05SP: PR302.2 PU300.2
TRST#_XDP: JXDP1.54 UC6.12
UG_3V: PQ100.4 PU100.10
UG_5V: PQ101.4 PU100.16
UG_+V1.05SP: PQ300.4 PU300.9
UIM_CLK: JMINI2.12 JSH1.4
UIM_DATA: JMINI2.10 JSH1.8
UIM_RESET: JMINI2.14 JSH1.6
UIM_VPP: JMINI2.16 JSH1.7
USB3RN1: L55.4 R484.1 UC1.G20
USB3RN1_D-: D34.1 D34.9 JUSB3.5 L55.3 R484.2
USB3RN2: L40.4 R246.1 UC1.E18
USB3RN2_D-: D17.1 D17.9 JUSB1.5 L40.3 R246.2
USB3RN3: U33.5 UC1.G17
USB3RN3_D-: D15.1 D15.9 JUSB2.5 L37.3 R235.2
USB3RP1: L55.1 R485.1 UC1.H20
USB3RP1_D+: D34.2 D34.8 JUSB3.6 L55.2 R485.2
USB3RP2: L40.1 R247.1 UC1.F18
USB3RP2_D+: D17.2 D17.8 JUSB1.6 L40.2 R247.2
USB3RP3: U33.4 UC1.F17
USB3RP3_D+: D15.2 D15.8 JUSB2.6 L37.2 R236.2
USB3TN1: C448.2 UC1.C33
USB3TN1_D-: D34.4 D34.7 JUSB3.8 L56.3 R486.2
USB3TN1_RP_C: C448.1 L56.4 R486.1
USB3TN2: C292.2 UC1.B33
USB3TN2_C: C292.1 L41.4 R248.1
USB3TN2_D-: D17.4 D17.7 JUSB1.8 L41.3 R248.2
USB3TN3: U33.2 UC1.C30
USB3TN3_D-: D15.4 D15.7 JUSB2.8 L38.3 R237.2
USB3TP1: C449.2 UC1.B34
USB3TP1_D+: D34.5 D34.6 JUSB3.9 L56.2 R487.2
USB3TP1_RP_C: C449.1 L56.1 R487.1
USB3TP2: C293.2 UC1.A33
USB3TP2_C: C293.1 L41.1 R250.1
USB3TP2_D+: D17.5 D17.6 JUSB1.9 L41.2 R250.2
USB3TP3: U33.1 UC1.C31
USB3TP3_D+: D15.5 D15.6 JUSB2.9 L38.2 R239.2
USB_OC0#: RP5.7 U35.5 UC1.AL3
USB_OC1#: RC166.1 U52.5 UC1.AT1
USB_OC2#: RP5.8 U32.5 UC1.AH2
USB_OC3#: RP10.7 UC1.AV3
USB_PWR_SHR_EN#: R242.1 R287.2 U37.B10
USB_PWR_SHR_VBUS_EN: R241.1 R291.2 U37.B50
USB_SIDE_EN#: R288.2 U37.A33 U52.4
USBP0+: U36.8 UC1.AM8
USBP0-: U36.7 UC1.AN8
USBP0_D+: D18.2 JUSB1.3 L42.3 R249.2
USBP0_D-: D18.3 JUSB1.2 L42.2 R251.2
USBP1+: L54.1 R482.1 UC1.AT7
USBP1-: L54.4 R483.1 UC1.AR7
USBP1_R_D+: D33.3 JUSB3.3 L54.2 R482.2
USBP1_R_D-: D33.2 JUSB3.2 L54.3 R483.2
USBP2+: JMINI1.38 UC1.AP8
USBP2-: JMINI1.36 UC1.AR8
USBP3+: L8.1 R100.1 UC1.AT10
USBP3-: L8.4 R101.1 UC1.AR10
USBP3_D+: JEDP1.31 L8.2 R100.2
USBP3_D-: JEDP1.32 L8.3 R101.2
USBP4+: JUSH1.3 UC1.AL15
USBP4-: JUSH1.2 UC1.AM15
USBP5+: U33.6 UC1.AN13
USBP5-: U33.7 UC1.AM13
USBP5_D+: D16.3 JUSB2.3 L39.2 R238.2
USBP5_D-: D16.2 JUSB2.2 L39.3 R240.2
USBP6+: JMINI2.38 UC1.AN11
USBP6-: JMINI2.36 UC1.AP11
USBP7+: D8.3 JEDP1.38 UC1.AP13
USBP7-: D8.2 JEDP1.39 UC1.AR13
USBRBIAS: RC159.1 UC1.AJ10 UC1.AJ11
USH_DET#: JUSH1.20 RC282.2 UC1.E3
USH_PWR_ON: R439.1 U37.A18
USH_PWR_STATE#: JUSH1.16 R195.2 U37.A34
USH_SMBCLK: JUSH1.5 R190.2 U38.A50
USH_SMBDAT: JUSH1.6 R191.2 U38.B53
V_SYS: PC719.2 PU700.7 R381.2
VCI_IN2#: R347.2 U38.B63
VCP: PR710.1 PR732.1 U38.A12
VCT_LAN_R1: R175.2 U21.6
VFB: PR531.1 PU500.24
VGA_ID: R317.1 R320.2 U37.B59
VIDALERT_N: PR528.2 PU500.32 RC244.2 RC248.2
VIDSCLK: PR527.2 PU500.31 UC1.N63
VIDSOUT: PR529.2 PU500.1 RC249.2 UC1.L63
VMM2310_AUXN: R85.1 U6.M5
VMM2310_AUXP: T40.1(TP-1) U6.L5
VMM2310_HDP: R74.2 U6.M3
VMM2310_SCL: R77.1 U6.L4
VMM2310_SDA: R81.1 U6.M4
VMM2310_TX2N0: R84.1 U6.M9
VMM2310_TX2N1: R76.1 U6.M8
VMM2310_TX2N2: R75.1 U6.M7
VMM2310_TX2N3: R73.1 U6.M6
VMM2310_TX2P0: R88.1 U6.L9
VMM_DPB_CTRLCLK: R70.1 U6.K13 U11.12
VMM_DPB_CTRLDAT: R72.1 U6.L14 U11.9
VMM_DPC_CTRLCLK: R49.1 U6.B12 U13.12
VMM_DPC_CTRLDAT: R46.1 U6.A12 U13.9
VMM_GPIO6: R52.1 U6.C1
VMM_GPIO7: R53.1 U6.M12
VMM_GPIO8: R54.1 U6.M13
VMM_GPIO9: R63.1 U6.L3
VMM_MESCL: R40.1 U6.B5
VMM_MESDA: R42.1 U6.B6
VMM_SPI_CLK: U6.B3 U7.6
VMM_SPI_CS#: R64.2 U6.A4 U7.1
VMM_SPI_DIN: U6.B4 U7.2
VMM_SPI_DO: U6.A3 U7.5
VMM_SPI_HOLD: R65.2 U7.7
VMM_SPI_WP#: U6.B1 U7.3
VOL_DOWN: JMEDIA.4 R349.2 R360.2
VOL_DOWN_R: C456.2 R349.1 U38.B57
VOL_MUTE: JMEDIA.3 R352.2 R358.2
VOL_MUTE_R: C457.2 R352.1 U38.B2
VOL_UP: JMEDIA.5 R338.2 R362.2
VOL_UP_R: C455.2 R338.1 U38.B8
VR_EN: RC246.2 UC1.F60
VR_HOT#: PR534.1 PU500.30
VR_READY: RC247.2 UC1.C59
VREF: PC507.2 PH500.1 PR500.2 PR502.2 PR503.2 PR504.2 PR521.2 PU500.27
VSET_5075: C367.1 R394.1 U38.A17
VSYNC_DOCK: JDOCK1.67 R88.2
WIGIG60GHZ_DIS#: D13.1 R224.1 R289.2 U37.A1
WIGIG60GHZ_DIS#_R: D13.2 JMINI1.32 R224.2
WIMAX_LED#: JMINI1.42 Q22.4 R222.1 R228.1
WIRELESS_LED#: Q22.3 Q22.6 Q25.1 Q30.3 Q30.6 R432.2 U37.A47
WIRELESS_ON#/OFF: JSF1.3 R293.2 U37.B13
WLAN_LAN_DISB#: U24.4 U37.A64
WLAN_LED: LED5.2 R435.2
WLAN_LED#: JMINI1.44 Q22.1 R227.1
WLAN_RADIO_DIS#: D12.1 R215.1 U37.A48
WLAN_RADIO_DIS#_R: D12.2 JMINI1.20 R215.2
WWAN_RADIO_DIS#: JMINI2.20 RP11.6 U37.A53
WWAN_SMBCLK: JMINI2.30 R216.2 R218.1
WWAN_SMBDAT: JMINI2.32 R217.2 R219.1
XDP_DBRESET#: CC68.1 JXDP1.48 RC72.1 RC116.2 UC2.1
XDP_OBS0_R: JXDP1.21 UC1.J60
XDP_OBS1_R: JXDP1.23 UC1.H60
XDP_OBS2_R: T122.1(TP-1) UC1.H61
XDP_OBS3_R: T126.1(TP-1) UC1.H62
XDP_OBS4_R: T129.1(TP-1) UC1.K59
XDP_OBS5_R: T130.1(TP-1) UC1.H63
XDP_OBS6_R: T131.1(TP-1) UC1.K60
XDP_OBS7_R: T132.1(TP-1) UC1.J61
XDP_RST#_R: JXDP1.46 RC109.2
XFR_ID_BIT#: RP11.7 U37.B45
XTAL24_IN: RC40.1 RC44.2 UC1.A25
XTAL24_IN_R: CC7.2 RC40.2 YC2.3
XTAL24_OUT: CC6.2 RC44.1 UC1.B25 YC2.1
XTALI: C190.2 R206.2 U21.10 Y3.1
XTALO: R183.2 R206.1 U21.9
XTALO_R: C189.2 R183.1 Y3.3
Z2805: R280.1 T94.22
Z2806: R278.1 T94.16
Z2807: R279.1 T94.21
Z2808: R277.1 T94.15
Z4012: PD3.2 PR1.2
Z4304: PBATT1.3 PD1.2 PRP2.8
Z4305: PBATT1.4 PD1.3 PRP2.7
Z4306: PBATT1.5 PD2.2 PRP2.6
N18526: T3.1(TP-1) UC1.AL11
N19012: T4.1(TP-1) UC1.AC4
N19898: T5.1(TP-1) UC1.AV2
N33176: T2.1(TP-1) UC1.K10
N77714: T6.1(TP-1) UC1.K21
N77941: T7.1(TP-1) UC1.M21
N434133: T16.1(TP-1) UC1.E15
N434770: T17.1(TP-1) UC1.E13
N453960: T14.1(TP-1) UC1.AN10
N453980: T15.1(TP-1) UC1.AM10
N517848: T13.1(TP-1) UC1.AD4
N592736: T18.1(TP-1) UC1.AF20
N595754: T19.1(TP-1) UC1.AB21
N659696: T20.1(TP-1) UC1.AV63
N659720: T21.1(TP-1) UC1.AU63
N659740: T34.1(TP-1) UC1.P20
N659776: T36.1(TP-1) UC1.R20
N659780: T33.1(TP-1) UC1.A5
N659800: T22.1(TP-1) UC1.C63
N659846: T35.1(TP-1) UC1.E1
N659886: T23.1(TP-1) UC1.C62
N659906: T37.1(TP-1) UC1.D1
N659936: T24.1(TP-1) UC1.B43
N659940: T38.1(TP-1) UC1.J20
N659960: T25.1(TP-1) UC1.A51
N659980: T26.1(TP-1) UC1.B51
N660016: T39.1(TP-1) UC1.H18
N660346: T27.1(TP-1) UC1.L60
N660398: T28.1(TP-1) UC1.N60
N660504: T29.1(TP-1) UC1.W23
N660524: T30.1(TP-1) UC1.Y22
N660552: T31.1(TP-1) UC1.AV62
N660594: T32.1(TP-1) UC1.D58
N758470: T66.1(TP-1) UC1.L59
N759266: T67.1(TP-1) UC1.J58
N770443: T68.1(TP-1) UC1.N58
N770463: T69.1(TP-1) UC1.AC58
N778869: T70.1(TP-1) UC1.AB23
N784899: T71.1(TP-1) UC1.AD23
N785755: T72.1(TP-1) UC1.AA23
N786613: T73.1(TP-1) UC1.AE59
N843309: T74.1(TP-1) UC1.P60
N846514: T75.1(TP-1) UC1.P61
N847540: T76.1(TP-1) UC1.N59
N848568: T77.1(TP-1) UC1.N61
N849646: T78.1(TP-1) UC1.T59
N849666: T79.1(TP-1) UC1.AD60
N849686: T80.1(TP-1) UC1.AD59
N849706: T81.1(TP-1) UC1.AA59
N850792: T82.1(TP-1) UC1.AE60
N850812: T83.1(TP-1) UC1.AC59
N850832: T84.1(TP-1) UC1.AG58
N850852: T85.1(TP-1) UC1.U59
N851898: T86.1(TP-1) UC1.V59
N13302954: PC809.2 PD813.1 PD816.1 PD821.1 PQ815.4 PQ826.4 PR818.1 PR822.1
N13303110: PD821.2 PQ830.1
N13303122: PQ830.2 PR836.1 PR837.2
N13303138: PQ831.1 PR837.1
N13303142: PQ831.2 PU808.4
N13388109: PD820.2 PQ832.2 PR828.2
N13388133: PQ829.2 PQ832.1 PR830.2
N13388149: PD815.2 PQ829.1
N13388161: PQ829.3 PR830.1 PR894.2 PR895.2
N13389204: PC740.1 PQ710.2 PR727.1 PR729.2 PU2.1
N13401571: PBATT1.7 PD2.3
N16958676: R417.2 R418.2 U43.5
N16958821: C391.1 U43.10
N16994246: PC713.1 PD702.1 PR715.2
N17012912: PQ710.3 PQ710.6 PR728.1
N17149547: PR711.2 PR726.2 PR750.2 PR751.2 PU700.10
N17156946: PC5.1 PQ4.4 PQ6.4 PR14.2 PR17.1 PR18.1
N17156948: PQ6.1 PQ6.2
N17205976: JDEG1.10 R388.2
N17219423: PD701.1 PR708.2 PR745.1
N17219466: PR210.2 PR211.2 PU11.7
N17318583: PD807.1 PQ801.3 PR802.2
N17321675: PQ806.3 PR810.2 PR812.2 PU804.2
N17321677: PD818.1 PQ802.6 PQ805.2 PQ806.6 PR801.2
N17404646: C339.1 R324.2
N17639884: PC505.2 PR519.2 PU500.2
N17640254: PC506.1 PR523.1 PR535.1 PU500.25
N17640267: PC512.1 PR535.2
N17640270: PC506.2 PC512.2 PR521.1 PR523.2 PU500.26
N17645088: PL500.3 PR512.2
N17663289: PC713.2 PC714.1 PL701.2 PQ704.1 PQ704.2 PQ704.3 PQ706.5 PU700.19
N17680637: PR536.2 PR537.2 PU500.8
N17680665: PR516.1 PR539.2 PR540.2 PU500.3
N17683399: PR725.2 PU700.3
N17812022: Q20.3 R152.2
N18063845: R413.1 U42.4
N18435663: RC263.1 UC4.2
N18502042: D23.2 D24.2 Q24.1 Q25.4 R428.2
N18502098: Q25.3 Q26.2
N18502175: Q26.1 R438.1
N18599297: C76.2 R57.1
N18599324: C85.2 R45.1
N19638084: PC401.1 PJP400.2 PJP402.2 PU400.5 PU400.9
N19638635: PR114.2 PU100.19
N19641658: PR748.1 PR749.2 PU703.4
N19643962: PR710.2 PU703.6
N19662847: PQ825.2 PR872.2
N19721969: PL500.4 PR522.1 PU501.4
N19723889: PR517.1 PU501.6
N19723999: PC504.2 PU501.7
N19810155: PC811.1 PQ811.4 PR821.1
N19817114: PC809.1 PQ815.1 PQ815.2 PQ815.3 PQ826.1 PQ826.2 PQ826.3 PR818.2
N19821087: Q29.2 R460.2
N19867208: PR717.2 PU700.5
N19955529: PD810.1 PD814.1 PD819.1 PQ816.2
N19967828: PQ813.5 PR848.2 PR853.2
N19968070: PQ821.5 PR851.2 PR852.2
N19968610: PQ818.2 PQ819.3 PQ819.6 PR824.1 PR834.1
N19969338: PD811.2 PR815.2
N20046697: Q3.2 R102.2 R106.2
N20049726: R421.2 R422.2 R439.2 U45.3
N20054548: R39.1 U17.22
N20054658: C134.1 U17.37
N20054660: C134.2 U17.35
N20059638: R186.1 U17.46
N20070293: PQ823.3 PR863.2 PR869.1
N20089981: C385.1 U17.31
N20097876: PC807.2 PQ810.4 PR811.2
N20124570: PQ712.6 PR734.2
N20242895: PQ827.2 PR856.2
N20279752: PQ828.2 PR861.2
N20279756: PQ821.6 PQ828.1 PR839.2
N20412388: JEDP1.22 LE1.1
N20426339: C407.1 U22.12
N20428354: R196.1 U22.3
N20463494: C433.1 U31.12
N20469495: C394.1 U31.10
N21122826: C427.1 U22.10
N21375241: D31.2 JHP1.5 R480.2
N21887845: JMINI1.49 R223.2
N23380026: Q124.2 R420.2
N23382220: C145.1 R147.1 R194.1
N23382222: C146.1 R151.1 R153.1
N23382664: Q123.5 Q123.6 R202.2
N23382684: Q123.2 R213.1 R220.1
N23469003: CC67.2 RC83.1
N23469424: CC69.2 RC128.1
N23599481: C409.1 U3.10
N23599487: C429.1 U3.12
N23599941: R129.2 U3.3
N24705366: CC70.2 RC195.1
N24843313: C319.1 R273.2
N24843502: CE8.1 RE4.2
N24844156: CE9.1 RE5.2
N26813169: R319.2 U37.B18
N28286586: Q15.1 R430.1
N28286590: D23.1 Q24.3
N28286598: Q15.2 Q24.6
N31479955: R321.1 U37.B19
N34998891: JDIMM2.201 RD10.1
N34998993: JDIMM2.197 RD11.1
N45129141: Q4.1 R99.2
N48705646: PL3.1 PQ2.1 PR7.1 PR10.2
N48705653: PQ2.3 PR7.2 PR9.1
N48705663: PQ3.2 PR10.1 PR12.2
N48705665: PQ2.2 PQ3.1 PR11.2 PR13.1
N48708347: PC204.2 PR200.1
N48708425: PR206.2 PU11.9
N48716673: PR838.2 PU800.28
N48716693: PR850.1 PU800.26
N53733529: R379.2 U38.B62
N53734664: R381.1 U38.B61
N53866851: C363.1 R382.2
N59558234: C323.1 T94.3
N59558236: C324.1 T94.4
N59558274: C325.1 T94.9
N59558278: C326.1 T94.10
N59657288: R161.2 U19.25
N61090377: QD1.3 R29.1 R30.1 R31.1 R33.1
N61500733: PR513.1 PU500.4
N61500909: PC510.2 PR526.1 PU500.28
N61500999: PH501.2 PR515.1
N61501060: PC508.1 PR522.2
N61501216: PC504.1 PR517.2
N61501245: PC501.1 PH500.2 PR505.2 PU500.14
N61501462: PR511.2 PU500.16
N61858263: R211.1 U27.26
N61898314: JDIMM1.197 RD5.2
N61898317: JDIMM1.201 RD6.2
N62014302: C401.1 U46.12
N62015979: C402.1 U46.10
N62018216: R425.2 R426.2 U46.3 U46.5
N62020898: C398.1 U45.10
N62020976: C397.1 U45.12
N62021317: R423.2 R424.2 U45.5
N62022297: C390.1 U43.12
N62022948: R416.2 U43.3
N62078629: C148.1 U18.10
N62078645: R154.2 U18.3 U18.5
N62078782: C147.1 U18.12
N62100802: Q1.2 Q17.6 R94.2
N62111964: Q12.2 R403.2
N62132680: T1.1(TP-1) UC1.L11
N64492809: Q21.3 R157.2
N64492816: Q21.6 R156.2
N64569940: C136.1 R149.2
N64569944: C135.1 R148.2
N66971753: PR100.2 PR102.2 PU100.4
N66971793: PR105.1 PU100.5
N66971949: PR101.2 PR104.2 PU100.2
N66972030: PC110.1 PR109.2
N66972075: PR106.1 PU100.1
N66972333: PC109.2 PR110.1
N66980103: PC114.2 PR112.1
N66983215: PC111.2 PR111.1
N66984844: PC306.2 PR306.1
N70882705: Q16.1 R435.1
N70882773: Q16.2 Q25.6
N74832224: R367.1 R370.1 U38.A59
N74863185: PQ809.4 PR813.1 PR815.1
N78934544: PQ812.2 PQ812.3 PR816.1
N78935279: PD811.1 PQ812.6
N78945927: PQ805.5 PQ805.6 PR807.2
N78957489: PQ816.1 PR822.2
N78963519: PQ817.1 PR819.1 PU805.2
N78963697: PU805.4 PU806.1
N78967013: PD810.2 PU806.4
N78999869: PQ801.2 PR802.1 PR804.1
N78999885: PQ807.6 PR804.2
N79001628: PQ802.2 PU801.4
N79002827: PQ806.2 PU804.4
N79017925: PR820.1 PU806.2
N79021833: PD814.2 PU807.4
N79023703: PR863.1 PU800.19
N79025276: PQ807.2 PQ807.3 PR808.2
N79026826: PQ818.1 PR823.1 PR825.2
N79029876: PR825.1 PU807.2
N79030038: PQ813.2 PQ813.3 PR829.2
N79030087: PQ813.6 PR826.2
N79030091: PQ814.2 PR826.1 PR827.1
N79030745: PD813.2 PQ814.1
N79031357: PQ821.2 PQ821.3 PR849.2
N79031406: PQ822.2 PR839.1 PR840.1
N79031414: PD816.2 PQ822.1
N79033066: PQ823.2 PR869.2 PR870.1
N79033085: PQ824.1 PR870.2
N79033110: PQ824.2 PQ824.4 PR875.2
N79099120: PC700.2 PQ701.2 PQ702.2 PR702.2
N79099147: PC721.2 PC722.1 PR719.1 PU700.12
N79099356: PQ703.1 PQ703.3 PR706.2 PR707.2 PR709.1
N79099392: PC704.2 PC705.1 PR705.2 PU700.1
N79099442: PC703.2 PC704.1 PR704.2 PU700.2
N79099501: PC714.2 PR724.2
N79099542: PC708.1 PR713.1 PR714.1 PU700.6
N79099714: PC720.2 PC721.1 PR718.1 PU700.13
N79100283: PR716.3 PR718.2
N79100287: PQ701.1 PR700.2
N79100289: PQ702.1 PR700.3
N79100293: PR716.2 PR719.2
N79100387: PQ700.4 PR701.1
N79106288: PR722.1 PU700.11
N79108614: PQ712.3 PR740.2 PU3.1
N79108640: PQ710.5 PU3.4
N79108839: PR736.2 PR739.2 PR741.1 PR744.1 PU2.7
N79108872: PC727.1 PR729.1 PR732.2 PU2.3
N79108988: PC729.1 PR736.1 PR737.2 PR742.1 PU2.5
N79109000: PC730.1 PR738.2 PR743.1 PU2.6
N79109047: PC726.1 PR730.2 PR734.1 PR735.1 PU2.2
N79111305: PR715.1 PU700.17
N79114795: PC4.1 PQ1.2 PR6.2
N79114801: PD4.2 PQ1.1
N80905978: PC402.1 PR400.2 PR401.1 PU400.8
N80906026: PC403.2 PR402.2 PR403.1 PU400.2
N85750543: PC304.1 PR301.2
