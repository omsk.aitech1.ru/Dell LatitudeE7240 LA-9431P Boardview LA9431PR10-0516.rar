# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N13388133: length 4.5
  TOP w0.254: v2(4.05,39.55) 4.25,39.75 4.25,40.49
  BOTTOM w0.254: PR830.2 3.7,40.94 PQ832.1 3.42,39.55 v2(4.05,39.55)
N13388149: length 7.5
  TOP w0.102: PD815.2 3.54,35.71 v1(2.73,34.9)
  TOP w0.254: PD815.2 3.54,36.87 2.55,37.86 2.55,41.07 PQ829.1
N13388161: length 6.9
  TOP w0.254: PQ829.3 4.25,41.64 4.46,41.44 5.59,41.44 v1(5.99,41.85) 5.99,42.61 v2(5.79,42.81)
  BOTTOM w0.254: v2(5.79,42.81) 5.79,42.19 PR895.2 PR830.1 5.44,40.44 PR894.2
N13389204: length 16.9
  TOP w0.254: PQ710.2 97.13,90.41 96.86,90.15 v2(96.86,90.02) ; v2(91.49,83.49) 91.76,83.76 PR727.1 PC740.1 92.37,85.57 PR729.2
  BOTTOM w0.254: v2(91.49,83.49) 92.31,83.49 93.12,84.29 93.12,84.99 93.73,85.6 PU2.1 93.73,89.55 95,90.82 96.06,90.82 v1(96.31,90.57) v2(96.86,90.02)
N13401571: length 6.7
  TOP w0.102: PD2.3 159.95,7.59 v1(160.46,8.1)
  TOP w0.254: PD2.3 159.95,6.26 v2(159.92,6.22)
  IN3 w0.254: PBATT1.7 159.92,4.02 v2(159.92,6.22)
N16958676: length 3.4
  BOTTOM w0.102: R417.2 210.52,75.03 R418.2 210.31,75.02 209.89,75.44 v1(209.6,75.44) 209.18,75.02 209.05,75.02 208.72,74.69 U43.5
N16958821: length 2.1
  BOTTOM w0.102: C391.1 208.86,71.02 208.86,71.74 208.72,71.88 U43.10
N16994246: length 0.8
  TOP w0.102: v1(53.82,15.52) 53.82,14.71
N17012912: length 10.3
  TOP w0.254: PQ710.6 100.69,91.06 PR728.1 100.93,91.83 100.57,92.19 v1(98.76,92.19) 97.21,92.19 96.32,91.3 96.32,89.88 96.66,89.53 97.08,89.53 97.31,89.76 PQ710.3
N17149547: length 23.9
  TOP w0.102: v2(54.71,17.12) 54.14,17.12 v1(54.03,17.23)
  TOP w0.254: PU700.10 53.57,5.74 53.76,5.55 v2(54.03,5.55) 54.48,5.55 54.9,5.13 PR750.2 PR726.2 54.68,3.68 PR751.2 ; v2(54.71,17.12) 54.75,17.08 PR711.2
  IN2 w0.254: v2(54.71,17.12) 54.7,17.12 54.06,17.75 52.2,17.75 50.39,15.95 50.39,13.97 49.73,13.31 49.73,11.06 50.66,10.13 50.66,8.23 52.44,6.45 53.12,6.45 v2(54.03,5.55)
N17156946: length 0.7
  TOP w0.102: 53.49,40.42 53.86,40.79 v1(54.03,40.79)
  vias: v2(53.39,37.69)
N17156948: length 3.9
  TOP w0.102: PQ6.1 v1(56.34,36.25)
  TOP w0.254: PQ6.1 55.14,37.02 54.92,37.25 54.38,37.25 54.19,37.06 PQ6.2
N17205976: length 58.1
  TOP w0.102: R388.2 v1(3.81,8.48) v2(3.07,7.75)
  BOTTOM w0.102: JDEG1.10 13.17,42.28 13.2,42.25 13.2,41.57 13.19,41.56 13.19,41.48 12.92,41.21 12.92,40.67 12.67,40.43 12.67,39.24 12.52,39.09 12.52,37.03 11.35,35.86 11.35,35.13 10.06,33.84 7.25,33.84 7.06,33.65 5.77,33.65 5.56,33.45 5.56,31.14 7.9,28.8 7.9,26.85 7.34,26.29 7.34,23.8 8.53,22.61 8.53,21.36 8.92,20.98 8.92,5.85 9.55,5.22 9.55,3.89 9.18,3.52 7.21,3.52 3.09,7.64 3.09,7.73 v2(3.07,7.75)
N17219423: length 1.6
  TOP w0.508: 48.77,16.97 49.76,17.96 PD701.1
  vias: v1(48.13,17.22)
N17219466: length 4.2
  TOP w0.203: PU11.7 117.95,10.04 v1(118.59,9.4) 118.59,8.66 119.08,8.18 PR210.2
  TOP w0.254: PR210.2 PR211.2
N17318583: length 1.5
  BOTTOM w0.102: 150.62,15.07 149.31,15.07 v1(149.15,15.24)
N17321675: length 4.1
  TOP w0.254: PQ806.3 123.86,10.02 123.62,10.26 123.18,10.26 123.06,10.15 PR810.2 PR812.2 122.97,11.07 123.43,11.53 PU804.2
N17321677:
  vias: v1(126.01,5.93)
N17404646: length 2.6
  TOP w0.102: v1(30.95,37.48) 30.95,36.54 C339.1 29.78,36.3 R324.2
N17639884: length 6.3
  TOP w0.203: v2(86.58,74.29) 86.9,74.29 87.05,74.44 PU500.2
  TOP w0.254: v2(86.58,74.29) 86.37,74.5 86.37,75.8 85.84,76.33 PR519.2
  BOTTOM w0.102: v2(86.58,74.29) 86.56,74.31 85.41,74.31 v1(85.28,74.43)
  BOTTOM w0.254: PC505.2 87.45,74.78 86.97,74.29 v2(86.58,74.29)
N17640254: length 5
  TOP w0.203: PC506.1 93.1,77.28 v1(92.44,76.62) 92,76.17 91.55,76.17 91.25,75.87 PU500.25
  TOP w0.254: PC506.1 PR523.1 93.1,79.43 PR535.1
N17640267: length 2.1
  TOP w0.102: v1(94.15,80.83) 93.69,80.38 PR535.2
  TOP w0.254: PC512.1 PR535.2
N17640270: length 5.1
  TOP w0.203: PR521.1 91.14,77.38 v1(91.14,76.63) 91.14,76.26 90.85,75.98 PU500.26
  TOP w0.254: PC512.2 92.19,79.4 PR523.2 PC506.2 PR521.1
N17645088: length 5.1
  TOP w0.102: PR512.2 v1(90.78,63.02)
  TOP w0.254: PR512.2 92.19,62.32 v2(92.46,62.06)
  BOTTOM w0.254: v2(92.46,62.06) 92.2,62.31 PL500.3
N17663289: length 25.8
  IN2 w1.016: 68.96,10.06 70.69,11.79 70.69,13.94 69.98,14.66 64.8,14.66 64.24,15.21 60.41,15.21 59.91,14.71 56.54,14.71 56.03,15.21 54.47,15.21 51.61,12.36
  vias: v1(69.08,11.52) v3(51.99,11.35) v3(51.99,10.69) v3(64.12,7.72) v3(64.12,7.09) v3(64.12,6.45) v3(64.76,7.72) v3(64.76,7.09) v3(64.76,6.45) v3(65.39,7.72) v3(65.39,7.09) v3(65.39,6.45) v3(66.03,7.72) v3(66.03,7.09) v3(66.03,6.45) v3(68.5,8.04) v3(68.5,7.4) v3(68.52,6.76) v3(68.52,6.12) v3(69.2,8.04) v3(69.2,7.4) v3(69.2,6.77) v3(69.2,6.13)
N17680637: length 4.8
  TOP w0.102: PR537.2 85.85,70.38 v1(85.4,69.93)
  TOP w0.203: v2(86.87,71.3) 86.87,71.45 87.46,72.04 PU500.8
  TOP w0.254: PR537.2 86.42,70.85 v2(86.87,71.3) 86.44,71.73 PR536.2
N17680665: length 3.9
  TOP w0.203: PU500.3 87.32,74.04 87.09,73.81 86.67,73.81 86.49,73.63 PR540.2
  TOP w0.254: PR540.2 PR539.2 PR516.1
N17683399: length 4.5
  TOP w0.254: PR725.2 47.61,5.72 48.39,6.5 48.68,6.5 49.26,7.09 49.26,7.28 v1(49.61,7.63) 49.9,7.91 PU700.3
N17812022: length 1.3
  TOP w0.254: R152.2 277.8,27.66 277.21,27.07 Q20.3
N18063845: length 1.2
  TOP w0.102: R413.1 39.99,10.22 40.04,10.27 U42.4
N18435663: length 2.9
  TOP w0.102: UC4.2 107.37,95.86 v1(107,95.49) RC263.1
N18502042: length 11.7
  TOP w0.102: Q24.1 198.92,93.32 198.69,93.32 198,94.02 v2(198,94.06) 197.84,94.21 194.89,94.21 R428.2 193.06,94.74 D23.2 191.51,93.88 D24.2 191.48,94.6 v1(191.11,94.97)
  BOTTOM w0.102: v2(198,94.06) 198.02,94.08 198.02,94.7 198.25,94.93 198.76,94.93 198.92,95.09 Q25.4
N18502098: length 2.5
  BOTTOM w0.102: Q25.3 198.92,92.98 199.17,92.72 v1(199.17,92.34) 198.58,92.34 198.54,92.38 Q26.2
N18502175: length 2.2
  BOTTOM w0.102: v1(194.58,92.68) 194.88,92.38 R438.1 Q26.1
N18599297: length 2.6
  BOTTOM w0.102: R57.1 177.65,82.59 v1(177.32,82.26) 177.32,81.65 C76.2
N18599324: length 2.1
  BOTTOM w0.102: R45.1 C85.2 v1(177.18,74.64)
N19638084: length 2.3
  BOTTOM w0.102: v1(99.89,99.76) 99.89,99.25 99.42,98.78 PC401.1
N19638635: length 2.7
  TOP w0.203: PU100.19 194.76,48.85 194.4,48.49
  TOP w0.254: PR114.2 193.74,47.98 v1(194.02,48.27) 194.25,48.49 194.4,48.49
N19641658: length 1.3
  TOP w0.102: v1(42.53,8.24) 41.97,7.68 PR748.1
N19643962:
  vias: v1(41.67,3.53)
N19662847: length 1.7
  TOP w0.254: PR872.2 134.57,5.06 134.86,5.36 PQ825.2
N19721969:
  vias: v1(86.56,65.43)
N19723889: length 1.6
  BOTTOM w0.203: PU501.6 79.95,67.12 79.59,66.76 PR517.1
N19723999: length 2.6
  BOTTOM w0.102: v1(79.34,68.94) PC504.2
  BOTTOM w0.203: PU501.7 79.62,67.52 PC504.2
N19810155: length 6
  BOTTOM w0.102: v1(155.56,10.6) 155.56,10.91 156.77,12.12 PC811.1
  BOTTOM w0.254: PQ811.4 158.24,14.83 156.78,13.37 PR821.1 PC811.1
N19817114: length 1.9
  TOP w0.508: PR818.2 192.2,11.37 PC809.1 192.14,11.35 v3(191.16,11.35)
  vias: v1(189.59,11.1) v3(177.32,15.19) v3(177.34,14.55) v3(177.34,13.92) v3(178,15.21) v3(177.98,14.55) v3(177.98,13.92) v3(190.5,12.62) v3(190.53,11.99) v3(190.53,11.35) v3(191.19,12.65) v3(191.16,11.99)
N19821087: length 2.9
  TOP w0.102: v1(184.63,98.78) 184.26,98.41 R460.2 185.12,97.84 185.22,97.74 Q29.2
N19867208: length 5
  TOP w0.254: PU700.5 50.37,6.91 50.09,6.63 50.09,6.2 49.86,5.97 v1(49.44,5.97) 49.33,5.97 49.07,5.71 49.07,4.17 48.45,3.54 PR717.2
N19955529: length 65.2
  IN3 w0.254: v2(134.26,12.04) 145.76,12.04 146.42,12.7 152.97,12.7 153.25,12.42 166.08,12.42 170.89,7.61 178.4,7.61 v2(179.38,6.63)
  BOTTOM w0.254: v2(179.38,6.63) 180.04,5.97 190.55,5.97 191.47,6.88 191.47,8.69 192.72,9.94 PQ816.2
  vias: v1(133.5,12.2)
N19967828: length 2.3
  BOTTOM w0.254: PQ813.5 201.68,4.6 PR853.2 201.59,4.69 PR848.2
N19968070: length 92.4
  TOP w0.254: PQ821.5 204.76,16.61 204.89,16.74 PR851.2 205.26,16.5 v2(205.73,16.03) ; PR852.2 147.28,10.49 v1(147.03,10.24) v2(146.63,9.84)
  IN2 w0.254: v2(210.86,16.76) 206.46,16.76 v2(205.73,16.03)
  IN3 w0.254: v2(146.63,9.84) 149.8,9.84 150.98,11.02 165.5,11.02 170.41,6.11 175.13,6.11 179.87,1.37 203.75,1.37 204.83,2.45 209.46,2.45 211.28,4.27 211.28,16.34 v2(210.86,16.76)
N19968610: length 24
  TOP w0.102: v1(147.23,15.65) 146.88,15.29 v2(146.88,14.95)
  TOP w0.254: v2(138.23,3.78) 138.52,4.07 PQ819.6 ; v2(146.88,14.95) 146.88,14.44 147.18,14.13 PR834.1 ; v2(141.08,8.23) 141.63,7.68 PQ818.2 141.52,7.49 PR824.1 142.04,6.07 142.04,5.63 141.79,5.37 PQ819.3
  IN3 w0.254: v2(138.23,3.78) 139.62,3.78 141.08,5.24 v2(141.08,8.23)
  BOTTOM w0.254: v2(141.08,8.23) 141.08,9.82 143.62,12.36 144.39,12.36 146.88,14.85 v2(146.88,14.95)
N19969338: length 1.7
  TOP w0.102: PD811.2 174.07,10.41 v1(173.57,9.91)
N20046697: length 8.9
  TOP w0.102: Q3.2 88.71,95.36 88.51,95.16 v1(85.74,95.16) 85.4,95.16 84.44,96.11 83.03,96.11 82.88,96.27 R106.2 82.6,97.03 R102.2
N20049726: length 4.8
  TOP w0.102: U45.3 194.47,32.47 R421.2 R422.2 195.19,31.82 195.16,31.79 R439.2 v1(195.16,30.38)
N20054548: length 5.8
  TOP w0.102: R39.1 280.37,33.73 v1(280.37,34.51) 280.37,35.05 279.71,35.71 277.55,35.71 277.4,35.57 U17.22
N20054658: length 3.6
  TOP w0.254: C134.1 269.84,39.22 269.84,37.63 269.3,37.09 269.3,36.72 269.45,36.57 U17.37
N20054660: length 2.1
  TOP w0.254: U17.35 271.08,39.37 C134.2
N20059638: length 2.7
  TOP w0.254: U17.46 269.11,32.07 269.06,32.02 v1(268.36,32.02) 267.37,32.02 R186.1
N20070293: length 3
  TOP w0.254: PQ823.3 8.38,35.53 PR869.1 8.89,34.2 PR863.2
N20089981: length 13.3
  TOP w0.102: v2(274.6,41.97) 274.23,41.6 274.23,39.55 273.08,38.4 U17.31 ; v1(269.89,43.32) 270.03,43.18 270.69,43.18 270.84,43.03 C385.1 270.27,41.99 v2(270.12,41.83)
  IN1 w0.084: v2(270.12,41.83) 270.85,42.57 274.24,42.57 274.6,42.21 v2(274.6,41.97)
N20124570: length 1.1
  TOP w0.102: v1(92.35,87.16) 92.67,87.48 PR734.2
N20242895: length 4.6
  BOTTOM w0.102: PR856.2 28.37,42.42 28.9,42.94 PQ827.2 31.74,42.94 v1(32.23,43.43)
N20279752: length 2.7
  TOP w0.102: PQ828.2 203.66,20.75 v1(204.06,21.16)
  TOP w0.254: PR861.2 202.72,19.86 PQ828.2
N20279756: length 11.9
  TOP w0.254: PQ821.6 204.88,17.26 205.26,17.64 PQ828.1 206.3,19.21 206.65,18.86 206.65,17.2 207.01,16.84 v1(207.01,15.49) 206.55,15.04 206.55,12.71 PR839.2
N20412388: length 7.3
  TOP w0.102: LE1.1 62.5,79.44 v1(62.68,79.25) 63.09,78.84 v2(63.09,78.78)
  BOTTOM w0.102: v2(63.09,78.78) 63.09,76.66 62.18,75.74 62.18,75.1 62.19,75.09 JEDP1.22
N20426339: length 4.1
  TOP w0.102: v1(203.48,41.06) 203.48,39.46 C407.1 203.35,38.41 U22.12
N20428354: length 2.3
  TOP w0.102: U22.3 199.8,38.41 199.7,38.52 199.24,38.52 199.14,38.41 v1(199.03,38.41) 198.29,38.41 R196.1
N20463494: length 3.9
  BOTTOM w0.102: U31.12 196.92,73.97 197.5,74.55 198.27,74.55 C433.1 198.76,75.46 199.23,75.93 v1(199.23,75.95)
N20469495: length 4.7
  TOP w0.102: C394.1 v1(196.66,74.8) 196.66,75.62 v2(196.85,75.81)
  BOTTOM w0.102: U31.10 196.12,74.17 196.74,74.79 196.74,75.69 v2(196.85,75.81)
N21122826: length 3
  TOP w0.102: U22.10 202.81,37.61 202.91,37.5 203.3,37.5 203.95,38.15 C427.1 204.75,38.16 v1(204.93,38.34)
N21375241: length 10
  TOP w0.127: JHP1.5 270.54,55.47 v1(270.09,55.92)
  BOTTOM w0.254: R480.2 271.58,52.08 D31.2 271.02,53.76 271.02,55.27 271.22,55.47 JHP1.5
N21887845: length 3.1
  BOTTOM w0.102: JMINI1.49 210.98,31.2 210.12,30.34 v1(209.88,30.34) 209.74,30.34 209.27,29.87 R223.2
N23380026: length 3.6
  TOP w0.102: Q124.2 159.39,91.41 159.65,91.15 R420.2 161.94,91.15 v1(162.19,90.89)
N23382220: length 2
  TOP w0.254: R147.1 274.36,23.28 R194.1 C145.1
N23382222: length 3.2
  TOP w0.102: R153.1 274.56,26.01 v1(274.31,26.26)
  TOP w0.254: R153.1 C146.1 274.42,24.32 R151.1
N23382664: length 3.9
  TOP w0.102: v1(266.52,27.56) R202.2 267.56,27.47 Q123.6 267.56,25.85 267.73,25.68 268.04,25.68 268.21,25.85 Q123.5
N23382684: length 5.9
  TOP w0.102: v1(266.33,24.42) 266.48,24.57 266.48,25.44 267.41,25.44 268.21,24.64 Q123.2 268.21,23.8 267.78,23.37 R213.1 R220.1
N23469003: length 2
  TOP w0.102: CC67.2 RC83.1 v1(112.2,15.39)
N23469424: length 3
  TOP w0.102: RC128.1 CC69.2 135.82,28.47 136.98,29.63 v1(136.98,30.1)
N23599481: length 1.8
  TOP w0.102: U3.10 203.55,27.49 203.63,27.57 203.63,28.35 C409.1
N23599487: length 3.9
  TOP w0.102: U3.12 202.75,28.42 C429.1 203.43,29.1 v1(203.43,30.53)
N23599941: length 2.7
  TOP w0.102: U3.3 202.75,23.86 R129.2 202.27,23.46 v1(202.08,23.27)
N24705366: length 2.3
  TOP w0.102: CC70.2 RC195.1 52.51,28.32 v1(52.07,28.76)
N24843313: length 2.6
  BOTTOM w0.102: R273.2 146.6,97.19 C319.1 v1(148.58,96.35)
N24843502: length 1
  BOTTOM w0.102: CE8.1 RE4.2
N24844156: length 1
  BOTTOM w0.102: CE9.1 RE5.2
N26813169: length 10.2
  TOP w0.102: U37.B18 24.45,30.52 24.18,30.79 23.8,30.79 23.56,31.03 23.48,31.03 23.03,31.47 v2(22.91,31.47) ; v1(27.41,27.71) 27.53,27.84 v2(27.53,28.3) R319.2
  BOTTOM w0.102: v2(27.53,28.3) 27.53,28.94 26.57,29.91 24.69,29.91 23.57,31.03 23.48,31.03 23.03,31.47 v2(22.91,31.47)
N28286586: length 2
  BOTTOM w0.102: Q15.1 204.11,94.21 204.67,94.77 R430.1
N28286590: length 7.6
  TOP w0.102: D23.1 197.49,93.88 v1(198.04,93.32) 198.58,92.79 200,92.79 200.4,93.18 Q24.3
N28286598: length 6.4
  TOP w0.102: v2(199.57,94.28) 199.1,94.75 Q24.6
  BOTTOM w0.102: v2(199.57,94.28) 199.68,94.39 200.08,94.39 200.37,94.68 200.84,94.68 202.26,93.26 Q15.2 201.82,92.43 v1(201,92.43)
N31479955: length 7.6
  TOP w0.102: v2(23.48,31.6) 23.48,31.47 23.93,31.02 U37.B19 ; v2(27.62,31.42) 27.98,31.42 28.44,30.96 R321.1
  BOTTOM w0.102: v2(23.48,31.6) 23.48,31.47 24.26,30.7 26.13,30.7 26.85,31.42 v2(27.62,31.42)
N34998891: length 3
  TOP w0.102: v1(197.84,27.69) 198.15,27.37 v2(198.4,27.37) 198.23,27.21 RD10.1
  BOTTOM w0.102: JDIMM2.201 v2(198.4,27.37)
N34998993: length 7.4
  TOP w0.102: v2(198.43,28.64) 198.07,28.64 197.28,27.85 RD11.1 v1(196.14,26.53)
  BOTTOM w0.102: v2(198.43,28.64) 197.99,28.64 197.2,27.85 JDIMM2.197
N45129141: length 3.9
  TOP w0.102: R99.2 70.88,68.81 71.49,68.19 72.21,68.19 72.38,68.36 Q4.1 72.38,68.96 v1(73.23,69.81)
N48705646: length 7
  TOP w0.254: PR7.1 82.52,85.95 PQ2.1 85.53,85.95 PR10.2 v1(86.84,86.05) 87.15,86.36 PL3.1
N48705653: length 7.6
  TOP w0.254: PR7.2 82.23,86.58 PQ2.3 82.23,90 v1(81.99,90.25) 81.99,92 PR9.1
N48705663: length 5.2
  TOP w0.254: PR10.1 86.03,86.97 86.13,86.87 87.33,86.87 v1(87.97,87.51) 88.17,87.72 PQ3.2 87.96,88.89 PR12.2
N48705665: length 9.9
  TOP w0.102: PQ2.2 84.16,89.45 v1(83.77,89.84)
  TOP w0.254: PQ2.2 84.76,88.04 84.96,87.83 PR11.2 85.95,87.83 86.45,88.33 86.45,89.36 87.67,90.57 PQ3.1 88.82,91.1 PR13.1
N48708347: length 1.4
  TOP w0.102: PC204.2 v1(111.3,14.3)
N48708425: length 2.5
  TOP w0.203: PR206.2 119.1,11.73 v1(118.59,11.23) 118.2,10.84 PU11.9
N48716673: length 3.4
  TOP w0.102: v1(1.3,31.58) 1.3,31.32 PR838.2
  TOP w0.254: PU800.28 2.51,30.1 PR838.2
N48716693: length 3.8
  TOP w0.254: PU800.26 5.28,31.64 v1(3.83,33.09) 3.42,33.5 PR850.1
N53733529: length 8.2
  TOP w0.102: R379.2 14.94,16.17 v2(15.15,15.95) ; v2(20.76,13.41) 20.76,13.51 20.69,13.58 U38.B62
  BOTTOM w0.102: v2(15.15,15.95) 16.81,14.3 17.78,14.3 18.44,13.64 20.63,13.64 20.76,13.51 v2(20.76,13.41)
N53734664: length 8.6
  TOP w0.102: v2(21.8,14.65) 21.77,14.65 21.2,14.08 U38.B61 ; R381.1 17.62,12.41 v2(17.62,12.05)
  BOTTOM w0.102: v2(17.62,12.05) 17.62,12.05 17.74,11.93 19.29,11.93 20.28,12.92 20.28,12.93 21,12.93 21.8,13.73 v2(21.8,14.65)
N53866851: length 1.5
  TOP w0.102: C363.1 33.33,16.85 R382.2
N59558234: length 5
  BOTTOM w0.102: v1(260.87,81.95) C323.1
  BOTTOM w0.381: T94.3 257.29,83.86 258.31,82.84 258.75,82.84 C323.1
N59558236: length 4.2
  BOTTOM w0.381: T94.4 256.02,83.22 v1(256.78,82.46) 257.1,82.14 258.18,82.14 C324.1
N59558274: length 4
  BOTTOM w0.508: C325.1 248.27,82.4 249.12,82.4 v1(249.42,82.7) 249.69,82.97 249.69,84.48 T94.9
N59558278: length 4.8
  BOTTOM w0.102: v1(245.12,81.83) C326.1
  BOTTOM w0.508: C326.1 248.4,83.86 T94.10
N59657288: length 2.4
  TOP w0.102: R161.2 169.64,83.57 v1(169.64,83.71) U19.25
N61090377: length 105.2
  TOP w0.102: R31.1 R33.1 177.45,18.7 v2(178.73,19.98) ; v2(115.34,21.41) 116.45,22.52 v1(116.45,25.65) 116.45,27.44 116.89,27.88 116.89,30.01 117.79,30.91 QD1.3 ; v2(99.2,20.68) R29.1 R30.1
  IN3 w0.122: v2(178.73,19.98) 177.14,18.39 139.44,18.39 139.23,18.18 133.86,18.18 133.65,18.39 132.99,18.39 132.43,18.94 130.52,18.94 130.15,19.32 128.41,19.32 127.5,18.4 124.19,18.4 122.78,16.99 118.94,16.99 118.26,17.67 115.23,17.67 114.49,18.4 114.49,19.86 115.34,20.71 v2(115.34,21.41) 114.48,22.28 100.8,22.28 v2(99.2,20.68)
N61500733: length 2.9
  TOP w0.203: v2(86.87,73.35) 87.1,73.35 87.39,73.64 PU500.4
  BOTTOM w0.102: v2(86.87,73.35) 86.64,73.35 v1(86.07,72.78)
  BOTTOM w0.254: v2(86.87,73.35) 87.21,73.35 PR513.1
N61500909: length 5.9
  TOP w0.102: v1(90.14,80.2) 90.14,79.32 89.9,79.08 PR526.1
  TOP w0.203: v2(89.99,76.68) 90.05,76.62 PU500.28
  TOP w0.254: PR526.1 89.71,78.46 89.71,77.25 89.99,76.97 v2(89.99,76.68)
  BOTTOM w0.508: PC510.2 89.99,76.99 v2(89.99,76.68)
N61500999: length 1.8
  TOP w0.102: PH501.2 93.97,65.58 v1(94.11,65.72)
  TOP w0.254: PR515.1 PH501.2
N61501216: length 2.6
  BOTTOM w0.102: PR517.2 77.08,66.76 v1(76.7,66.38)
  BOTTOM w0.508: PC504.1 77.88,67.26 PR517.2
N61501245: length 11.3
  TOP w0.203: PC501.1 90.61,70.73 90.45,70.89 PU500.14
  TOP w0.254: v2(90.6,68.17) 90.6,68.8 PR505.2 PC501.1
  BOTTOM w0.254: v2(90.6,68.17) 90.12,68.66 88.14,68.66 86.4,70.4 v1(86.06,70.4) 84.66,70.4 PH500.2
N61501462: length 4.1
  TOP w0.102: v1(93.4,68.66) 92.46,69.6 PR511.2
  TOP w0.203: PR511.2 92.46,70.61 92.16,70.9 91.43,70.9 91.25,71.08 PU500.16
N61858263: length 2.5
  TOP w0.203: R211.1 254.71,15.52 255.18,15.99 255.74,15.99 256.19,16.44 U27.26
N61898314: length 5
  TOP w0.102: RD5.2 119.62,24.93 120.3,24.25 v1(120.89,24.25) v2(121.46,24.25)
  BOTTOM w0.102: JDIMM1.197 120.7,24.42 120.87,24.25 v2(121.46,24.25)
N61898317: length 8.3
  TOP w0.102: RD6.2 118.73,24.36 v1(120.14,22.95) 120.74,22.35 v2(121.01,22.35)
  BOTTOM w0.102: v2(121.01,22.35) 121.01,23.2 122.03,24.23 122.03,24.68 121.9,24.81 JDIMM1.201
N62014302: length 2.9
  TOP w0.102: v2(187.35,69.57) 187.35,69.37 187.79,68.93 U46.12
  BOTTOM w0.102: C401.1 186.91,68.57 187.35,69.01 v2(187.35,69.57)
N62015979: length 3.4
  TOP w0.102: v2(188.52,69.51) 188.59,69.44 U46.10
  BOTTOM w0.102: v1(189.88,69.14) 189.31,68.57 C402.1 188.9,69.13 v2(188.52,69.51)
N62018216: length 4.3
  TOP w0.102: U46.5 188.59,65.77 v2(188.67,65.68) ; U46.3 187.79,65.84 v2(187.63,65.68)
  BOTTOM w0.102: v2(187.63,65.68) 187.64,65.68 v1(188.14,65.68) v2(188.67,65.68) R425.2 R426.2
N62020898: length 1.8
  TOP w0.102: C398.1 189.93,33.27 U45.10
N62020976: length 1.7
  TOP w0.102: C397.1 189.78,32.41 191.05,32.41 191.11,32.47 U45.12
N62021317: length 4
  TOP w0.102: U45.5 193.85,33.27 194.05,33.48 194.58,33.48 R423.2 R424.2 194.61,34.98 v1(194.27,35.32)
N62022297: length 2.1
  BOTTOM w0.102: C390.1 207.92,71.07 U43.12
N62022948: length 2.8
  BOTTOM w0.102: v1(208.31,76.01) 208.27,75.97 R416.2 207.3,75.55 207.92,74.93 U43.3
N62078629: length 1.3
  TOP w0.102: C148.1 269.47,18.34 269.44,18.37 U18.10
N62078645: length 5.8
  TOP w0.102: R154.2 265.74,21.03 v1(265.74,20.04) 265.74,19.21 ; 265.74,19.21 265.74,18.45 265.93,18.26 266.39,18.26 266.5,18.37 U18.5 ; 265.74,19.21 266.43,19.21 266.48,19.17 U18.3
N62078782: length 1.3
  TOP w0.102: C147.1 269.48,19.23 269.42,19.17 U18.12
N62100802: length 6.3
  TOP w0.102: Q1.2 146.1,102.39 R94.2 147.12,101.37 147.12,99.92 146.67,99.48 Q17.6 145.96,99.48 v1(145.33,100.11)
N62111964: length 3.2
  TOP w0.102: Q12.2 35.23,19.71 35.1,19.58 35.1,18.97 R403.2 35.43,18.49 v1(36.22,17.7)
N62132680: length 1.4
  TOP w0.102: v2(144.26,76.11) 144.13,75.98 T1.1
  BOTTOM w0.076: UC1.L11 144.82,76.67 v2(144.26,76.11)
N64492809: length 3.7
  TOP w0.102: Q21.3 281.52,25.57 281.42,25.67 281.42,26.92 v1(280.8,27.55) R157.2
N64492816: length 4.1
  TOP w0.254: R156.2 279.04,27.36 279.04,24.75 279.53,24.27 Q21.6
N64569940: length 0.9
  TOP w0.254: R149.2 273.25,26.9 C136.1
N64569944: length 1
  TOP w0.254: R148.2 272.55,27.34 C135.1
N66971753: length 4.2
  TOP w0.203: PU100.4 197.24,46.86
  TOP w0.254: PR102.2 PR100.2 198.78,45.31 v1(197.76,46.34) 197.24,46.86
N66971793: length 3.6
  TOP w0.203: PU100.5 197.64,47.09
  TOP w0.254: 197.64,47.09 198.22,46.51 v1(199.12,46.51) 199.39,46.51 199.82,46.08 PR105.1
N66971949: length 3.8
  TOP w0.203: PU100.2 196.44,46.69
  TOP w0.254: 196.44,46.69 v1(195.95,46.21) 195.69,45.95 PR104.2 PR101.2
N66972030: length 1.4
  TOP w0.102: PC110.1 v1(190.14,49.06)
N66972075: length 4.1
  TOP w0.203: PU100.1 196.04,47.05
  TOP w0.254: PR106.1 193.92,45.17 194.47,45.73 v1(194.47,46.52) 194.73,46.77 195.76,46.77 196.04,47.05
N66972333: length 1.4
  TOP w0.102: PR110.1 v1(202.04,51.59)
N66980103: length 1.4
  TOP w0.102: PC114.2 189.28,63.44 v1(188.96,63.75)
N66983215: length 0.8
  TOP w0.102: 202.58,62.72 202.58,63.49 v1(202.62,63.52)
N66984844: length 1.8
  TOP w0.102: PC306.2 230.56,79.98 v1(229.96,80.58)
N70882705: length 6
  TOP w0.102: v2(205.35,99.57) 204.23,98.45 R435.1
  BOTTOM w0.102: Q16.1 204.11,97.11 204.7,97.69 v1(204.7,98.15) 204.7,98.92 v2(205.35,99.57)
N70882773: length 2.5
  BOTTOM w0.102: Q16.2 202.26,95.29 201.42,95.29 v1(201.25,95.46) 201.07,95.64 200.35,95.64 200.22,95.51 Q25.6
N74832224: length 12.6
  TOP w0.102: U38.A59 18.47,13.33 18.28,13.14 18.2,13.14 v2(17.95,12.89) ; v2(16.66,21.56) 16.69,21.59 R367.1 R370.1
  IN1 w0.084: v2(17.95,12.89) 17.24,12.89 16.84,13.28 16.84,21.39 v2(16.66,21.56)
N74863185: length 9.9
  TOP w0.102: v1(178.73,10.77) PR815.1
  TOP w0.254: PR815.1 177.51,11.67 PR813.1 v2(176.78,11.68)
  BOTTOM w0.254: PQ809.4 172.26,11.02 172.69,10.59 172.69,10.31 173.18,9.83 175.9,9.83 176.78,10.72 v2(176.78,11.68)
N78934544: length 1.3
  TOP w0.102: PQ812.3 v1(179.55,7.26)
N78935279: length 1.6
  TOP w0.102: v1(175.3,6.53) 175.11,6.72 PD811.1
N78945927: length 1.4
  TOP w0.102: PQ805.6 131.82,5.89 v1(131.95,6.03)
N78957489: length 6
  TOP w0.254: PR822.2 192.2,8.76 192.58,8.38 193.09,8.38 v2(193.36,8.65)
  BOTTOM w0.102: v1(194.17,5.9) 194.64,6.37 PQ816.1
  BOTTOM w0.254: PQ816.1 194.15,7.86 v2(193.36,8.65)
N78963519: length 6.4
  TOP w0.102: v1(143.24,13.66) PQ817.1
  TOP w0.254: PR819.1 143.09,10.82 143.24,10.97 PQ817.1 142.58,11.98 142.06,11.45 141.4,11.45 141.07,11.79 PU805.2
N78967013: length 3.6
  TOP w0.254: PU806.4 137.11,11.61 v1(136.47,10.97) 135.88,10.97 135.12,10.2 PD810.2
N78999869: length 3.1
  BOTTOM w0.254: PR804.1 PR802.1 151.87,11.73 151.32,12.28 PQ801.2
N78999885: length 3.6
  BOTTOM w0.254: PR804.2 149.59,11.2 149.59,12.61 148.78,13.42 PQ807.6
N79001628: length 2.1
  TOP w0.254: PQ802.2 129.85,10.01 130.6,9.25 PU801.4
N79002827: length 2.3
  TOP w0.254: PU804.4 125.31,10.88 124.51,10.08 PQ806.2
N79017925: length 3.4
  TOP w0.102: PR820.1 138.23,12.61 v1(137.59,13.25)
  TOP w0.254: PR820.1 138.52,12.13 138.56,12.09 138.56,11.24 138.84,10.96 PU806.2
N79023703: length 2.1
  TOP w0.254: PR863.1 8.74,32.66 8.78,32.62 v1(8.78,32.17) PU800.19
N79025276: length 3.1
  BOTTOM w0.254: PQ807.3 147.48,11.37 148.13,10.72 ; 148.13,10.72 PQ807.2 ; 148.13,10.72 PR808.2
N79029876: length 3.1
  TOP w0.254: PR825.1 138.23,9.13 138.23,7.57 137.93,7.28 PU807.2
N79030038: length 3.1
  TOP w0.254: PR829.2 207.14,2.82 v2(206.74,3.21)
  BOTTOM w0.102: 205.77,4.1 v1(206.5,4.84)
N79030087:
  vias: v1(201.77,5.79)
N79030745:
  vias: v1(194.77,3.49)
N79031357: length 45.7
  TOP w0.102: PR849.2 180.85,6.59 v1(181.28,7.02)
  TOP w0.254: PR849.2 180.85,5.41 178.96,3.52 178.96,2.37 179.92,1.41 202.01,1.41 v2(203.3,2.7)
  IN4 w0.254: v2(203.3,2.7) 203.15,2.86 203.15,11.45 200.9,13.7 v2(200.9,16.55)
N79031406: length 3.1
  TOP w0.102: PQ822.2 204.65,12.39 205.55,11.49 v1(206.91,11.49)
N79031414:
  vias: v1(201.31,14.85)
N79033066: length 9.2
  TOP w0.254: PR869.2 7.34,35.66 6.66,35.66 6.45,35.86 PQ823.2 6.45,37.86 5.7,38.61 5.7,40.98 5.98,41.26 v2(6.24,41.26)
  BOTTOM w0.102: v1(6.67,40.97) 6.53,40.97 v2(6.24,41.26)
  BOTTOM w0.254: PR870.1 6.46,41.54 6.24,41.31 v2(6.24,41.26)
N79033085: length 3
  TOP w0.102: v1(7.61,43.22) 7.35,42.96 v2(7.11,42.96)
  TOP w0.254: v2(7.11,42.96) 6.66,42.51 6.66,42.2 6.77,42.09 PQ824.1
  BOTTOM w0.254: PR870.2 6.93,42.79 v2(7.11,42.96)
N79033110: length 4.6
  TOP w0.254: PR875.2 10.55,41.66 10.55,40.94 v1(10.43,40.82) 10.26,40.65 9.88,40.65 9.74,40.79 PQ824.4 8.45,40.79 7.8,41.44 PQ824.2
N79099120: length 16.8
  TOP w0.102: v1(38.84,3.44) 39.14,3.75 39.14,4.55 PR702.2
  TOP w0.254: PC700.2 44.41,3.63 v2(43.99,3.21) ; PQ701.2 36.36,8.09 36.06,7.78 36.06,7.02 35.67,6.64 35.67,5.56 36.06,5.18 36.06,4.1
  IN4 w0.254: v2(43.99,3.21) 36.37,3.21 35.74,3.85 35.74,3.97 v2(35.61,4.1)
N79099147: length 7.4
  TOP w0.254: PR719.1 57.81,5.4 PC721.2 56.99,6.22 56.13,6.22 v2(55.96,6.4) 55.83,6.4 54.82,7.41 PU700.12
  BOTTOM w0.102: v1(55.02,5) 54.75,5.27 54.75,6.03 PC722.1
  BOTTOM w0.254: PC722.1 55.92,6.44 v2(55.96,6.4)
N79099356: length 15.8
  TOP w0.102: PR707.2 46.3,9.75 v1(46.44,9.89)
  TOP w0.254: v2(41.78,5.36) 41.46,5.04 41.46,4.95 PR709.1 41.1,4.67 40.74,5.03 40.73,5.03 40.18,5.57 ; v2(44.95,9.05) 45.4,9.51 PR707.2 45.4,10.38 45.32,10.45 PQ703.3 45.32,11.85 45.07,12.1 44.63,12.1 44.5,12.23 43.74,12.23 43.42,11.91 PQ703.1
  IN4 w0.254: v2(41.78,5.36) 42.62,6.2 44.69,6.2 45.03,6.53 45.03,8.97 v2(44.95,9.05)
N79099392: length 8.2
  TOP w0.254: PU700.1 50.42,8.91 50.22,9.12 50.22,10.07 49.92,10.36 49.71,10.36 ; 49.71,10.36 v2(49.71,10.39) ; 49.71,10.36 48.76,10.36 v1(48.43,10.03) PC704.2 47.54,8.83 PR705.2
  BOTTOM w0.254: v2(49.71,10.39) 49.84,10.39 50.15,10.07 50.15,8.55 PC705.1
N79099442: length 6.4
  TOP w0.102: v2(49.33,8.1) 49.33,8.8 v1(49.66,9.13)
  TOP w0.254: PR704.2 48.04,7.8 48.41,7.43 PC704.1 48.65,7.43 49.33,8.1 v2(49.33,8.1) 49.64,8.41 PU700.2
  BOTTOM w0.254: PC703.2 50.09,7.34 49.33,8.1 v2(49.33,8.1)
N79099501: length 3.3
  TOP w0.102: v1(65.2,3.66) 64.45,2.91 63.42,2.91 62.55,3.78 62.54,3.78
N79099542: length 3.2
  TOP w0.254: PU700.6 51.57,4.96 PR714.1 50.56,4.81 PC708.1 PR713.1
N79099714: length 8.5
  TOP w0.254: PR718.1 58.69,4.93 PC721.1 58.22,6.39 57.98,6.39 57.71,6.65 56.58,6.65 55.79,7.44 v2(55.79,7.66) 55.16,7.66 54.9,7.91 PU700.13
  BOTTOM w0.102: v2(55.79,7.66) 55.79,7.42 56.49,6.72 v1(56.49,6.54)
  BOTTOM w0.254: v2(55.79,7.66) 55.78,7.64 PC720.2
N79100283: length 29.8
  TOP w0.102: v1(78.11,12.14) 77.9,12.34 v2(77.9,12.8)
  TOP w0.254: PR718.2 58.73,3.15 v2(58.74,3.14)
  IN2 w0.254: v2(77.9,12.8) 77.9,7.07 77.01,6.18 77.01,5.57 76.51,5.07 74.58,3.14 v2(58.74,3.14)
  BOTTOM w0.254: PR716.3 77.74,12.64 v2(77.9,12.8)
N79100287: length 31.6
  TOP w0.254: v2(37.24,10.91) 37.07,10.91 36.37,10.21 36.37,9.37 36.06,9.05 PQ701.1
  IN4 w0.254: v2(50.93,18.87) 50.93,18.77 50.3,18.15 49.62,18.15 49.1,17.63 49.1,15.19 47.45,13.54 41.45,13.54 38.76,10.85 37.3,10.85 v2(37.24,10.91)
  BOTTOM w0.254: PR700.2 52.96,25.74 52.76,25.95 51.75,25.95 51.03,25.22 v1(51.03,21.69) 51.03,20.71 51.42,20.32 51.42,19.15 51.14,18.87 v2(50.93,18.87)
N79100289: length 38.3
  TOP w0.254: v2(34.22,9.36) 34.22,8.66 34.98,7.91 34.98,6.77 33.82,5.61 33.82,5.26 34.09,4.99 PQ702.1
  IN4 w0.254: v2(34.22,9.36) 34.89,9.36 36.96,11.43 37.41,11.43 37.62,11.23 38.6,11.23 41.3,13.92 47.29,13.92 48.72,15.35 48.72,17.79 49.46,18.53 50.13,18.53 50.44,18.85 50.44,19.1 50.83,19.48 v2(50.93,19.48)
  BOTTOM w0.254: v2(50.93,19.48) 50.93,20.22 50.62,20.52 50.62,25.37 51.57,26.33 52.63,26.33 52.96,26.66 PR700.3
N79100293: length 31.3
  TOP w0.102: v2(77.11,12.79) v1(76.15,12.79)
  TOP w0.254: v2(57.59,3.12) 57.81,3.34 PR719.2
  IN2 w0.254: v2(77.11,12.79) 77.52,12.38 77.52,7.23 76.63,6.34 76.63,5.73 74.42,3.52 59.16,3.52 59.03,3.64 58.52,3.64 58,3.12 v2(57.59,3.12)
  BOTTOM w0.254: v2(77.11,12.79) 77.2,12.79 77.74,13.32 PR716.2
N79100387: length 3
  BOTTOM w0.102: v1(50.47,28.14) 49.99,28.63 PR701.1
  BOTTOM w0.254: PQ700.4 51.26,29.57 50.81,29.12 PR701.1
N79106288: length 4.3
  TOP w0.254: PR722.1 56.35,4.5 56.35,5.17 v1(55.73,5.78) 55.27,6.25 55.27,6.32 54.68,6.91 PU700.11
N79108614: length 16.3
  TOP w0.102: v1(98.95,86.82) 99.73,87.6 PR740.2
  TOP w0.254: v2(92.53,92.09) 92.42,91.97 PQ712.3 ; PU3.1 102.26,88.97 101.41,88.12 v2(100.94,88.12) 100.62,87.81 PR740.2
  IN1 w0.254: v2(92.53,92.09) 96.97,92.09 v2(100.94,88.12)
N79108640: length 1.6
  TOP w0.254: PQ710.5 100.48,90.41 100.62,90.27 PU3.4
N79108839: length 6.4
  TOP w0.254: PR736.2 95.06,82.26 v2(95.12,82.19)
  BOTTOM w0.102: v1(92.38,82.97) 93.35,82 PR744.1
  BOTTOM w0.254: PR744.1 PR741.1 PR739.2 v2(95.12,82.19) 95,82.32 PU2.7
N79108872: length 7.3
  TOP w0.254: v2(96.56,87.19) PC727.1 PR732.2 96.56,85.43 95.83,84.71 v1(95.62,84.71) 95.36,84.71 95.06,85.01 94.04,85.01 PR729.1
  BOTTOM w0.254: PU2.3 96.27,87.48 v2(96.56,87.19)
N79108988: length 5.9
  TOP w0.102: v1(97.78,82.66) 97.54,82.42 v2(97.54,82.17)
  TOP w0.254: v2(97.54,82.17) 97.27,81.9 PR737.2 96.81,81.91 PC729.1 95.95,82.82 PR742.1 95.94,82.85 95.06,83.72 PR736.1
  BOTTOM w0.254: v2(97.54,82.17) PU2.5
N79109000: length 5
  BOTTOM w0.102: v1(98.88,81.51) PR743.1
  BOTTOM w0.254: PR743.1 PC730.1 PR738.2 96.01,82.07 96.27,82.32 PU2.6
N79109047: length 3.3
  TOP w0.102: PR730.2 95.95,87.64 v1(96.33,88.02)
  BOTTOM w0.254: v2(95.68,87.16) 95.52,87.16 95,87.68 PU2.2
N79111305: length 2.1
  TOP w0.254: PR715.1 53.63,10.81 53.07,10.24 PU700.17
N79114795: length 5.6
  TOP w0.102: v1(155.71,12.47) PR6.2
  TOP w0.254: PR6.2 PC4.1 155.17,11.61 155.31,11.47 155.31,10.29 155.78,9.82 PQ1.2
N79114801: length 5.3
  TOP w0.102: PD4.2 158.06,6.55 v1(158.06,5.87)
  TOP w0.254: PD4.2 156.89,7.72 155.07,7.72 154.81,7.47 PQ1.1
N80905978: length 6.4
  BOTTOM w0.254: PU400.8 102.4,92.13 PC402.1 PR401.1 104.11,91.85 v1(104.75,92.48) 104.75,93.51 104.38,93.88 103.87,93.88 PR400.2
N85750543: length 1.3
  TOP w0.102: PR301.2 v1(234.62,72.38)

## Copper pours and planes (outline as drawn)
1.5VSP on BOTTOM (solid shape): 96.04,97.74 96.05,97.72 96.05,97.62 96.15,97.62 96.18,97.6 96.76,97.6 96.93,97.43 96.93,95.75 96.9,95.67 96.83,95.64 96.47,95.29 96.83,94.93 96.9,94.9 96.93,94.83 96.93,94.46 96.72,94.26 95.33,94.26 94.59,93.52 93.22,93.52 93.12,93.62 93.12,94.18 93.5,94.56 93.5,95.8 94.06,96.36 94.68,96.98 94.68,96.98 95.33,97.62 95.82,97.62 95.82,97.7 95.86,97.74 95.86,98.14 96.04,98.14
1.35V_B+ on TOP (solid shape): 110.52,12.47 110.52,6.78 110.21,6.48 107.75,6.48 107.59,6.63 107.59,7.44 107.8,7.64 107.8,11.35 107.57,11.58 107.29,11.58 107.06,11.81 107.06,12.5 107.24,12.67 110.31,12.67
1.35V_B+ on BOTTOM (solid shape): 109.83,7.73 109.83,7.3 109.25,6.72 106.5,6.72 106.35,6.87 106.35,7.35 106.48,7.48 108.46,7.48 109.11,8.13 109.44,8.13
1.35V_B+ on IN1 (solid shape): outline of 502 points within 108.29,9.63 121.91,13.18
+0.9V_LAN on TOP (solid shape): 254.43,75.09 254.43,74.08 254.52,73.99 254.59,73.99 254.64,73.97 254.69,73.95 255.2,73.44 255.2,71.88 255.46,71.61 256.05,71.61 256.5,71.17 261.02,71.17 261.05,71.14 261.05,70.41 260.95,70.31 254.99,70.31 254.39,70.9 254.39,73.16 253.83,73.73 253.83,75.12 253.86,75.16 254.37,75.16
+0.9V_LAN on IN1 (solid shape): outline of 363 points within 248.51,72.47 256.88,82.78
+0.675V_DDR_VTT on TOP (solid shape): 199.82,26.83 199.82,19.34 199.7,19.21 199.7,16.8 199.57,16.67 199.12,16.67 198.68,17.12 198.68,19.51 198.5,19.68 198.5,22.53 198.68,22.71 198.68,26.77 198.81,26.9 199.76,26.9
+0.675V_DDR_VTT on TOP (solid shape): 112.37,6.02 112.4,6 112.42,5.97 112.42,5.49 112.85,5.49 112.85,5.97 112.87,6 112.91,6.02 113.23,6.02 113.31,5.94 113.31,4.52 113.18,4.39 111.84,4.39 111.73,4.5 111.73,5.92 111.84,6.02
+0.675V_DDR_VTT on TOP (solid shape): 123.01,26.59 123.01,24.28 123.19,24.1 123.19,16.59 123.04,16.43 122.35,16.43 121.67,17.12 118.86,17.12 117.97,16.23 117.97,15.66 117.84,15.53 116.83,15.53 116.7,15.66 116.7,16.59 116.84,16.73 116.84,17.2 118.29,18.64 120.17,18.64 122.07,20.55 122.07,26.64 122.28,26.85 122.76,26.85
+0.675V_DDR_VTT on BOTTOM (solid shape): 200.2,24.68 200.2,19.41 200.01,19.21 199.15,19.21 198.37,19.99 198.37,22.33 198.68,22.63 198.68,24.61 198.87,24.8 200.08,24.8
+0.675V_DDR_VTT on BOTTOM (solid shape): 123.28,26.43 123.28,20.57 123.6,20.25 123.6,16.74 123.37,16.51 122.83,16.51 122.61,16.74 122.61,18.64 121.72,19.53 121.72,23.6 122.3,24.18 122.3,26.9 122.38,26.97 122.73,26.97
+0.675V_DDR_VTT on BOTTOM (solid shape): outline of 363 points within 111.49,4.67 118.61,16.29
+0.675V_DDR_VTT on IN4 (solid shape): 123.33,24.09 123.33,23.87 123.77,23.43 123.77,22.05 123.77,22.04 123.75,21.85 123.77,21.66 123.77,21.65 123.77,18.95 123.52,18.69 122.05,18.69 121.72,19.02 121.72,23.57 122.66,24.51 122.92,24.51
+0.675V_DDR_VTT on IN4 (solid shape): 199.57,24.71 199.57,21.03 199.59,21 199.59,20.04 199.29,19.74 197.76,19.74 197.28,20.22 197.28,24.45 197.94,24.45 197.94,24.39 197.95,24.34 197.97,24.29 197.99,24.24 198.02,24.2 198.06,24.16 198.1,24.13 198.14,24.1 198.19,24.08 198.24,24.07 198.3,24.06 198.35,24.07 198.4,24.08 198.45,24.1 198.5,24.13 198.54,24.16 198.58,24.2 198.61,24.24 198.63,24.29 198.65,24.34 198.65,24.39 198.65,24.45 198.65,24.5 198.63,24.55 198.61,24.6 198.58,24.64 198.54,24.68 198.5,24.72 198.45,24.74 198.4,24.76 198.35,24.77 198.3,24.78 198.24,24.77 198.19,24.76 198.14,24.74 198.1,24.72 198.06,24.68 198.02,24.64 197.99,24.6 197.97,24.55 197.95,24.5 197.94,24.45 197.28,24.45 197.28,25.25 197.41,25.37 198.91,25.37
+0.675V_P on TOP (solid shape): 114.7,9.7 114.7,9.44 113.84,8.58 113.84,7.82 114.05,7.62 115.16,7.62 115.29,7.75 115.29,9.32 115.37,9.4 115.47,9.4 115.52,9.35 115.52,7.54 115.85,7.21 117.07,7.21 117.17,7.11 117.17,6.07 117.12,6.02 113.89,6.02 113.41,6.02 113.26,6.17 112.09,6.17 112.04,6.22 112.04,7.04 112.8,7.8 112.8,8.76 113.79,9.75 114.65,9.75
+1.2V_LDO on IN1 (solid shape): outline of 115 points within 256.08,16.58 265.93,25.44
+1.2V_LDO_AIN on TOP (solid shape): 261.68,24.13 261.68,23.66 260.46,22.44 260.17,22.44 260.06,22.55 260.06,23.37 260.95,24.26 261.56,24.26
+1.2V_LDO_AIN on TOP (solid shape): 260.83,17.22 260.83,15.67 261.14,15.37 261.14,14.71 261.07,14.64 260.59,14.64 260.07,15.16 260.07,17.25 260.13,17.31 260.74,17.31
+1.2V_LDO_AIN on IN2 (solid shape): outline of 155 points within 256.61,14.26 264.34,27.22
+1.05V_M on TOP (solid shape): 138.48,92.94 138.48,92.11 138.1,91.73 136.96,91.73 136.83,91.86 136.83,92.87 137.02,93.07 138.35,93.07
+1.05V_M on TOP (solid shape): 158.45,93.34 158.45,92.72 158.31,92.57 157.19,92.57 157.05,92.43 154.01,92.43 153.09,91.51 148.05,91.51 147.88,91.68 147.88,92.85 148.08,93.05 152.74,93.05 153.7,94 157.79,94
+1.05V_M on BOTTOM (solid shape): 156.76,95.21 158.87,95.21 159.06,95.03 159.06,93.11 159.39,92.77 159.39,89.78 158.99,89.38 156.65,89.38 156.49,89.54 156.49,91.47 155.94,92.02 155.94,94.92 156.2,95.18 156.25,95.2 156.28,95.22 156.75,95.22
+1.05V_M on BOTTOM (solid shape): 210.16,74.64 211.17,74.64 211.91,73.9 211.91,72.25 211.71,72.05 210.83,72.05 210.64,72.23 210.55,72.39 210.4,72.48 209.8,73.08 209.8,73.81 209.65,73.96 209.14,73.96 208.98,74.12 208.98,74.69 209.11,74.82 209.98,74.82
+1.05V_M on BOTTOM (solid shape): 227.95,85.32 227.95,82.14 227.83,82.02 224.16,82.02 223.34,81.2 223.34,79.11 223.29,79.02 223.19,79.02 222.66,78.71 223.19,78.41 223.29,78.41 223.34,78.32 223.34,77.98 222.26,76.89 222.26,74.04 222.05,73.84 220.24,73.84 219.91,74.17 219.91,78.6 219.96,78.8 219.91,78.99 219.91,79.6 221.53,81.22 221.84,81.22 223.28,82.66 223.28,82.96 225.38,85.06 225.38,85.27 225.68,85.57 227.7,85.57
+1.05V_M on IN2 (solid shape): outline of 3974 points within 131.88,67.22 144.58,92.9
+1.05V_M on IN4 (solid shape): outline of 166 points within 142.65,68.05 147.19,70.61
+1.05V_M on VCC: 219.74,84.94 215.55,89.13 189.18,89.13 188.55,89.76 183.46,89.76 182.83,89.13 181.39,89.13 181,89.51 167.33,89.51 166.95,89.13 158.14,89.13 157,90.27 156.11,90.27 155.22,91.16 146.5,91.16 145.61,90.27 142.57,90.27 141.93,89.64 135.16,89.64 134.8,90 134.8,95.22 150.02,95.22 150.65,95.86 155.52,95.86 156.79,94.59 164.03,94.59 165.88,92.73 180.97,92.73 181.3,93.07 182.66,93.07 183.16,93.57 187.52,93.57 188.03,93.07 193.87,93.07 194.64,92.3 226.23,92.3 228.91,89.63 228.91,85.68 228.16,84.94
+1.05V_M on VCC: 221.65,70.17 216.75,70.17 216.51,70.15 216.26,70.11 216.24,70.1 216.17,70.17 215.33,70.17 215.21,70.05 215.07,70.19 215.04,70.27 215.08,70.34 215.11,70.88 214.58,70.84 214.5,70.8 214.43,70.83 213.28,71.98 210.46,71.98 209.86,72.59 209.86,76.45 209.89,76.46 210.07,76.59 210.13,76.79 210.16,76.86 210.22,76.89 210.5,77.35 210,77.56 209.9,77.56 209.86,77.65 209.86,78.35 210.21,78.71 210.85,78.71 211.61,79.48 221.05,79.48 222.17,78.35 222.17,73.35 222.15,73.28 222.08,73.25 221.96,73.23 221.86,73.16 221.79,73.14 221.73,73.16 221.13,72.9 221.73,72.63 221.79,72.66 221.86,72.63 221.96,72.57 222.08,72.54 222.15,72.51 222.17,72.44 222.17,70.69
+1.05V_M_JTAG on IN4 (solid shape): outline of 203 points within 72.9,68.22 82.01,77.42
+1.05V_MODPHY on TOP (solid shape): outline of 85 points within 141.94,88.19 149.34,94.15
+1.05V_MODPHY on IN3 (solid shape): 154.51,85.14 154.51,83.74 154.33,83.57 150.52,83.57 149.89,84.2 149.89,85.09 150.44,85.65 154,85.65
+1.05V_MODPHY on IN3 (solid shape): 148.36,92.73 148.36,87.4 148.16,87.2 146,87.2 145.14,88.06 145.14,89.6 146.82,89.6 146.82,89.55 146.83,89.49 146.85,89.44 146.87,89.39 146.9,89.35 146.94,89.31 146.98,89.28 147.03,89.25 147.08,89.23 147.13,89.22 147.18,89.22 147.23,89.22 147.29,89.23 147.34,89.25 147.38,89.28 147.42,89.31 147.46,89.35 147.49,89.39 147.51,89.44 147.53,89.49 147.54,89.55 147.54,89.6 147.53,89.65 147.51,89.7 147.49,89.75 147.46,89.79 147.42,89.83 147.38,89.87 147.34,89.89 147.29,89.91 147.23,89.93 147.18,89.93 147.13,89.93 147.08,89.91 147.03,89.89 146.98,89.87 146.94,89.83 146.9,89.79 146.87,89.75 146.85,89.7 146.83,89.65 146.82,89.6 145.14,89.6 145.14,89.74 145.77,90.37 145.77,92.75 145.93,92.91 148.18,92.91
+1.05V_MODPHY on VCC: 158.14,69.57 155.12,72.6 155.12,78.44 151.56,81.99 151.56,84.58 151.79,84.81 152.81,84.81 153.19,85.19 155.77,85.19 156.13,84.83 156.13,82.8 158.93,80.01 158.93,74.04 159.46,73.51 181.13,73.51 188.5,80.87 192.1,80.87 193.87,79.1 196.92,79.1 197.16,78.86 197.16,75.26 196.8,74.9 193.58,74.9 191.29,77.19 189.3,77.19 181.68,69.57
+1.05V_MODPHY_PCH on TOP (solid shape): outline of 281 points within 144.89,75.73 149.71,88.04
+1.05V_MP on BOTTOM (solid shape): 227.46,81.2 227.46,77.93 225.48,75.95 225.48,73.02 225.07,72.62 222.83,72.62 222.68,72.77 222.68,72.78 222.47,73 222.47,76.78 223.49,77.8 223.49,79.34 223.51,79.38 223.55,79.4 224.03,79.4 224.03,79.9 223.55,79.9 223.51,79.91 223.49,79.95 223.49,80.14 223.51,80.18 223.55,80.2 224.03,80.2 224.03,80.7 223.55,80.7 223.51,80.71 223.49,80.75 223.49,81.08 224.13,81.71 226.95,81.71
+1.05V_RUN on TOP (solid shape): 136.68,92.87 136.68,91.73 137.18,91.23 137.18,90.95 137.54,90.59 137.54,89.71 137.51,89.68 136.89,89.68 135.72,90.85 135.72,91.6 136.28,91.6 136.28,92.1 135.72,92.1 135.72,92.89 135.85,93.03 136.52,93.03
+1.05V_RUN on BOTTOM (solid shape): 200.19,71.42 200.19,70.31 199.89,70.02 198.26,70.02 197.21,71.07 197.21,71.73 197.28,71.81 199.8,71.81
+1.05V_RUN on BOTTOM (solid shape): 109.74,90.29 109.74,89.55 109.91,89.39 109.91,88.68 109.78,88.56 108.38,88.56 108.26,88.68 108.26,90.4 108.32,90.46 109.57,90.46
+1.05V_RUN on BOTTOM (solid shape): 210.92,70.11 211.36,70.11 211.36,70.59 211.94,70.59 212.86,69.66 212.86,68.74 212.7,68.58 210.11,68.58 209.86,68.83 209.86,69.85 210.59,70.59 210.92,70.59
+1.05V_RUN on BOTTOM (solid shape): outline of 347 points within 185.51,71.32 192.08,79.03
+1.05V_RUN on VCC: 153.7,63.6 151.54,65.76 145.19,65.76 142.9,68.05 137.21,68.05 137.21,75.18 138.35,76.32 138.35,81.15 138.84,81.64 151.2,81.64 154.61,78.23 154.61,72.39 157.93,69.06 181.89,69.06 189.51,76.68 191.08,76.68 193.37,74.4 197.01,74.4 197.66,75.05 197.66,75.79 202.85,75.79 203.74,76.68 209.35,76.68 209.35,72.39 210.26,71.48 213.07,71.48 214.85,69.69 214.73,69.57 214.73,67.37 211.78,67.37 210.21,68.47 208.69,67.28 192.86,67.28 190.7,65.13 174.32,65.13 172.79,63.6
+1.05V_RUN_U43 on BOTTOM (solid shape): 209.97,72.44 209.97,72.27 210.12,71.83 210.58,71.92 212.52,71.92 213.06,71.38 213.06,70.9 212.95,70.79 211.93,70.79 211.88,70.84 209.78,70.84 209.78,70.89 209.48,70.89 209.1,71.26 209.1,71.92 209.02,72.01 209.02,72.71 209.09,72.78 209.63,72.78
+1.05V_RUN_VMM on BOTTOM (solid shape): 203.09,77.13 203.09,74.01 202.81,73.73 201.07,73.73 201.07,74.29 200.59,74.29 200.59,73.73 200.29,73.73 200.2,73.82 200.2,74.88 200.41,75.08 201.13,75.08 201.36,75 201.65,75.1 201.72,75.08 202.08,75.02 202.3,75.32 202.3,75.36 202.3,77.09 202.36,77.15 203.06,77.15
+1.05V_RUN_VMM_U31 on BOTTOM (solid shape): 200.24,73.57 201.36,73.57 201.41,73.51 201.41,72.58 201.3,72.47 199.78,72.47 199.17,73.08 197.26,73.08 197.19,73.15 197.19,73.9 197.52,74.23 199.58,74.23
+1.5V_THERMAL on BOTTOM (solid shape): 97.02,98.83 97.02,97.83 96.95,97.76 96.19,97.76 96.16,97.79 96.16,98.25 96.15,98.26 96.15,98.29 95.72,98.29 95.72,97.77 95.71,97.76 95.43,97.76 95.36,97.83 95.36,98.57 95.37,98.59 95.38,98.6 95.76,98.98 95.83,98.98 95.83,98.98 96.86,98.98
+1.05V_VCCST on TOP (solid shape): 135.56,92.37 135.56,89.69 135.47,89.6 134.81,89.6 134.72,89.69 134.72,92.28 134.86,92.42 135.51,92.42
+1.05V_VMM_VDD on BOTTOM (solid shape): outline of 423 points within 192.82,76.03 201.93,84.35
+1.05V_VMM_VDD on IN1 (solid shape): outline of 580 points within 191.82,78.41 199.38,84.11
+1.05V_VMM_VDD on IN3 (solid shape): outline of 759 points within 191.79,78.23 199.12,84.13
+1.05V_VMM_VDDTX on BOTTOM (solid shape): outline of 92 points within 202.43,73.82 205.03,82.51
+1.05V_VMM_VDDTX on IN2 (solid shape): outline of 1544 points within 191.85,78.37 204.15,85.66
+1.8V_RUN_CARD on TOP (solid shape): 276.49,5.28 276.49,4.9 276.3,4.71 274.51,4.71 274.32,4.9 274.32,6.6 274.42,6.71 275.07,6.71
+1.8V_RUN_CARD on TOP (solid shape): 255.39,17.77 255.39,17.54 254.67,16.81 253.94,16.81 253.37,16.24 252.88,16.24 252.87,16.23 252.35,16.23 252.02,15.9 252.02,15.53 251.91,15.42 251.35,15.42 251.23,15.54 251.23,17.27 251.33,17.37 252.43,17.37 252.58,17.53 254.23,17.53 254.54,17.84 255.32,17.84
+1.8V_RUN_CARD on BOTTOM (solid shape): 276.59,5.36 276.59,3.93 276.59,3.92 276.44,3.58 276.33,3.24 276.32,3.22 276.29,3.19 275.6,3.19 275.4,3.39 275.4,5.5 275.54,5.64 276.31,5.64
+1.8V_RUN_CARD on IN3 (solid shape): 254.23,15.9 254.23,14.88 254,14.66 253.06,14.66 252.25,15.47 252.25,16.66 252.4,16.81 253.31,16.81
+1.8V_RUN_CARD on IN3 (solid shape): 276.61,5.14 276.61,4.17 276.23,3.79 274.71,3.79 274.54,3.96 274.54,5.17 274.73,5.36 276.39,5.36
+1.35V_MEM on TOP (solid shape): outline of 15468 points within 80.12,13.31 176.84,69.6
+1.35V_MEN_P on TOP (solid shape): 111.52,8.91 111.55,8.9 111.57,8.86 111.57,8.38 112,8.38 112,8.86 112.02,8.9 112.05,8.91 112.32,8.91 112.37,8.86 112.37,7.64 112.24,7.52 111.05,7.52 110.97,7.59 110.97,8.79 111.1,8.91
+1.35V_MEN_P on TOP (solid shape): 89.68,13.13 89.71,13.12 89.73,13.08 89.73,12.63 90.43,12.63 90.43,13.08 90.45,13.12 90.48,13.13 90.88,13.13 90.91,13.12 90.93,13.08 90.93,12.63 91.63,12.63 91.63,13.08 91.65,13.12 91.68,13.13 94.95,13.13 94.98,13.12 95,13.08 95,12.63 95.7,12.63 95.7,13.08 95.72,13.12 95.75,13.13 96.15,13.13 96.18,13.12 96.2,13.08 96.2,12.63 96.9,12.63 96.9,13.08 96.92,13.12 96.95,13.13 97.69,13.13 97.79,13.03 97.79,10.11 97.51,9.83 89.18,9.83 88.85,10.16 88.85,13.03 88.95,13.13
+1.35V_MEN_P on BOTTOM (solid shape): 101.63,14.88 101.63,9.93 101.45,9.75 90.03,9.75 89.78,10.01 89.78,14.76 90.03,15.01 101.5,15.01
+3.3V_ALW on TOP (solid shape): 16.59,20.96 16.59,18.2 16.51,18.12 15.75,18.12 15.52,18.35 15.52,20.98 15.72,21.18 16.37,21.18
+3.3V_ALW on TOP (solid shape): 202.47,25.21 202.47,23.8 202.33,23.66 201.3,23.66 201.17,23.78 201.17,25.11 201.32,25.26 202.42,25.26
+3.3V_ALW on TOP (solid shape): 199.16,37.34 200.56,37.34 200.63,37.26 200.63,36.45 200.46,36.27 198.76,36.27 198.65,36.37 198.65,37.26 198.76,37.36 199.14,37.36
+3.3V_ALW on TOP (solid shape): 205.04,24.67 205.04,23.82 204.89,23.68 204.15,23.68 203.92,23.91 203.92,24.47 203.83,24.57 203.83,25.23 203.89,25.29 204.42,25.29
+3.3V_ALW on TOP (solid shape): 267.34,18.01 267.34,16.05 267.26,15.98 266.7,15.98 266.4,16.28 266.4,18.03 266.45,18.08 266.46,18.08 267.26,18.08
+3.3V_ALW on TOP (solid shape): 200.63,39.37 200.63,38.76 200.58,38.71 198.87,38.71 198.61,38.97 198.61,39.78 198.8,39.98 200.03,39.98
+3.3V_ALW on TOP (solid shape): 10.24,7.78 10.24,6.26 9.81,5.83 6.85,5.83 6.53,6.15 6.53,6.82 6.1,7.25 5.6,7.25 5.54,7.31 5.54,7.8 5.61,7.87 10.15,7.87
+3.3V_ALW on TOP (solid shape): 194.68,32.04 194.68,31.41 194.55,31.28 194.04,31.28 193.85,31.47 193.15,31.47 193.09,31.53 193.09,32.17 193.15,32.23 194.04,32.23 194.11,32.3 194.42,32.3
+3.3V_ALW on TOP (solid shape): 193.92,35.34 193.92,33.69 193.79,33.57 193.15,33.57 193.09,33.63 193.09,34.14 192.85,34.38 192.58,34.38 192.46,34.51 192.46,35.66 192.52,35.72 193.54,35.72
+3.3V_ALW on TOP (solid shape): 50.99,72.76 50.99,72.34 50.48,71.83 50.48,68.66 53.72,65.42 53.72,64.71 52.87,63.86 52.1,63.86 48.69,67.27 48.69,71.5 50.05,72.87 50.88,72.87
+3.3V_ALW on TOP (solid shape): 202.74,8.61 202.74,7.15 202.62,7.02 202.62,5.82 202.62,5.54 202.55,5.47 202.31,5.47 202.24,5.55 202.24,6.9 201.38,7.75 200.63,7.75 200.51,7.87 200.51,8.5 200.69,8.67 202.68,8.67
+3.3V_ALW on TOP (solid shape): 42.24,11.12 42.24,10.71 41.76,10.22 41.76,9.59 41.75,9.56 41.74,9.54 41.64,9.44 41.59,9.3 41.58,9.28 41.55,9.26 41.04,9.26 40.9,9.4 40.9,11.03 41.12,11.25 42.11,11.25
+3.3V_ALW on TOP (solid shape): 59.5,19.21 59.75,19.12 59.99,19.21 61.58,19.21 61.87,18.92 61.87,18.12 61.56,17.8 57.21,17.8 56.97,17.56 55.91,17.56 55.49,17.98 55.49,18.94 55.76,19.21
+3.3V_ALW on TOP (solid shape): 10.77,12.79 10.77,11.78 9.93,10.94 9.44,10.94 9.23,11.15 9.23,12.72 9.5,12.99 9.78,12.99 9.78,12.62 9.78,12.48 9.81,12.45 9.96,12.45 10.16,12.45 10.17,12.45 10.23,12.45 10.26,12.48 10.26,12.54 10.26,12.55 10.26,13 10.56,13
+3.3V_ALW on TOP (solid shape): 11.23,39.83 11.23,38.91 11.3,38.84 11.99,38.84 12.05,38.78 12.05,36.98 11.83,36.77 11.05,36.77 10.92,36.64 10.92,36.14 11.27,35.8 11.27,34.76 11.13,34.62 10.62,34.62 10.45,34.78 10.45,36.41 10.26,36.6 9.82,36.6 9.7,36.72 9.7,38.16 9.77,38.23 10.25,38.23 10.41,38.39 10.41,39.75 10.59,39.93 11.13,39.93
+3.3V_ALW on TOP (solid shape): outline of 113 points within 32.55,22.9 36.93,28.65
+3.3V_ALW on TOP (solid shape): outline of 187 points within 188.87,63.35 196.08,67.03
+3.3V_ALW on BOTTOM (solid shape): 207.62,74.73 207.62,74.08 207.57,74.02 207.09,74.02 206.89,73.82 206.89,73.61 206.67,73.4 205.84,73.4 205.75,73.49 205.75,74.18 206.43,74.86 207.5,74.86
+3.3V_ALW on BOTTOM (solid shape): 102.01,98.98 102.02,98.96 102.03,98.94 102.03,97.8 101.92,97.69 101.77,97.69 101.77,97.69 101.41,97.69 101.4,97.69 101.37,97.71 101.37,98.21 101.36,98.22 101.36,98.25 100.93,98.25 100.93,98.22 100.91,98.2 100.91,97.7 100.9,97.69 100.52,97.69 100.52,97.68 100.28,97.68 100.2,97.75 100.2,99.11 100.41,99.32 101.68,99.32
+3.3V_ALW on BOTTOM (solid shape): 266.42,43.65 266.42,41.94 266.29,41.67 266.42,41.4 266.42,41.22 266.23,40.91 266.42,40.59 266.42,38.07 266.85,37.64 266.85,37.21 266.81,37.21 266.5,36.85 266.81,36.5 266.85,36.5 266.85,35.61 266.42,35.18 266.42,33.43 265.38,32.38 264.74,32.38 264.72,32.41 264.72,33.02 265.23,33.53 265.23,43.49 265.52,43.78 266.29,43.78
+3.3V_ALW on BOTTOM (solid shape): outline of 316 points within 262.51,15.95 267.36,27.33
+3.3V_ALW on BOTTOM (solid shape): outline of 94 points within 235.74,70.18 266.24,72.39
+3.3V_ALW on BOTTOM (solid shape): outline of 870 points within 120,3.84 133.59,12.99
+3.3V_ALW on IN1 (solid shape): outline of 665 points within 199.63,6.88 204.98,25.44
+3.3V_ALW on IN2 (solid shape): 238.35,72.21 238.35,70.66 237.9,70.21 236.04,70.21 235.89,70.36 235.89,71.35 236.86,72.31 238.25,72.31
+3.3V_ALW on IN2 (solid shape): 186.13,82.53 186.48,82.23 186.84,82.53 186.84,82.57 187.81,82.57 188.8,81.58 188.8,79.43 188.29,78.92 187.73,78.92 187.73,79.24 186.83,80.14 186.83,80.16 186.8,80.34 186.68,80.47 186.65,80.49 186.62,80.51 186.59,80.57 186.61,80.64 186.67,80.86 186.58,81.06 186.56,81.13 186.58,81.19 186.31,81.78 186.04,81.19 186.06,81.13 186.04,81.06 186.01,81.02 185.97,80.92 185.96,80.81 185.89,80.72 185.78,80.74 185.65,80.87 185.65,82.32 185.9,82.57 186.13,82.57
+3.3V_ALW on IN2 (solid shape): outline of 572 points within 207.26,65.3 222.15,72.59
+3.3V_ALW on IN3 (solid shape): 207.05,74.24 207.05,73.57 206.21,72.74 205.16,72.74 204.88,73.02 204.88,73.69 205.13,73.95 205.64,73.95 206.13,74.44 206.84,74.44
+3.3V_ALW on IN3 (solid shape): 203.75,67.46 203.75,65.37 203.58,65.2 203.08,65.2 202.95,65.32 202.95,66.84 202.63,67.17 202.63,67.41 202.92,67.7 203.51,67.7
+3.3V_ALW on VCC (solid shape): outline of 46177 points within 1.02,2.96 208.73,66.78
+3.3V_ALW2 on TOP (solid shape): 142.16,10.52 142.16,10.39 142.86,9.69 143.8,9.69 143.81,9.68 144.27,9.68 144.32,9.63 144.32,9.05 144.1,8.83 142.77,8.83 141.97,9.63 141.58,9.63 141.28,9.93 141.28,10.64 141.45,10.82 141.86,10.82
+3.3V_ALW2 on TOP (solid shape): 139.5,7.28 140.7,7.28 140.96,7.02 140.96,6.39 140.39,5.82 139.29,5.82 139.22,5.85 139.19,5.93 138.99,6.29 138.58,6.21 138.56,6.2 138.54,6.2 137.85,6.2 137.78,6.26 137.78,6.71 138.48,7.4 138.48,7.59 138.54,7.66 139.12,7.66
+3.3V_ALW_PCH on TOP (solid shape): 160.79,70.88 160.79,68.9 160.24,68.34 160.24,67.3 160.14,67.2 159.7,67.2 159.63,67.27 159.63,67.86 159.45,68.03 158.88,68.03 158.75,68.17 158.75,69.74 160.01,70.99 160.68,70.99
+3.3V_ALW_PCH on TOP (solid shape): 40.7,47.59 41.2,46.9 41.2,46.82 40.69,46.32 40.56,46.2 40.4,46.2 40.38,46.21 40.36,46.23 39.94,46.94 39.94,46.96 39.94,46.99 39.99,47.09 40.63,47.6 40.68,47.6
+3.3V_ALW_PCH on TOP (solid shape): 152.86,56.11 152.86,54.84 152.5,54.48 152.03,54.48 151.36,55.14 150.74,55.14 150.62,55.13 150.51,55.08 149.53,55.08 149.52,55.08 148.98,55.08 148.59,55.47 148.59,56.16 148.69,56.26 152.71,56.26
