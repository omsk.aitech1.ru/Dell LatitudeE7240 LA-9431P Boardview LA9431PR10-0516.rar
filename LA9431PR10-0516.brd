# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_JTAG_JTAGX: length 70
  IN1 w0.084: v2(68.16,69.32) 68.16,71.76 69.71,73.31 69.71,75.51 72.34,78.14 88.32,78.14 89.16,77.29 91.18,77.29 94.6,73.87 94.6,72.24 95.22,71.61 107.45,71.61 109.11,69.95 109.88,69.95 v2(109.98,69.85)
  BOTTOM w0.076: v2(109.98,69.85) 109.98,69.48 110.87,68.59 111.49,68.59 111.6,68.7 112.46,68.7 UC1.AE63
  BOTTOM w0.102: v2(68.16,69.32) 69.05,68.43 73.15,68.43 v1(74.39,67.19) 74.45,67.13 76.32,67.13 78.23,69.05 RC10.1 78.23,70.24 RC97.2 RC123.2
PCH_JTAG_TCK: length 53.6
  TOP w0.102: RC142.1 72.76,66.01 v5(73.27,65.51) 73.9,65.51 v2(74.22,65.83)
  IN1 w0.084: v2(107.51,68.38) 94.79,68.38 94.28,68.89 87.66,68.89 86.78,69.77 77.68,69.77 75.87,67.96 75.87,67.48 v2(74.22,65.83)
  BOTTOM w0.076: UC1.AE62 112.95,68.54 111.67,68.54 111.56,68.43 109.91,68.43
  BOTTOM w0.102: 109.91,68.43 108.69,68.43 RC22.1 107.51,68.21 v2(107.51,68.38) ; v2(74.22,65.83) 74.98,66.59 76.22,66.59 79.17,69.53 RC124.2
PCH_JTAG_TCK_R: length 4.8
  TOP w0.102: RC142.2 v1(68.75,65.06) 68.75,63.97 68.44,63.66 68.44,63.41 68.16,63.13 JXDP1.55
PCH_JTAG_TDI: length 80.3
  TOP w0.102: v2(82.04,74.02) 81.48,74.57 v5(81.48,76.71) 81.48,77.51 80.59,78.41 RC17.1 80.26,78.66 80.51,78.9 80.51,79.13 80.21,79.43 78.71,79.43 78.24,79.9 77.13,79.9 75.29,78.05 70.65,78.05 63.26,70.67 63.26,65.44 62.31,64.49 58.51,64.49 RC96.1
  IN4 w0.084: v2(82.04,74.02) 85.75,74.02 85.93,73.84 87.82,73.84 89.71,75.73 90.82,75.73 91.78,76.69 106.05,76.69 108.31,74.44 v2(108.31,69.06)
  BOTTOM w0.076: 109.91,70.23 110.1,70.23 110.15,70.18 110.25,70.18 110.53,69.9 110.82,69.9 111.69,69.04 112.14,69.04 112.46,69.35 112.77,69.35 112.94,69.52 112.94,69.69 113.18,69.93 113.69,69.93 UC1.AD61
  BOTTOM w0.102: 109.91,70.23 109.6,70.23 109.42,70.05 109.42,69.72 108.76,69.06 v2(108.31,69.06)
PCH_JTAG_TDO: length 46.9
  TOP w0.102: v2(75.37,67.77) v5(75.37,68.36)
  IN1 w0.084: v2(113.65,69.26) 113.44,69.06 111.35,69.06 111.02,68.73 110.25,68.73 109.94,69.04 109.44,69.04 109.4,69.07 109.09,69.07 107.2,70.97 87.5,70.97 87.43,70.89 83.68,70.89 82.21,72.36 79.53,72.36 79.34,72.17 79.34,71.73 v2(75.37,67.77)
  BOTTOM w0.076: v2(113.65,69.26) 113.68,69.23 113.95,68.96 UC1.AE61
  BOTTOM w0.102: RC95.1 RC104.2 75.41,70.26 75.37,70.22 RC18.1 v2(75.37,67.77)
PCH_JTAG_TMS: length 41.8
  TOP w0.102: v2(80.04,79.02) 79.43,78.41 RC20.1 RC101.1 78.35,79.03 v5(77.86,79.51)
  IN1 w0.084: v2(80.04,79.02) 80.09,78.97 80.09,78.97 80.71,78.35 88.4,78.35 89.25,77.5 91.27,77.5 94.75,74.02 105.98,74.02 107.12,72.88 107.67,72.88 107.96,72.58 107.96,71.4 109.13,70.23 110.13,70.23 110.63,69.74 v2(110.63,69.53)
  BOTTOM w0.076: UC1.AD62 112.85,69.19 112.85,69.19 112.84,69.18 112.52,69.18 112.21,68.87 111.29,68.87 v2(110.63,69.53)
PCH_JTAG_TRST#: length 84.5
  TOP w0.102: v2(63.49,63.79) 63.72,64.02 63.72,70.48 69.59,76.35 v5(70.02,76.35) 71.23,77.57 76.1,77.57 76.94,78.41 RC135.2
  BOTTOM w0.076: UC1.AU62 113.2,62.15 112.83,62.52 112.51,62.52 111.2,61.21 111.2,60.45 110.64,59.89 109.91,59.89
  BOTTOM w0.102: v2(63.49,63.79) 67.81,63.79 70.09,61.51 70.09,60.8 71.06,59.83 71.58,59.83 72.06,59.35 72.06,55.28 73.05,54.29 101.36,54.29 107.21,60.15 107.62,60.15 107.87,59.89 109.91,59.89
PCH_NFC_RST: length 230.6
  TOP w0.102: U29.2 v2(251.03,12.67)
  IN4 w0.084: v2(251.03,12.67) 251.27,12.92 251.27,13.52 251.96,14.21 251.96,21 253.54,22.58 261.99,22.58 263.51,24.1 265.99,24.1 266.62,24.74 266.62,25.88 268.12,27.38 272.67,27.38 274.08,25.97 276.28,25.97 276.67,26.36 276.67,29.87 271.62,34.92 271.62,39.9 271.06,40.46 271.06,52.24 267.87,55.43 267.87,70.91 265.33,73.45 265.33,73.91 264.94,74.3 263.01,74.3 262.61,73.9 256.8,73.9 255.08,75.62 245.19,75.62 243.85,76.96 241.07,76.96 240.36,77.67 239.94,77.67 236.17,81.43 233.87,81.43 232.5,82.8 218.43,82.8 216.67,81.03 215.38,81.03 211,76.66 208.91,76.66 206.82,74.57 206.16,74.57 205.47,73.88 204.93,73.88 203.17,72.12 198.28,72.12 197.72,71.55 197.72,71.13 198.02,70.83 198.02,70.17 197.51,69.66 194.72,69.66 194.59,69.79 190.48,69.79 189.77,70.5 180.73,70.5 179.67,69.44 178.83,69.44 177.77,68.39 177.77,67.8 177.39,67.42 173.03,67.42 172.22,68.22 172.22,72.5 171.88,72.83 170.22,72.83 169.74,72.36 164.74,72.36 164.43,72.04 160.88,72.04 160.46,71.63 159.13,71.63 158.83,71.93 152.1,71.93 151.41,71.25 151.41,70.38 150.94,69.91 147.89,69.91 v2(147.52,70.29)
  BOTTOM w0.076: UC1.AD7 147.34,70.11 v2(147.52,70.29)
PCH_OPI_COMP: length 4.8
  BOTTOM w0.076: UC1.AW15 142.65,60.83 143.05,60.43 143.05,58.99 143.56,58.49 143.56,58.36
  BOTTOM w0.305: 143.56,58.36 v1(143.96,57.96) 144.32,57.59 144.32,56.88 RC168.1
PCH_PCIE_IREF: length 6.3
  BOTTOM w0.203: UC1.B27 135.16,82.43 135.16,82.58 134.99,82.76 134.99,83.6
  BOTTOM w0.305: RC163.2 133.21,87.34 v1(133.21,86.39) 133.65,85.95 133.66,85.95 134.93,84.68 134.93,83.92 134.99,83.86 134.99,83.6
PCH_PCIE_RCOMP: length 4
  BOTTOM w0.203: UC1.A27 135.43,84.3
  BOTTOM w0.305: RC161.2 134.35,85.94 v1(134.94,85.36) 135.43,84.86 135.43,84.3
PCH_PCIE_WAKE#: length 183.5
  TOP w0.102: v2(165.94,67.04) 166.26,67.04 RC71.2 ; U38.A44 22.94,20.39 22.47,20.87 22.47,20.89 21.92,21.44 21.92,21.73 21.77,21.88 21.77,24.49 22.21,24.93 v1(24.74,24.93) 25.39,25.58 25.39,28.3 25.59,28.49 v2(25.58,28.49)
  IN2 w0.089: v2(148.11,67.44) 147.75,67.08 147.61,67.08 147.21,66.67 147.21,66.36 147.41,66.16 147.41,62.42 146.97,61.98 146.97,58.56 147.47,58.06 147.47,56.79 147.23,56.55 147.23,53.45 146,52.22 146,51.41
  IN2 w0.122: v2(25.58,28.49) 25.58,28.79 27.16,30.38 27.67,30.38 28.4,31.1 28.4,33.01 30.53,35.14 34.87,35.14 35.01,35.28 38.74,35.28 39.97,36.51 42.86,36.51 44.56,38.21 45.32,38.21 51.33,44.22 55.15,44.22 56.06,45.14 61.7,45.14 62.13,45.56 66.88,45.56 67.31,45.14 116.4,45.14 117.4,46.14 142.2,46.14 146,49.94 146,51.41
  IN4 w0.084: v2(148.11,67.44) 148.58,66.96 150.49,66.96 150.87,66.58 152.79,66.58 153,66.79 153.75,66.79 153.85,66.69 156.09,66.69 156.5,66.28 162.53,66.28 163.71,67.45 165.53,67.45 v2(165.94,67.04)
  BOTTOM w0.076: UC1.AJ5 148.56,66.95 148.11,67.41 v2(148.11,67.44)
PCH_PLTRST#: length 44.9
  TOP w0.102: RC300.2 173.96,58.08 UC3.1 ; RC300.2 RC90.2 ; RC300.2 RC89.2 ; v2(169.42,68.55) 170.23,67.74 170.23,67.29 v1(171.41,66.11) 171.54,65.98 173.54,65.98 175.57,63.95 175.57,61.43 174.66,60.53 RC92.2 RC91.2 RC90.2 ; RC90.2 174.23,58.73 UC3.2
  IN4 w0.084: v2(147.51,68.36) 147.51,68.37 148.07,68.93 149.34,68.93 149.53,68.73 150.35,68.73 150.67,69.06 150.67,69.39 152.1,70.81 152.88,70.81 153.1,71.03 162.01,71.03 162.28,71.3 162.86,71.3 163.67,70.49 165.83,70.49 166.42,69.9 168.99,69.9 169.42,69.47 v2(169.42,68.55)
  BOTTOM w0.076: v2(147.51,68.36) 147.51,68.36 147.51,68.08 UC1.AG7
PCH_PLTRST#_EC: length 320.4
  TOP w0.102: U38.B30 28.98,16.58 v2(28.6,16.2) ; v2(179.5,57.04) v1(179.5,55.85) 179.69,55.66 179.69,49.16 187.54,41.31 R131.1 190.82,41.81 U30.1 ; RC109.1 57.63,61.06 57.25,61.44 v2(56.97,61.44) ; U37.B22 23.89,32.52 23.41,32.04 23.1,32.04 v2(23.11,32.05) ; UC3.4 171.82,59.38 172.16,59.04 172.16,57.49 v2(172.14,57.47) ; v2(42.34,35.34) 42.81,35.34 43.12,35.66 U25.16
  IN1 w0.084: v2(42.34,35.34) 45.24,35.34 46.27,34.32 46.27,32.41 45.04,31.18 45.04,29.68 44.16,28.79 v2(44.16,24.64) 43.96,24.44 42.09,24.44 41.56,23.91 41.56,22.59 40.5,21.54 40.5,17.65 37.39,14.54 34.7,14.54 33.76,15.48 32.19,15.48 31.92,15.21 30.53,15.21 29.55,16.2 v2(28.6,16.2) ; v2(179.5,57.04) 174.94,57.04 174.51,57.47 v2(172.14,57.47)
  IN2 w0.122: v2(44.16,24.64) 44.51,24.29 44.91,24.29 46.83,26.2 49.85,26.2 50.7,27.05 51.33,27.05 54.23,29.95 57.39,29.95 57.74,30.3 64.92,30.3 66,31.38 97.36,31.38 97.59,31.15 118.89,31.15 122.36,27.68 123.73,27.68 124.61,26.8 126.77,26.8 127.62,27.65 129.08,27.65 129.52,27.21 130.69,27.21 132.17,28.69 135.85,28.69 137.88,30.72 160.64,30.72 171.76,41.83 171.76,52.12 172.76,53.13 172.76,55.76 172.14,56.39 v2(172.14,57.47) ; v2(56.97,61.44) 55.69,60.16 55.69,56.95 57.48,55.16 57.48,48.62 56.8,47.94 54.9,47.94 54.19,47.23 42.25,47.23 38.14,43.12 35.42,43.12 31.69,39.39 26.64,39.39 25.53,38.29 25.53,33.98 24.16,32.61 23.98,32.61 23.41,32.04 23.1,32.04 v2(23.11,32.05)
  IN4 w0.084: v2(42.34,35.34) 42.15,35.53 40.63,35.53 40.23,35.14 40.23,31.98 39.7,31.44 35.81,31.44 34.76,32.49 28.46,32.49 27.99,32.03 27.34,32.03 26.45,31.14 25.59,31.14 24.18,32.55 23.67,32.55 23.17,32.05 v2(23.11,32.05)
  BOTTOM w0.102: JMINI3.17 47.12,22.25 45.83,23.53 45.83,23.54 44.73,24.64 v2(44.16,24.64)
PCH_PWROK: length 22.9
  BOTTOM w0.076: UC1.AY7 147.1,60.14 147.1,58.74 147.51,58.33 147.51,57.48 149.39,55.6 v5(149.97,55.6) 150.43,55.6 150.52,55.69 150.93,55.69 151.31,55.31 151.31,54.46 152.71,53.06 153.85,53.06
  BOTTOM w0.102: 153.85,53.06 154.56,53.06 155.17,53.67 157.71,53.67 158.04,53.34 159.59,53.34 159.87,53.62 161.84,53.62 163.75,55.54 RC88.2
PCH_RSMRST#: length 33.7
  TOP w0.102: R377.2 v2(38.34,21.65) 37.9,21.21 37.9,20.62 v1(41.5,17.02) 41.58,16.94 41.81,16.94 42.62,16.13 42.62,14.83 41.66,13.87 R414.1 41.34,13.57 U42.1 ; v2(21.93,17.4) 22.4,17.4 22.76,17.75 22.76,18.14 22.69,18.2 U38.B47
  IN2 w0.122: v2(38.34,21.65) 38.32,21.65 37.88,21.21 34.93,21.21 34.34,20.62 29.68,20.62 28.89,19.84 23.72,19.84 22.68,18.8 22.68,17.72 22.36,17.4 v2(21.93,17.4)
PCH_RSMRST#_Q: length 161.8
  TOP w0.102: R414.2 42.14,15.28 42.14,15.93 41.71,16.36 v2(41.48,16.36) ; R413.2 39.72,8.72 39.28,9.16 39.28,11.35 v1(38.74,11.9) v2(38.74,12.6)
  IN1 w0.084: v2(38.74,12.6) 40.03,13.89 40.03,14.91 v2(41.48,16.36) 42.47,17.35 42.47,21.74 42.65,21.93 42.65,23.09 42.9,23.34 44.68,23.34 45.44,24.1 45.44,25.53 47.09,27.18 47.09,27.61 v2(46.81,27.89)
  IN2 w0.122: v2(46.81,27.89) 47.37,27.89 47.61,28.13 48.27,28.13 53.36,33.21 53.36,33.73 53.68,34.05 55.58,34.05 56.29,33.34 61.52,33.34 63.01,34.83 148.71,34.83 161.66,47.78 161.66,57.64 161.84,57.81 v2(162.09,57.81)
  BOTTOM w0.102: RC93.1 162.09,58.18 v2(162.09,57.81)
PCH_RSMRST#_R: length 24.1
  BOTTOM w0.076: 147.45,58.88 147.45,59.82 147.61,59.98 147.61,60.54 147.84,60.78 UC1.AW6
  BOTTOM w0.102: RC136.2 162.93,58.98 161.98,58.98 RC93.2 161.52,57.81 v1(161.24,57.53) 160.9,57.19 RC79.2 161.37,55.99 161.37,54.99 161.01,54.63 152.92,54.63 151.38,56.17 150.16,56.17 147.45,58.88
PCH_RTCRST#: length 150.4
  TOP w0.102: JAPS1.9 37.4,43.81 37.54,43.66 39.3,43.66 42.78,47.15 46.49,47.15 47.7,48.36 49.53,48.36 50.29,49.12 54.4,49.12 v2(54.55,48.97) 54.55,45.63 v5(54.29,45.36) 54.29,44.26 v2(54.82,43.72)
  IN2 w0.089: v2(147.52,61.75) 148.19,61.08 148.19,58.15 148.67,57.67 148.67,54.02 147.56,52.91 147.56,51.41
  IN2 w0.122: 147.56,51.41 147.56,48.94 143.25,44.63 118.23,44.63 117.23,43.63 54.91,43.63 v2(54.82,43.72)
  BOTTOM w0.076: v2(147.52,61.75) 147.52,61.75 147.14,62.14 UC1.AU7
  BOTTOM w0.102: 56.81,59.28 RC6.2 55.87,58.44 51.92,54.5 51.92,52.72 53.76,50.88 CMOS1.2 54.74,50.22 54.35,49.83 54.35,49.17 v2(54.55,48.97)
PCH_RTCX1: length 8.5
  BOTTOM w0.076: UC1.AW5 149.02,60.47 149.02,59.48
  BOTTOM w0.102: 152.04,57.41 150.34,59.11 149.39,59.11 149.02,59.48
  BOTTOM w0.203: 152.04,57.41 v1(152.22,57.23) 152.9,56.55 RC5.1 154.08,57.43 RC4.2
PCH_RTCX1_R: length 6.3
  BOTTOM w0.203: YC1.1 159.67,56.51 158.67,57.51 156.96,57.51 v1(156.65,57.81) 156.6,57.81 156.29,58.13 156.17,58.13 155.96,58.34 CC1.2 RC4.1
PCH_RTCX2: length 12.4
  BOTTOM w0.102: UC1.AY5 148.69,59.43 149.2,58.92 150.15,58.92 150.36,58.71 150.36,57.31 v1(150.59,57.08) 150.8,56.87 151.5,56.87 152.45,55.92 153.48,55.92
  BOTTOM w0.203: 153.48,55.92 RC5.2 155.02,55.65 CC2.2 155.31,55.65 155.86,56.2 YC1.2
PCH_SATA_MOD_EN#: length 5.6
  TOP w0.102: T123.1 31.27,20.94 v2(31.27,19.94) ; v2(28.21,18.52) 28.21,18.51 28.19,18.53 U38.B36
  IN4 w0.084: v2(28.21,18.52) 29.25,18.52 29.76,19.03 29.76,19.4 30.3,19.94 v2(31.27,19.94)
PCH_SMB_ALERT#: length 10.9
  BOTTOM w0.076: UC1.AN2 151.08,64.81 151.46,64.81 151.59,64.68 152.55,64.68 152.94,64.29 153.66,64.29 153.85,64.1
  BOTTOM w0.102: 153.85,64.1 153.85,64.1 154.3,64.1 154.5,64.29 154.5,64.53 155.84,65.88 155.84,66.03 v1(156.05,66.23) 156.41,66.6 156.45,66.6 156.7,66.84 156.7,67.27 156.95,67.53 157.58,67.53 158.23,66.88 RP5.6
PCH_SPI_CLK: length 46.4
  IN2 w0.122: v2(178.42,77.51) 179.95,75.98 179.95,73.25 179.73,73.04 179.73,70.92 v2(179.29,70.47)
  IN4 w0.084: v2(150.27,70.72) 150.27,71.1 151.87,72.69 153.16,72.69 153.7,73.23 155.09,73.23 155.5,73.63 158.39,73.63 159.18,72.85 163.8,72.85 164.45,73.49 164.84,73.49 165.17,73.16 167.49,73.16 167.76,73.43 172.26,73.43 172.83,72.86 172.83,70.29 173.08,70.05 176.82,70.05 177.24,70.47 v2(179.29,70.47)
  BOTTOM w0.076: v2(150.27,70.72) 149.97,71.02 UC1.AA3
  BOTTOM w0.102: R13.1 R18.1 R7.2 R20.2 178.6,77.33 v2(178.42,77.51)
PCH_SPI_CS0#: length 38.8
  IN2 w0.122: v2(164.87,83.91) 162.92,81.96 162.92,81.18 165.32,78.78 165.32,76.9 165.07,76.65 165.07,74.38 v2(164.9,74.21)
  IN4 w0.084: v2(147.52,72.19) 147.54,72.19 147.92,71.82 150.41,71.82 152.27,73.68 153.72,73.68 154.33,74.29 159.03,74.29 159.5,73.82 161.21,73.82 161.37,73.67 163.86,73.67 164.15,73.96 164.66,73.96 v2(164.9,74.21)
  BOTTOM w0.076: UC1.Y7 147.52,71.89 v2(147.52,72.19)
  BOTTOM w0.102: v2(164.87,83.91) 166.23,83.91 166.99,83.15 v5(168.24,83.15) 169.05,82.33 169.7,82.33 170.21,82.84 R3.1 170.6,82.55 R10.1
PCH_SPI_CS1#: length 36.5
  IN1 w0.084: v2(166.1,68.68) 166.22,68.68 166.35,68.81 166.35,69.68 166.22,69.8 166.04,69.8 165.92,69.68 165.92,69.24 165.82,69.14 165.68,69.14 165.58,69.24 165.58,69.72 165.5,69.8 165.33,69.8 165.24,69.72 165.24,69.2 165.15,69.1 165.01,69.1 164.91,69.2 164.91,69.72 164.83,69.8 163.9,69.8 162.41,71.3 162.23,71.3 161.91,70.98 161.66,70.98 161.42,71.22 157.37,71.22 157.28,71.14 157.28,70.72 157.19,70.62 157.05,70.62 156.95,70.72 156.95,71.14 156.87,71.22 156.67,71.22 156.59,71.14 156.59,69.7 156.49,69.6 156.35,69.6 156.25,69.7 156.25,71.2 156.15,71.3 156.02,71.3 155.92,71.2 155.92,69.7 155.82,69.6 155.68,69.6 155.58,69.7 155.58,71.09 155.48,71.19 155.33,71.19 155.23,71.09 155.23,69.7 155.13,69.6 154.99,69.6 154.89,69.7 154.89,70.83 154.79,70.93 154.66,70.93 154.56,70.83 154.56,69.94 154.46,69.84 154.32,69.84 154.22,69.94 154.22,70.76 154.1,70.88 153.34,70.88 153.21,71.01 v2(153.21,71.52)
  BOTTOM w0.076: v2(153.21,71.52) 153.21,71.54 153.07,71.68 152.11,71.68 152.1,71.68 151.52,71.68 151.4,71.55 151.08,71.55 150.92,71.39 150.13,71.39 150.09,71.43 149.89,71.43 149.51,71.81 UC1.Y4
  BOTTOM w0.102: v2(166.1,68.68) 166.09,68.69 R14.1 164.52,69.62 R17.1
PCH_SPI_DIN: length 47.4
  IN1 w0.084: v2(164.58,73.06) 164.27,73.06 163.56,73.77 163.56,74.27 163.12,74.71 161.94,74.71 161.74,74.52 161.33,74.52 161.2,74.39 161.2,74.27 161.29,74.18 161.54,74.18 161.64,74.09 161.64,73.95 161.54,73.85 161.29,73.85 161.2,73.77 161.2,73.37 161.1,73.27 160.97,73.27 160.87,73.37 160.87,74.38 160.77,74.48 160.63,74.48 160.53,74.38 160.53,73.37 160.43,73.27 160.3,73.27 160.2,73.37 160.2,73.74 160.11,73.82 159.52,73.82 159.44,73.74 159.44,73.56 159.34,73.46 159.2,73.46 159.1,73.56 159.1,74.21 159,74.31 158.87,74.31 158.77,74.21 158.77,73.05 158.67,72.95 158.53,72.95 158.43,73.05 158.43,73.77 158.33,73.87 158.19,73.87 158.1,73.77 158.1,73.55 158,73.45 157.86,73.45 157.76,73.55 157.76,73.74 157.68,73.82 157.51,73.82 157.43,73.74 157.43,73.62 157.34,73.53 157.17,73.53 157.09,73.62 157.09,73.77 156.99,73.87 156.85,73.87 156.76,73.77 156.76,73.54 156.66,73.44 156.52,73.44 156.42,73.54 156.42,73.77 156.32,73.87 156.18,73.87 156.08,73.77 156.08,73.5 155.99,73.4 155.85,73.4 155.75,73.5 155.75,73.77 155.65,73.87 155.51,73.87 155.41,73.77 155.41,73.47 155.32,73.37 155.18,73.37 155.08,73.47 155.08,73.74 155,73.82 154.74,73.82 154.57,73.66 154.57,73.54 154.92,73.19 154.92,73.05 154.82,72.95 154.69,72.95 154.33,73.3 154.22,73.3 153.99,73.08 153.99,72.96 154.22,72.73 154.22,72.59 154.12,72.49 153.98,72.49 153.75,72.72 153.63,72.72 153.52,72.6 153.52,72.48 153.85,72.15 153.85,72.01 153.75,71.91 153.61,71.91 153.28,72.25 153.16,72.25 152.76,71.85 152.76,71.09 152.41,70.74 151.9,70.74 151.37,70.21 150.04,70.21 149.68,70.56 v2(149.68,70.75)
  IN2 w0.122: v2(164.58,73.06) 164.33,73.32 164.33,74.27 164.77,74.71 164.77,76.7 165.07,77 165.07,78.68 162.67,81.07 162.67,82.83 v2(162.95,83.11)
  BOTTOM w0.076: UC1.AA4 149.32,71.11 v2(149.68,70.75)
  BOTTOM w0.102: v2(164.58,73.06) 164.88,73.06 R15.1 ; R41.1 R22.1 164.29,83.27 R4.1 163.12,83.27 v2(162.95,83.11)
PCH_SPI_DO: length 47.6
  IN1 w0.084: v2(152.39,71.24) 152.39,71.77 154.69,74.08 158.34,74.08 158.95,74.69 161.21,74.69 161.44,74.92 163.21,74.92 163.82,74.31 163.82,73.91 164.22,73.51 164.71,73.51 165.15,73.06 169.41,73.06 170.68,71.79 v2(179.31,71.79)
  IN2 w0.122: v2(175.55,78.74) 176.24,78.05 177.01,78.05 179.59,75.47 179.59,73.52 179.31,73.24 v2(179.31,71.79)
  BOTTOM w0.076: UC1.AA2 150.86,71.1 151.15,71.39 151.46,71.39 151.57,71.49 152.14,71.49 v2(152.39,71.24)
  BOTTOM w0.102: R12.1 174.37,82.3 174.73,82.65 R11.1 175.7,82.17 175.7,81.66 176.19,81.18 R9.2 R21.2 175.55,79.59 v2(175.55,78.74)
PCH_SPI_DO2: length 41.1
  IN1 w0.084: v2(147.52,71.24) 147.9,71.63 150.21,71.63 150.53,71.95 150.65,71.95 151.24,71.35 151.36,71.35 151.48,71.47 151.48,71.59 150.88,72.18 150.88,72.3 151,72.42 151.12,72.42 151.72,71.82 151.83,71.82 151.95,71.94 151.95,72.06 151.36,72.66 151.36,72.78 151.48,72.89 151.6,72.89 152.19,72.3 152.31,72.3 152.43,72.42 152.43,72.54 151.83,73.13 151.83,73.25 152.2,73.62 152.62,73.62 152.72,73.71 152.72,74.61 152.79,74.69 152.96,74.69 153.04,74.6 153.04,73.71 153.13,73.62 153.66,73.62 154.33,74.29 158.25,74.29 158.57,74.61 158.57,74.73 158.43,74.87 158.43,74.99 158.55,75.11 158.67,75.11 158.81,74.97 158.93,74.97 159.05,75.09 159.05,75.21 158.91,75.35 158.91,75.47 159.03,75.59 159.14,75.59 159.29,75.44 159.4,75.44 159.52,75.56 160.41,75.56 160.54,75.69 160.54,76.21 160.67,76.34 161.54,76.34 161.66,76.21 161.66,75.79 161.56,75.69 161.14,75.69 161.01,75.56 161.01,75.36 161.14,75.23 163.3,75.23 164.07,74.46 164.07,73.95 164.26,73.76 165.28,73.76 165.41,73.63 165.41,73.4 165.53,73.27 165.74,73.27 165.87,73.4 165.87,74.16 v2(165.91,74.21)
  BOTTOM w0.076: v2(147.52,71.24) 147.99,71.71 UC1.Y6
  BOTTOM w0.102: R58.2 R59.2 R6.1 168.94,73.11 R1.2 168.3,73.75 168.3,74.43 168.12,74.61 167.55,74.61 166.98,74.04 R19.1 166.79,74.04 166.62,74.21 v2(165.91,74.21)
PCH_SPI_DO3: length 46.5
  IN4 w0.084: v2(170.66,69.52) 170.66,67.58 170.57,67.49 170.43,67.49 170.36,67.57 170.36,69.25 170.23,69.38 170.12,69.38 170.02,69.28 170.02,67.5 169.89,67.37 168.94,67.37 168.81,67.5 168.81,69.21 168.72,69.31 168.6,69.31 168.5,69.21 168.5,67.61 168.41,67.51 168.27,67.51 168.17,67.61 168.17,69.21 168.07,69.31 167.93,69.31 167.83,69.21 167.83,67.55 167.73,67.45 167.6,67.45 167.5,67.55 167.5,69.21 167.4,69.31 167.26,69.31 167.16,69.21 167.16,68.08 167.08,68 165.07,68 162.84,70.22 160.71,70.22 159.91,69.42 155.31,69.42 155.18,69.29 154.51,69.29 154.28,69.06 153.52,69.06 153.09,69.49 v2(153.09,69.5)
  BOTTOM w0.076: v2(153.09,69.5) 152.96,69.5 152.44,68.98 151.4,68.98 UC1.AF1
  BOTTOM w0.102: v2(170.66,69.52) 172.15,69.52 172.49,69.86 R48.2 R43.2 R2.2 174.42,73.11 175.23,73.93 R16.2 175.23,74.18 R5.2
PCH_TPM_LPC_EN: length 52.4
  TOP w0.102: v1(109.03,83.88) 108.61,83.88 v2(107.65,82.92)
  IN1 w0.084: v2(148.82,72.19) 148.43,71.8 147.4,71.8 147.24,71.64 146.84,71.64 145.95,72.53 144.45,72.53 143.79,73.19 143.79,74.19 142.19,75.79 138.76,75.79 137.88,76.68 118.81,76.68 117.37,78.12 117.37,78.71 116.55,79.54 115.48,79.54 114.95,79.01 113.03,79.01 112.17,79.87 110.4,79.87 109.33,80.94 109.33,81.72 109.04,82.02 108,82.02 107.65,82.37 v2(107.65,82.92)
  BOTTOM w0.076: UC1.Y5 148.82,71.89 v2(148.82,72.19)
  BOTTOM w0.102: RC56.2 v2(107.65,82.92) R198.1
PCI_CLK_LPC: length 179.1
  TOP w0.102: RC58.1 v2(34.99,40.26) 33.62,40.26 32.36,39 32.36,35.72 32.07,35.43 29.74,35.43 RC61.1 ; v2(31.38,18.03) 31.5,18.15 RC63.1 ; RC65.2 140.83,52.11 v1(143.37,49.57) 149.91,49.57 150.79,50.45 v2(150.79,52.04)
  IN1 w0.084: v2(34.99,40.26) 34.99,39.67 32.8,37.49 32.8,33.87 33.68,32.99 33.68,29.29 34.72,28.25 34.72,25.27 33.22,23.77 33.22,22.53 33.55,22.2 33.55,21.27 32.69,20.41 32.69,19.34 v2(31.38,18.03)
  IN2 w0.089: 150.79,51.41 v2(150.79,52.04)
  IN2 w0.122: v2(47.88,36.85) 47.88,37.5 49.9,39.52 51.13,39.52 53.39,41.78 53.92,41.78 54.2,41.5 58.86,41.5 59.37,41 125.89,41 126.94,42.04 144.58,42.04 150.79,48.26 150.79,51.41
  IN4 w0.084: v2(34.99,40.26) 36.25,41.52 40.02,41.52 42.31,39.22 45.52,39.22 v2(47.88,36.85)
PCI_CLK_LPC_0: length 10.8
  TOP w0.102: v2(142.71,64.1) 142.09,64.1 141.53,63.54 v1(141.53,60.24) 141.53,56.6 CC15.2 RC65.1
  BOTTOM w0.076: UC1.AN15 143.02,64.41 v2(142.71,64.1)
PCI_CLK_LPC_1: length 18.1
  TOP w0.102: RC64.1 RC66.1 CC14.2 v1(144.07,52.04) 142.67,53.44 142.67,59.98 141.91,60.74 141.91,63.16 142.22,63.47 v2(142.7,63.47)
  BOTTOM w0.076: v2(142.7,63.47) 143,63.76 UC1.AP15
PCIE_PRX_GLANTX_N3: length 132.9
  TOP w0.102: v2(250.33,70.41) 250.24,70.5 250.24,70.75 C176.2
  IN1 w0.091: v2(250.33,70.41) 250.24,70.5 250.24,70.75 249.98,71.01 248.42,71.01 246.8,72.63 246.8,78.25 245.57,79.48 244.65,79.48 244.45,79.27 244.45,79.06 v2(244.27,78.88)
  IN4 w0.084: v2(144.44,79.21) 144.69,79.46 144.84,79.46 145.03,79.65 145.03,80.02 148,82.99 153.22,82.99 153.22,82.99
  IN4 w0.091: 153.22,82.99 156.2,80.01 160.98,80.01 161.42,80.45 163.15,80.45 163.61,79.99 171.11,79.99 172.24,78.87 173.91,78.87 174.26,78.52 174.26,77.86 175,77.12 175,76.55 176.52,75.02 181.08,75.02 182.93,73.16 184.29,73.16 184.76,73.63 191.19,73.63 192.07,74.52 202.47,74.52 205.57,77.61 206.6,77.61 209.32,80.33 210.74,80.33 211.62,81.2 211.62,82.42 215.48,86.28 217.95,86.28 219.24,87.58 221.04,87.58 221.67,86.95 231.9,86.95 232.88,85.97 232.88,85.13 234.66,83.35 236.97,83.35 239.57,80.75 241.05,80.75 242.4,79.39 244.22,79.39 244.37,79.24 244.37,78.98 v2(244.27,78.88)
  BOTTOM w0.076: v2(144.44,79.21) 144.76,78.89 UC1.G11
PCIE_PRX_GLANTX_N3_C: length 3.2
  TOP w0.102: U21.39 251.13,73.92 251.04,73.83 251.04,73.29 v3(250.62,72.87) 250.2,72.45 250.2,72.31 C176.1
PCIE_PRX_GLANTX_P3: length 132.8
  TOP w0.102: v2(249.74,70.41) 249.92,70.59 249.92,70.78 C179.2
  IN1 w0.091: v2(244.86,78.88) 244.82,78.88 244.62,79.07 244.62,79.2 244.72,79.3 245.5,79.3 246.62,78.18 246.62,72.56 248.35,70.84 249.91,70.84 249.99,70.76 249.99,70.62 249.78,70.41 v2(249.74,70.41)
  IN4 w0.084: 153.34,83.11 153.33,83.12 153.32,83.12 153.29,83.15 153.22,83.15 153.15,83.15 147.93,83.15 144.87,80.09 144.87,79.71 144.77,79.62 144.69,79.62 v2(144.44,79.87)
  IN4 w0.091: v2(244.86,78.88) 244.84,78.88 244.55,79.17 244.55,79.32 244.3,79.57 242.47,79.57 241.12,80.92 239.64,80.92 237.04,83.52 234.73,83.52 233.05,85.2 233.05,86.04 231.97,87.12 221.74,87.12 221.11,87.75 219.17,87.75 217.88,86.46 215.41,86.46 211.45,82.49 211.45,81.27 210.67,80.5 209.24,80.5 206.53,77.78 205.49,77.78 202.4,74.69 192,74.69 191.12,73.81 184.69,73.81 184.22,73.34 183.01,73.34 181.15,75.19 176.6,75.19 175.17,76.62 175.17,77.19 174.43,77.93 174.43,78.59 173.98,79.04 172.31,79.04 171.18,80.16 163.68,80.16 163.22,80.62 161.35,80.62 160.91,80.18 156.27,80.18 153.34,83.11
  BOTTOM w0.076: v2(144.44,79.87) 144.77,79.55 UC1.F11
PCIE_PRX_GLANTX_P3_C: length 3.2
  TOP w0.102: C179.1 249.99,72.3 249.99,72.54 250.24,72.8 250.24,72.83 250.66,73.25 250.7,73.25 250.82,73.38 250.82,73.83 250.73,73.92 U21.38
PCIE_PRX_MMITX_N5: length 188.5
  TOP w0.102: C238.1 263.94,29.15 264.27,29.15 v2(264.45,29.33)
  IN1 w0.091: v2(264.45,29.33) 264.45,29.32 264.85,28.92 265.05,28.92 265.44,29.3 265.44,33.97 265.95,34.49 265.95,72.67 264.32,74.3 263.98,74.3 263.67,74.61 263.67,74.8 v2(263.31,75.15)
  IN4 w0.084: v2(145.34,79.22) 145.6,79.44 145.86,79.44 146.19,79.77 146.19,80.33 148.44,82.57 152.73,82.57 153.68,81.62 153.68,81.62 153.71,81.58 153.71,81.58 153.73,81.57
  IN4 w0.091: v2(263.31,75.15) 263.33,75.15 263.71,75.52 263.71,75.86 263.57,76 262.84,76 262.5,75.66 260.48,75.66 259.95,76.19 259.02,76.19 257.71,77.5 255.8,77.5 255.31,77.98 250.5,77.98 249.96,77.44 245.16,77.44 244.37,78.23 241.6,78.23 240.54,79.29 240.54,79.59 240.04,80.1 239.3,80.1 236.7,82.7 234.39,82.7 232.95,84.15 229.57,84.15 227.43,86.29 221.33,86.29 220.68,86.93 219.53,86.93 218.23,85.63 215.76,85.63 212.35,82.22 212.35,81.02 210.76,79.43 209.36,79.43 208.34,78.4 208.34,77.94 206.27,75.87 204.8,75.87 202.77,73.85 192.35,73.85 191.49,72.99 185.03,72.99 184.47,72.43 182.7,72.43 180.83,74.3 176.31,74.3 175.24,75.37 174.27,75.37 172.52,77.12 172.52,77.9 172.25,78.16 171.87,78.16 170.69,79.35 163.34,79.35 163.33,79.36 155.93,79.36 153.73,81.57
  BOTTOM w0.076: v2(145.34,79.22) 145.66,79.55 UC1.F10
PCIE_PRX_MMITX_N5_C: length 10.3
  TOP w0.102: U27.8 257.39,24.33 258.6,25.54 258.6,28.13 v3(259.33,28.86) 259.97,29.5 260.78,29.5 260.79,29.51 261.4,29.51 261.42,29.5 262.55,29.5 C238.2
PCIE_PRX_MMITX_P5: length 188.7
  TOP w0.102: C237.1 263.78,28.93 264.27,28.93 v2(264.45,28.75)
  IN1 w0.091: v2(263.9,75.15) 263.84,75.09 263.84,74.68 264.05,74.47 264.39,74.47 266.12,72.74 266.12,34.42 265.61,33.9 265.61,29.23 265.13,28.75 v2(264.45,28.75)
  IN4 w0.084: v2(145.4,79.86) 145.4,79.67 145.47,79.6 145.79,79.6 146.02,79.84 146.02,80.4 148.37,82.74 152.8,82.74 153.85,81.69
  IN4 w0.091: 153.85,81.69 156,79.53 163.4,79.53 163.41,79.52 170.76,79.52 171.95,78.33 172.33,78.33 172.69,77.97 172.69,77.2 174.35,75.54 175.31,75.54 176.38,74.47 180.9,74.47 182.77,72.6 184.4,72.6 184.96,73.16 191.42,73.16 192.28,74.02 202.7,74.02 204.72,76.05 206.2,76.05 208.17,78.02 208.17,78.48 209.29,79.6 210.69,79.6 212.18,81.09 212.18,82.29 215.69,85.8 218.16,85.8 219.46,87.11 220.75,87.11 221.4,86.46 227.5,86.46 229.64,84.32 233.02,84.32 234.47,82.87 236.77,82.87 239.37,80.27 240.11,80.27 240.72,79.66 240.72,79.36 241.67,78.41 244.45,78.41 245.24,77.62 249.89,77.62 250.43,78.16 255.38,78.16 255.87,77.67 257.78,77.67 259.09,76.36 260.02,76.36 260.55,75.84 262.43,75.84 262.77,76.17 263.64,76.17 263.9,75.91 v2(263.9,75.15)
  BOTTOM w0.076: UC1.E10 145.82,80.08 145.59,79.86 v2(145.4,79.86)
PCIE_PRX_MMITX_P5_C: length 10.3
  TOP w0.102: C237.2 262,29.29 v3(261.1,29.29) 260.06,29.29 259.7,28.93 259.7,28.88 259.24,28.42 259.19,28.42 258.81,28.04 258.81,25.45 257.6,24.24 257.6,23.72 257.79,23.53 U27.7
PCIE_PRX_WLANTX_N4: length 126.1
  IN2 w0.132: v2(177.04,75.67) 177.04,75.65 177.48,75.22 177.48,74.85 177.34,74.71 176.23,74.71 175.95,74.43 175.95,70.38 177.72,68.61 177.72,67.81 178.9,66.63 178.9,62.77 178.6,62.47 178.6,58.15 177.16,56.72 177.16,52.5 189.75,39.91 194.72,39.91 197.13,37.5 197.13,35.16 200.95,31.34 200.95,30.45 202.41,28.99 202.41,27.07 202.92,26.56 203.78,26.56 205.29,25.04 205.29,22.68 204.69,22.08 204.69,21.09 204.94,20.84 204.94,20.71 204.69,20.46 v2(204.69,20.4)
  IN4 w0.084: v2(143.47,79.93) 143.51,79.9 143.51,79.63 143.38,79.5 143.25,79.5 143.08,79.67 143.08,80.64 144.06,81.62 144.5,81.62 146.8,83.92 153.23,83.92 153.45,83.7 153.45,83.7 153.48,83.66 153.48,83.66 153.5,83.65
  IN4 w0.091: 153.5,83.65 156.49,80.65 160.71,80.65 161.95,81.89 166.63,81.89 167.88,80.64 171.41,80.64 172.52,79.53 175.82,79.53 177.13,78.21 177.13,76.64 177.45,76.32 177.45,76.08 177.34,75.97 177.27,75.97 177.04,75.75 v2(177.04,75.67)
  BOTTOM w0.076: v2(143.47,79.93) 143.47,79.91 143.84,79.55 UC1.F13
  BOTTOM w0.102: JMINI1.23 210.85,20.8 210.7,20.95 209.65,20.95 208.42,19.72 205.16,19.72 204.85,20.03 204.85,20.23 v2(204.69,20.4)
PCIE_PRX_WLANTX_P4: length 126.1
  IN2 w0.132: v2(205.28,20.46) 205.18,20.55 205.18,20.94 204.93,21.19 204.93,21.98 205.54,22.58 205.54,25.15 203.88,26.8 203.02,26.8 202.65,27.17 202.65,29.09 201.19,30.55 201.19,31.44 197.38,35.26 197.38,37.6 194.82,40.16 189.85,40.16 177.41,52.6 177.41,56.62 178.84,58.05 178.84,62.36 179.15,62.67 179.15,66.73 177.97,67.92 177.97,68.71 176.2,70.48 176.2,74.33 176.33,74.47 177.45,74.47 177.72,74.75 177.72,75.57 v2(177.63,75.67)
  IN4 w0.084: v2(143.48,79.13) 143.28,79.34 143.18,79.34 142.91,79.6 142.91,80.71 143.99,81.79 144.43,81.79 146.73,84.09 153.3,84.09 153.62,83.77
  IN4 w0.091: v2(177.63,75.67) 177.63,76.39 177.3,76.71 177.3,78.28 175.89,79.7 172.59,79.7 171.48,80.81 167.95,80.81 166.7,82.06 161.88,82.06 160.64,80.82 156.56,80.82 153.62,83.77
  BOTTOM w0.076: v2(143.48,79.13) 143.82,79.13 143.91,79.04 143.91,78.89 UC1.G13
  BOTTOM w0.102: JMINI1.25 210.85,21.6 210.76,21.5 210.76,21.27 210.66,21.17 209.56,21.17 208.33,19.94 205.25,19.94 205.06,20.12 205.06,20.25 v2(205.28,20.46)
PCIE_PTX_GLANRX_N3: length 148.6
  TOP w0.102: C181.1 252.94,70.72 252.94,70.58 v2(253.12,70.4)
  IN1 w0.084: 148.95,85.4 148.97,85.38 148.97,85.38 149,85.34 149,85.34 152.43,81.91 152.43,80.07 152.9,79.6 153.83,79.6 153.83,79.61 153.85,79.61 ; v2(133.19,84.06) 133.21,84.04 135.19,84.04 136.51,85.36 139.27,85.36 139.65,84.98 140.26,84.98 140.87,84.37 145.04,84.37 146.24,85.56 146.25,85.57
  IN1 w0.091: v2(253.12,70.4) 252.91,70.61 252.91,70.89 252.39,71.41 250.5,71.41 250.25,71.66 248.77,71.66 247.44,72.99 247.44,78.52 245.84,80.12 243.73,80.12 241.08,82.77 239.63,82.77 237.9,84.51 235.79,84.51 234.83,83.55 224.08,83.55 222.95,84.68 221.36,84.68 220.7,84.03 214.8,84.03 210.69,79.91 209.52,79.91 208.18,78.57 208.18,77.93 207.67,77.42 207.67,77.14 205.09,74.56 203.96,74.56 201.77,72.37 197.8,72.37 197.56,72.13 194.25,72.13 194.15,72.03 181.68,72.03 180.48,73.23 176.03,73.23 175.6,73.65 173.69,73.65 172.62,74.72 169.84,74.72 169.32,75.25 167.43,75.25 166.34,76.34 165.02,76.34 163.34,78.02 161.17,78.02 160.26,78.93 158.83,78.93 158.36,78.46 155.3,78.46 154.15,79.61 153.85,79.61 ; 148.95,85.4 148.65,85.7 146.38,85.7 146.25,85.57
  BOTTOM w0.076: 133.75,82.98 133.75,82.02 134.05,81.72 UC1.C29
  BOTTOM w0.102: v2(133.19,84.06) 133.31,83.93 133.63,83.93 133.87,83.69 133.87,83.11 133.75,82.98
PCIE_PTX_GLANRX_N3_C: length 3.1
  TOP w0.102: C181.2 252.93,72.31 252.93,72.53 v3(252.53,72.94) 252.24,73.23 252.24,73.83 252.33,73.92 U21.42
PCIE_PTX_GLANRX_P3: length 148.5
  TOP w0.102: v2(252.54,70.4) 252.72,70.58 252.72,70.72 C178.1
  IN1 w0.084: v2(133.06,83.41) 133.08,83.41 133.54,83.87 135.26,83.87 136.58,85.19 139.2,85.19 139.58,84.81 140.19,84.81 140.8,84.2 145.11,84.2 146.31,85.4 146.32,85.4 146.35,85.44 146.36,85.44 146.37,85.45 ; 148.83,85.27 152.26,81.84 152.26,80 152.83,79.44 153.83,79.44 153.83,79.43 153.85,79.43
  IN1 w0.091: 146.37,85.45 146.45,85.53 148.58,85.53 148.83,85.27 ; v2(252.54,70.4) 252.74,70.59 252.74,70.81 252.32,71.23 250.43,71.23 250.18,71.49 248.7,71.49 247.27,72.92 247.27,78.45 245.77,79.95 243.66,79.95 241.01,82.6 239.56,82.6 237.83,84.34 235.86,84.34 234.91,83.38 224.01,83.38 222.88,84.51 221.43,84.51 220.77,83.85 214.87,83.85 210.76,79.74 209.6,79.74 208.36,78.5 208.36,77.86 207.84,77.35 207.84,77.07 205.16,74.38 204.03,74.38 201.84,72.2 197.88,72.2 197.63,71.95 194.32,71.95 194.22,71.85 181.61,71.85 180.41,73.05 175.96,73.05 175.53,73.48 173.62,73.48 172.55,74.55 169.77,74.55 169.25,75.07 167.36,75.07 166.26,76.17 164.95,76.17 163.27,77.85 161.1,77.85 160.19,78.76 158.9,78.76 158.43,78.29 155.23,78.29 154.08,79.43 153.85,79.43
  BOTTOM w0.076: 133.56,83.1 133.56,82.24 133.48,82.15 133.27,82.15 133.21,82.09 133.21,81.9 133.32,81.79 133.44,81.79 UC1.B30
  BOTTOM w0.102: v2(133.06,83.41) 133.06,83.42 133.35,83.72 133.54,83.72 133.66,83.6 133.66,83.2 133.56,83.1
PCIE_PTX_GLANRX_P3_C: length 3.1
  TOP w0.102: U21.41 251.93,73.92 252.02,73.83 252.02,73.13 252.15,73 252.15,72.97 252.5,72.62 252.53,72.62 252.72,72.43 252.72,72.3 C178.2
PCIE_PTX_MMIRX_N5: length 203.1
  TOP w0.102: C236.1 261.77,27.49 261.98,27.49 v2(262.16,27.3)
  IN1 w0.084: 152.51,78.14 151.76,78.14 151.32,78.58 151.32,82 149.09,84.24 146.7,84.24 145.34,82.88 140.69,82.88 138.89,84.68 138.35,84.68 v2(138.23,84.81)
  IN1 w0.091: v2(244.81,71.31) 244.63,71.13 244.41,71.13 244.3,71.24 244.3,73.49 245.73,74.91 245.73,76.7 242.77,79.66 242.77,80.17 240.85,82.09 238.29,82.09 237.79,82.58 236.04,82.58 235.72,82.91 223.77,82.91 223.3,83.38 215.07,83.38 210.74,79.05 210.74,78.85 210.24,78.35 209.67,78.35 208.35,77.03 208.35,76.53 207.29,75.47 206.94,75.47 205.37,73.9 204.24,73.9 200.98,70.64 200.26,70.64 199.96,70.33 198.36,70.33 197.22,71.48 194.68,71.48 194.58,71.38 180.42,71.38 180.04,71.76 180.04,72.21 179.81,72.43 173.34,72.43 172.88,72.9 171.16,72.9 170.23,73.82 167.17,73.82 166.16,74.84 165.18,74.84 163,77.02 161.26,77.02 160.33,77.95 158.79,77.95 158.25,77.41 153.25,77.41 152.51,78.14
  IN4 w0.091: v2(262.16,27.3) 262.84,27.3 263.07,27.53 263.07,31.13 265.46,33.52 265.46,69.73 264.81,70.38 253.95,70.38 253.32,71.02 245.87,71.02 245.58,71.31 v2(244.81,71.31)
  BOTTOM w0.076: v2(138.23,84.81) 138.23,84.7 137.81,84.28 137.81,83.67 138.38,83.1 138.38,82.57 138.19,82.38 UC1.C23
PCIE_PTX_MMIRX_N5_C: length 6.4
  TOP w0.102: C236.2 260.52,27.48 260.41,27.58 259.74,27.58 259.59,27.43 259.59,27.11 259.6,27.1 259.6,26.44 259.59,26.43 259.59,25.34 258.97,24.72 258.97,24.71 258.4,24.14 258.4,23.65 258.59,23.47 U27.5
PCIE_PTX_MMIRX_P5: length 203
  TOP w0.102: v2(262.16,27.89) 261.98,27.7 261.77,27.7 C235.1
  IN1 w0.084: v2(138.23,84.18) 138.57,84.52 138.82,84.52 140.62,82.71 145.41,82.71 146.77,84.07 149.02,84.07 151.16,81.93 151.16,78.51 151.69,77.98 152.44,77.98 152.44,77.97
  IN1 w0.091: 152.44,77.97 153.18,77.23 158.32,77.23 158.86,77.77 160.26,77.77 161.19,76.85 162.93,76.85 165.11,74.67 166.09,74.67 167.1,73.65 170.16,73.65 171.09,72.72 172.81,72.72 173.27,72.26 179.74,72.26 179.87,72.13 179.87,71.69 180.35,71.21 194.66,71.21 194.76,71.31 197.14,71.31 198.29,70.16 200.03,70.16 200.34,70.46 201.05,70.46 204.31,73.72 205.44,73.72 207.01,75.3 207.36,75.3 208.52,76.46 208.52,76.96 209.74,78.18 210.31,78.18 210.91,78.78 210.91,78.98 215.14,83.21 223.23,83.21 223.7,82.73 235.64,82.73 235.96,82.41 237.72,82.41 238.22,81.91 240.78,81.91 242.59,80.1 242.59,79.59 245.56,76.63 245.56,74.99 244.13,73.56 244.13,71.17 244.34,70.96 244.57,70.96 v2(244.81,70.72)
  IN4 w0.091: v2(244.81,70.72) 244.81,70.74 245.2,71.13 245.51,71.13 245.8,70.84 253.24,70.84 253.88,70.21 264.73,70.21 265.29,69.66 265.29,33.59 262.9,31.2 262.9,27.6 262.77,27.48 262.56,27.48 262.16,27.87 v2(262.16,27.89)
  BOTTOM w0.076: UC1.C22 138.6,81.71 138.35,81.95 138.35,82.31 138.55,82.5 138.55,83.17 137.97,83.74 137.97,83.93 v2(138.23,84.18)
PCIE_PTX_MMIRX_P5_C: length 6.4
  TOP w0.102: C235.2 260.27,27.8 259.65,27.8 259.37,27.52 v3(259.37,26.78) 259.37,25.42 258.76,24.81 258.76,24.8 258.19,24.23 U27.6
PCIE_PTX_WLANRX_N4: length 127.3
  IN1 w0.091: v2(133.42,85.34) 133.31,85.34 133.16,85.19 133.16,84.86 133.24,84.78 133.63,84.78 134.9,86.05 145.55,86.05 145.84,86.34 149.07,86.34 155.83,79.58 160.53,79.58 161.36,78.75 164.85,78.75 166.78,76.82 167.55,76.82 168.48,75.89 169.59,75.89 170.11,75.37 173.26,75.37 173.68,74.95 174.63,74.95 175.13,74.45 176.91,74.45 177.09,74.27 177.09,74.03 v2(177.29,73.82)
  IN2 w0.132: v2(177.29,73.82) 177.06,73.59 177.06,72.9 177.76,72.2 177.76,69.99 178.74,69.01 178.74,68.22 179.91,67.05 179.91,62.36 179.6,62.05 179.6,57.73 178.17,56.3 178.17,52.91 190.17,40.92 195.14,40.92 198.14,37.92 198.14,35.62 201.96,31.8 201.96,30.94 205.37,27.53 205.37,26.4 206.3,25.47 206.3,22.26 205.99,21.95 205.99,21.44 v2(206.09,21.34)
  BOTTOM w0.076: v2(133.42,85.34) 133.42,85.05 134.41,84.06 134.41,83.49 134.44,83.46 134.48,83.42 134.48,82.79 134.34,82.65 134.34,82.61 134.05,82.33 UC1.B29
  BOTTOM w0.102: v2(206.09,21.34) 205.92,21.51 205.92,22.64 206.29,23.01 207.35,23.01 C242.1
PCIE_PTX_WLANRX_N4_C: length 4.1
  BOTTOM w0.102: C242.2 208.98,23.04 209.52,23.04 209.83,23.34 v3(209.83,23.8) 209.83,24.19 209.91,24.27 210.52,24.27 210.79,24 JMINI1.31
PCIE_PTX_WLANRX_P4: length 127.6
  IN1 w0.091: v2(132.66,85.34) 132.91,85.34 132.99,85.25 132.99,84.79 133.17,84.6 133.7,84.6 134.97,85.87 145.62,85.87 145.92,86.17 148.99,86.17 155.76,79.41 160.46,79.41 161.29,78.57 164.78,78.57 166.71,76.65 167.48,76.65 168.41,75.72 169.51,75.72 170.04,75.2 173.19,75.2 173.6,74.78 174.55,74.78 175.06,74.28 176.84,74.28 176.92,74.2 176.92,74.03 v2(176.71,73.82)
  IN2 w0.132: v2(176.71,73.82) 176.82,73.72 176.82,72.8 177.52,72.1 177.52,69.89 178.49,68.91 178.49,68.11 179.66,66.95 179.66,62.46 179.35,62.15 179.35,57.84 177.92,56.4 177.92,52.81 190.07,40.67 195.04,40.67 197.89,37.81 197.89,35.52 201.71,31.7 201.71,30.84 205.13,27.42 205.13,26.29 206.05,25.37 206.05,22.36 205.74,22.05 205.74,21.57 v2(205.51,21.34)
  BOTTOM w0.076: v2(132.66,85.34) 132.71,85.38 132.96,85.38 133.05,85.29 133.05,85.18 134.25,83.99 134.25,83.42 134.32,83.35 134.32,82.86 134.27,82.81 UC1.A29
  BOTTOM w0.102: v2(205.51,21.34) 205.7,21.53 205.7,22.73 206.2,23.23 207.37,23.23 C243.1
PCIE_PTX_WLANRX_P4_C: length 4.1
  BOTTOM w0.102: C243.2 208.92,23.25 209.44,23.25 209.61,23.43 209.61,23.52 209.6,23.53 209.6,24.06 209.61,24.08 209.61,24.28 209.82,24.49 210.5,24.49 210.82,24.8 JMINI1.33
PCIE_WAKE#: length 264.3
  TOP w0.102: R340.2 35.48,26.02 35.22,26.29 33.43,26.29 33.05,25.91 30.37,25.91 29.46,26.82 28.53,26.82 28.28,26.57 v1(28.28,25.37) 28.28,24.97 27.69,24.37 v2(27.69,23.91) ; v2(26.36,17.84) 27.19,18.67 U38.B38
  IN1 w0.084: v2(27.69,23.91) 27.69,22.75 27.95,22.49 27.95,21.23 27.24,20.52 27.24,20.45 26.78,20 26.78,18.26 v2(26.36,17.84)
  IN2 w0.122: v2(194.29,37.67) 194.29,33.99 199.96,28.32 199.96,25.1 203.17,21.88 203.17,19.84 203.43,19.58 203.43,15.09 204.8,13.72 v2(205.33,13.72)
  IN3 w0.122: v2(26.36,17.84) 26.38,17.86 26.38,17.36 26.91,16.83 30.48,16.83 31.3,16 33.02,16 34.99,17.97 37.44,17.97 39.2,19.73 39.2,22.38 41.76,24.94 41.76,25.8 44.91,28.96 45.9,28.96 47.53,30.58 50.21,30.58 52.75,33.12 55.77,33.12 56.77,34.12 61.74,34.12 62.53,34.91 117.35,34.91 122.29,29.97 122.29,27.07 122.64,26.72 126.45,26.72 128.65,28.92 129.84,28.92 131.06,30.15 131.76,30.15 132.78,31.17 132.78,32.5 137.1,36.82 185.84,36.82 186.65,36.01 187.52,36.01 187.78,36.27 189.44,36.27 190.84,37.67 v2(194.29,37.67)
  BOTTOM w0.102: v2(205.33,13.72) 206.81,13.72 207.35,13.18 207.35,12.38 210.92,8.8 JMINI1.1 ; v2(194.29,37.67) 194.29,38.73 198.59,43.03 201.84,43.03 204.32,40.55 JMINI2.1
PCIECLK_REQ0#: length 8.9
  BOTTOM w0.076: 153.85,74.68 153.21,74.68 152.88,74.35 152.88,73.81 152.57,73.51 151.56,73.51 151.43,73.64 150.72,73.64 150.62,73.54 UC1.U2
  BOTTOM w0.102: RC57.2 157.61,75.22 156.54,75.22 156.4,75.08 155.63,75.08 154.76,74.22 154.46,74.22 154,74.68 153.85,74.68
PE_REXT: length 3.1
  TOP w0.203: R205.2 259.97,25.23 v1(259.37,24.64) 259.14,24.4 258.99,24.25 U27.4
PE_RST#: length 17.2
  TOP w0.102: R443.2 R27.1 v2(250.43,28.02) ; v1(255.77,27.9) v2(255.26,27.9) 255,28.15 U26.4 ; U27.15 253.98,21.3 v2(253.4,21.88)
  IN1 w0.084: v2(255.26,27.9) 255.01,27.9 254.75,27.63 254.75,26.25 254.37,25.87 254.37,24.17 253.4,23.2 v2(253.4,21.88)
  BOTTOM w0.102: v2(250.43,28.02) 251.08,28.66 251.78,28.66 252.54,27.9 v2(255.26,27.9)
PECI_EC: length 146.6
  TOP w0.102: v2(20.24,23.71) R375.2
  IN1 w0.084: v2(64.34,76.29) 64.41,76.22 66.88,76.22 67.75,77.08 67.75,77.95 68.37,78.57 69.16,78.57 72.11,81.52 75.75,81.52 77.45,83.21 83.28,83.21 83.71,82.78 85.1,82.78 85.4,82.48 92.15,82.48 93.77,80.86 100.38,80.86 101.35,79.89 107.81,79.89 109.49,78.21 111.24,76.47 v2(111.24,75.79)
  IN4 w0.084: v2(20.24,23.71) 20.42,23.53 21.35,23.53 22.25,24.43 23.88,24.43 25.45,26.01 30.98,26.01 31.38,25.61 32.5,25.61 33.35,26.47 35,26.47 35.2,26.67 41.33,26.67 41.92,26.08 45.61,26.08 46.23,26.69 46.23,28.87 48.13,30.77 48.13,33.91 53.8,39.58 53.87,39.58 55.92,41.63 55.92,44.48 56.65,45.21 61.86,45.21 62.82,46.18 62.82,48.48 61.02,50.28 61.02,64.85 62.79,66.62 62.79,74.74 v2(64.34,76.29)
  BOTTOM w0.076: v2(111.24,75.79) 111.69,75.34 113.01,75.34 113.3,75.63 UC1.N62
PECI_EC_R: length 3.3
  TOP w0.102: R375.1 20.57,21.86 20.57,21.39 20.51,21.32 20.21,21.32 20.13,21.25 v1(20.13,21.12) 20.13,21.01 20.35,20.79 20.83,20.79 20.94,20.68 U38.A48
PGOOD_3V_5V: length 3.3
  TOP w0.203: PR107.1 200.2,48.08 199.99,48.3 199.38,48.3 198.83,48.85 PU100.7
  TOP w0.254: PR108.2 PR107.1
PIRQ#_TPM: length 9.6
  TOP w0.102: RP2.8 156.91,73.79 156.62,73.49 153.54,73.49 152.53,74.51 151.28,74.51 v1(151.02,74.25) 150.51,74.75 150.13,74.75 v2(149.66,75.22)
  BOTTOM w0.076: UC1.N4 149.32,75.56 v2(149.66,75.22)
PLT_LAN_RST#: length 11.9
  TOP w0.102: R145.2 243.69,74.43 246.61,74.43 246.86,74.18 246.86,73.41 246.69,73.23 U20.4 246.69,72.17 246.89,71.97 R25.1 v1(247.75,73.08) 247.75,74.79 248.34,75.37 U21.36
PLTRST_LAN#: length 93.3
  TOP w0.102: U20.2 246.04,70.4 245.88,70.24 243.03,70.24 242,71.27 242,73.66 R145.1 242.43,75.53 238.53,79.42 v1(238.53,81.64) v2(238.53,82.64) ; v2(176.33,59.66) 175.84,59.18 RC91.1
  IN3 w0.122: v2(238.53,82.64) 238.28,82.39 224,82.39 222.77,81.16 212.65,81.16 211.23,79.74 210.92,79.43 209.07,79.43 208.38,78.74 208.38,77.81 206.62,76.05 204.93,76.05 201.84,72.95 201.57,72.95 199.74,71.12 199.74,70.71 197.19,68.17 196.82,68.17 196.81,68.17 195.56,68.17 194.3,66.92 191.73,66.92 191.41,66.6 184.28,66.6 181.61,63.92 181.61,60.9 180.37,59.66 v2(176.33,59.66)
PLTRST_MMI#: length 170.9
  TOP w0.102: v2(176.33,58.94) 175.68,58.29 RC90.1 ; U26.1 251.95,29.45 251.83,29.58 R443.1 v1(251.38,31.06) 251.38,31.98 252.84,33.44 264.15,33.44 265.27,34.56 265.27,51.25 266.66,52.64 268.3,52.64 v2(269.35,51.59)
  IN3 w0.122: v2(176.33,58.94) 180,58.94 181.86,60.8 181.86,63.82 184.39,66.35 191.52,66.35 191.84,66.67 194.4,66.67 195.66,67.92 197.3,67.92 199.99,70.61 199.99,71.02 201.67,72.7 201.94,72.7 203.94,74.7 205.33,74.7 206.41,75.78 207.64,75.78 212.77,80.91 222.87,80.91 224.1,82.14 241.62,82.14 243.82,79.93 245.13,79.93 249.05,76.02 256.57,76.02 257.42,76.87 259.3,76.87 259.72,76.46 260.08,76.46 260.71,75.82 263.88,75.82 264.54,75.16 264.54,74.22 266.07,72.69 267.02,72.69 268.06,71.64 268.06,52.88 v2(269.35,51.59)
PLTRST_NFC#: length 202
  TOP w0.102: v2(176,64.01) 176,63.52 v1(176.13,63.39) 176.75,62.77 176.75,58.66 175.58,57.49 RC300.1 ; U29.1 248.91,13.32 249.3,12.93 250.47,12.93 v2(250.86,13.32)
  IN4 w0.084: v2(176,64.01) 176.1,63.9 177.36,63.9 182.25,68.79 184.63,68.79 185.94,70.1 189.87,70.1 190.4,69.58 194.5,69.58 194.63,69.45 198.45,69.45 200.62,71.62 202.97,71.62 204.29,72.93 207.49,72.93 207.78,73.23 207.78,74.9 209.27,76.39 211.04,76.39 215.47,80.82 216.76,80.82 218.52,82.59 231.96,82.59 235.07,79.47 237.84,79.47 239.85,77.46 240.27,77.46 240.98,76.75 243.76,76.75 245.1,75.41 254.98,75.41 256.69,73.69 262.7,73.69 263.1,74.09 264.85,74.09 265.12,73.83 265.12,73.37 267.64,70.84 267.64,55.37 270.85,52.15 270.85,40.37 271.41,39.82 271.41,34.83 276.45,29.79 276.45,26.45 276.19,26.18 274.17,26.18 272.74,27.61 268.05,27.61 266.41,25.97 266.41,24.83 265.9,24.31 263.43,24.31 261.9,22.79 253.45,22.79 251.74,21.08 251.74,14.36 250.86,13.47 v2(250.86,13.32)
PLTRST_USH#: length 93
  TOP w0.102: RC89.1 174.94,55.85 v5(173.29,55.85) v2(172.78,56.36) ; v2(190.18,4.83) 190.26,4.9 JUSH1.15
  IN1 w0.084: v2(208.1,13.13) 207.71,12.74 207.71,9.03 207.15,8.47 v2(207.15,6.1)
  IN2 w0.122: v2(190.18,4.83) 190.61,4.39 192.97,4.39 193,4.43 202.27,4.43 204.81,6.98 206.27,6.98 v2(207.15,6.1) ; v2(172.78,56.36) 173.56,55.58 173.56,52.35 183.57,42.34 183.57,40.75 186.46,37.86 186.46,36.93 189.89,33.5 194.42,33.5 199.71,28.22 199.71,24.99 202.92,21.78 202.92,19.73 203.18,19.47 203.18,14.57 204.69,13.07 208.04,13.07 v2(208.1,13.13)
PLTRST_VMM2320#: length 55.1
  TOP w0.102: RC92.1 175.58,60.3 v2(176.34,61.06) v1(176.34,61.62) ; v2(201.26,86.56) 200.75,86.56 200.23,86.04 200.23,85.41 199.93,85.12 199.77,85.12 199.46,84.8 U6.A13
  IN2 w0.122: v2(201.26,86.56) 198.17,86.56 196.48,88.25 193.74,88.25 193.09,87.6 193.09,87.1 192.27,86.27 192.27,84.88 189.59,82.21 189.59,79.89 190.09,79.39 190.09,77.54 189.01,76.46 189.01,74.3 188.86,74.14 188.86,73.17 190.13,71.89 190.13,69.48 189.59,68.93 189.59,67.75 v2(189.84,67.5)
  IN3 w0.122: v2(189.84,67.5) 189.84,67.41 189.28,66.85 184.18,66.85 182.74,65.41 182.73,65.41 181.36,64.04 181.36,61.62 180.47,60.73 176.67,60.73 v2(176.34,61.06)
PM_APWROK: length 105.7
  TOP w0.102: v2(68.15,68.71) v1(67.34,69.52) 67.34,71.12 67.96,71.74 RC144.1 68.98,71.74 69.32,72.09 69.62,72.09 69.96,72.43 UC7.2 ; U38.A9 24.94,8.29 24.44,7.78 v2(24.37,7.78)
  IN1 w0.084: v2(42.7,11.03) 42.6,11.13 42.6,13.79 43.13,14.33 43.13,15.39 45.75,18.02 46.9,18.02 47.62,18.73 47.62,22.63 48.12,23.14 48.12,25.16 50.81,27.85 52.95,27.85 55.08,25.71 55.74,25.71 57.21,27.19 57.21,27.39 59.18,29.36 60.16,29.36 60.76,29.96 60.76,32.62 62.66,34.52 62.66,38.75 62.11,39.3 62.11,43.59 66.97,48.45 66.97,63.59 68.39,65.02 68.39,68.48 68.17,68.71 v2(68.15,68.71)
  IN2 w0.122: v2(24.37,7.78) 25.2,8.62 28.49,8.62 30.18,6.93 31.89,6.93 32.44,6.38 35.53,6.38 37.68,8.53 39.4,8.53 41.47,10.59 42.2,10.59 42.64,11.03 v2(42.7,11.03)
PM_APWROK_R: length 159.5
  TOP w0.102: RC144.2 68.68,70.46 69.2,70.46 69.31,70.57 UC7.4 69.31,71.4 69.52,71.6 71.07,71.6 v2(71.2,71.48) v5(72,71.48)
  IN1 w0.084: v2(71.2,71.48) 70.5,71.48 69.81,70.79 69.81,64.08 67.86,62.13 67.86,48.09 63.74,43.97 v2(63.74,39.46)
  IN2 w0.089: 152.56,51.41 152.56,52.18 151.47,53.27 151.47,57.55 150.76,58.25 150.76,60.25 150.67,60.34 150.67,62.48 151.13,62.94 151.13,63.42 151,63.54 151,66.28 150.69,66.59 150.69,70.95 150.4,71.24 v2(148.77,71.24)
  IN2 w0.122: v2(63.74,39.46) 64.02,39.75 144.41,39.75 152.56,47.9 152.56,51.41
  BOTTOM w0.076: UC1.AB5 148.64,71.11 v2(148.77,71.24)
PM_LANPHY_ENABLE: length 152.9
  TOP w0.102: RC197.1 166.48,63.66 v2(165.75,62.94) ; v2(265.94,75.01) 265.94,74.47 v1(265.56,74.1) 264.35,72.89 264.35,71.55 264.2,71.4 R180.1
  IN3 w0.089: v2(147.97,65.65) 148.41,65.2 148.41,63.19 148.62,62.99 149.21,62.99 149.77,62.44 153.85,62.44
  IN3 w0.122: 153.85,62.44 154.61,62.44 156.94,64.77 160.17,64.77 161.68,63.26 165.44,63.26 v2(165.75,62.94) 166.02,63.21 166.51,63.21 167.84,64.55 168.35,64.55 168.74,64.93 168.74,65.42 171.04,67.73 171.53,67.73 174.9,71.09 180.61,71.09 180.88,71.37 184.73,71.37 185.21,71.85 188.47,71.85 190.07,73.45 191.23,73.45 192.39,74.6 198.39,74.6 198.61,74.82 198.61,75.74 198.98,76.12 198.98,77.37 200.65,79.04 200.65,80.06 201.85,81.25 205.61,81.25 207.3,82.94 207.88,82.94 210.16,85.22 212.21,85.22 212.79,84.65 219.81,84.65 220.29,85.13 225,85.13 226.54,86.66 228.02,86.66 228.3,86.95 233.86,86.95 234.52,87.6 238.79,87.6 242.86,83.53 242.86,82.78 244.57,81.07 245.94,81.07 247.56,79.45 254.93,79.45 255.72,80.23 258.1,80.23 260.04,82.17 264.28,82.17 266.37,80.09 266.37,75.44 v2(265.94,75.01)
  BOTTOM w0.076: UC1.AM7 147.71,65.39 v2(147.97,65.65)
POA_WAKE#: length 4.7
  TOP w0.102: U38.B68 19.74,10.58 19.32,10.17 18.89,10.17 18.02,9.3 v1(17.89,9.3) 17.77,9.3 R346.2
POWER_SW#_MB: length 352.5
  TOP w0.102: v2(224.82,103.33) 224.81,103.32 SW1.2 SW1.4 ; C340.1 R329.2 13.53,6.26 13.74,6.48 13.74,6.92 v2(13.51,7.15) ; v2(98.88,99.49) 99.26,99.11 v5(99.26,97.89) 99.26,97.08 102.2,94.14 104.6,94.14 v2(105.25,93.5) ; v2(42.61,50.62) 42.61,49.92 41.59,48.91 37.27,48.91 35.41,47.05 35.41,45 JAPS1.11
  IN1 w0.084: v2(218.83,93) 218.16,92.33 207.7,92.33 206.83,91.47 v2(206.83,90.98)
  IN2 w0.122: v2(224.82,103.33) 224.82,98.55 222.92,96.66 220.8,96.66 218.83,94.69 v2(218.83,93)
  IN3 w0.122: v2(206.83,90.98) 206.4,91.41 192.9,91.41 190.3,88.81 189.04,88.81 188.03,87.8 186.07,87.8 185.07,86.8 176.27,86.8 174.65,88.42 167.41,88.42 165.94,89.89 160.19,89.89 159.52,89.23 154.56,89.23 152.84,90.95 152.84,92.52 151.37,93.98 149.64,93.98 148.87,94.75 136.84,94.75 136.43,94.34 130.53,94.34 129.41,95.46 126.99,95.46 126.49,95.96 122.64,95.96 122.15,95.46 114.13,95.46 112.59,93.92 109.22,93.92 109.17,93.97 105.71,93.97 v2(105.25,93.5)
  IN4 w0.084: v2(13.51,7.15) 12.94,7.72 12.94,8.2 10.62,10.52 9.63,10.52 9.05,11.09 9.05,15.52 9.61,16.07 9.61,20.32 8.56,21.37 8.56,21.77 9.25,22.45 9.25,27.94 8.64,28.55 4.33,28.55 1.14,31.73 1.14,37.67 1.46,37.99 4.88,37.99 6.08,39.19 6.08,39.94 8.98,42.84 12.57,42.84 12.87,42.53 15.82,42.53 15.96,42.67 18.05,42.67 18.09,42.62 19.66,42.62 19.76,42.71 20.92,42.71 21.86,43.65 24.66,43.65 25.51,44.5 27.72,44.5 28.64,45.43 30.26,45.43 31.57,46.73 33.05,46.73 36.34,50.02 37.43,50.02 38.76,51.36 41.87,51.36 v2(42.61,50.62) 42.99,50.62 43.73,51.36 48.39,51.36 51.65,54.62 51.65,55.69 53.51,57.55 53.51,60.05 51.39,62.16 51.39,62.54 49.04,64.89 49.04,70.01 49.69,70.66 49.69,77.44 57.73,85.48 60.7,85.48 67.66,92.43 81.16,92.43 83.68,94.95 88.15,94.95 88.76,94.34 96.68,94.34 99.26,96.91 99.26,99.11 v2(98.88,99.49)
POWER_SW_IN#: length 13.2
  TOP w0.102: U38.B67 20.38,11.08 v2(20.73,10.73) ; R327.2 R329.1 v2(14.2,7.22) 14.2,7.24 v1(13.78,7.66) 13.74,7.7 13.12,7.7 C343.1
  BOTTOM w0.102: v2(14.2,7.22) 14.2,7.45 14.57,7.82 17.79,7.82 19.23,9.26 19.97,9.26 20.73,10.01 v2(20.73,10.73)
PROC_OPI_RCOMP: length 3.9
  BOTTOM w0.076: UC1.AY15 142.82,60.02 142.82,59.02 142.86,58.98 142.86,58.78 143.16,58.48
  BOTTOM w0.305: RC237.1 143.59,57.04 143.59,57.77 143.16,58.2 143.16,58.48
PROCHOT#_EC: length 53.3
  TOP w0.102: R342.2 14.85,21.27 v2(15.16,20.95) 14.57,20.36 R334.1 ; R342.2 R335.2 ; R342.2 13.95,22.19 13.72,22.41 Q9.2 ; v2(21.94,20.8) U38.A46
  IN4 w0.084: v2(15.16,20.95) 15.16,20.88 15.65,20.39 15.65,20.11 15.35,19.81 15.29,19.81 14.94,20.16 13.6,20.16 13.45,20.01 13.45,19.06 13.32,18.94 13.07,18.94 12.96,19.05 12.96,21.53 13.06,21.62 13.48,21.62 13.57,21.54 13.57,20.61 13.65,20.52 13.82,20.52 13.9,20.61 13.9,21.54 13.99,21.62 14.15,21.62 14.24,21.54 14.24,20.61 14.32,20.52 14.49,20.52 14.57,20.61 14.57,21.54 14.66,21.62 16.04,21.62 16.5,21.17 16.79,21.17 16.89,21.06 16.89,20.63 15.49,19.23 14.02,19.23 13.91,19.11 13.91,18.83 13.99,18.75 15.51,18.75 17.28,20.52 17.28,21.49 17.36,21.58 17.53,21.58 17.61,21.49 17.61,20.89 17.7,20.8 17.87,20.8 17.95,20.89 17.95,21.15 18.03,21.23 18.2,21.23 18.29,21.15 18.29,20.89 18.37,20.8 18.54,20.8 18.62,20.89 18.62,21.16 18.7,21.25 18.87,21.25 18.96,21.16 18.96,20.89 19.04,20.8 19.21,20.8 19.29,20.89 19.29,21.49 19.37,21.58 19.54,21.58 19.63,21.49 19.63,20.6 19.72,20.5 19.86,20.5 19.96,20.6 19.96,21.49 20.05,21.58 20.21,21.58 20.3,21.49 20.3,19.93 20.4,19.83 20.53,19.83 20.63,19.93 20.63,21.2 20.72,21.28 20.88,21.28 20.97,21.2 20.97,19.38 21.06,19.29 21.22,19.29 21.3,19.37 21.3,20.49 21.4,20.59 21.57,20.59 21.64,20.52 21.64,19.37 21.72,19.29 22.41,19.29 23.15,20.02 23.15,20.25 23.08,20.32 22.64,20.32 22.58,20.39 22.58,21.53 22.48,21.62 22.02,21.62 21.94,21.54 v2(21.94,20.8)
