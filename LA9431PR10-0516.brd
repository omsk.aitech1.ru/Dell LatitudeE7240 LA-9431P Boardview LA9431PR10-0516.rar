# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATDRV#: length 40.2
  TOP w0.102: v2(87.38,12.6) v1(86.64,12.6)
  TOP w0.254: v2(56.59,5.63) 56.59,5.47 56.91,5.16 PR722.2
  IN3 w0.254: v2(87.38,12.6) 87.38,9.5 86.87,8.99 78.41,8.99 74.78,5.36 72.14,5.36 71.6,4.83 63.17,4.83 62.38,5.61 56.6,5.61 v2(56.59,5.63)
  BOTTOM w0.254: PQ800.4 88.16,13.39 v2(87.38,12.6)
BATT_WHITE#: length 96.1
  TOP w0.102: v2(187.1,100.13) v1(190.92,100.13) 193.22,100.13 194.19,101.1 LED7.1 ; R427.2 114.84,110.53 v2(115.39,111.08)
  IN3 w0.122: v2(187.1,100.13) 185.43,100.13 181.43,96.12 180.14,96.12 179.65,95.64 169.99,95.64 167.31,98.32 162.77,98.32 159.07,102.02 159.07,108.57 157.96,109.67 151.69,109.67 151.12,109.11 139.85,109.11 138.94,110.02 138.94,110.95 138.65,111.23 133.82,111.23 133.63,111.05 133.63,109.87 133.12,109.36 127.97,109.36 125.94,111.39 115.7,111.39 v2(115.39,111.08)
BATT_WHITE_LED#: length 30.5
  TOP w0.102: JLED1.2 124.34,99.64 124.97,100.27 124.97,101.22 125.32,101.57 125.32,103.33 124.97,103.68 124.97,108.83 125.91,109.77 125.91,110.78 124.78,111.91 v5(122.86,111.91) 112.15,111.91 112.13,111.93 110.18,111.93 110.17,111.92 109.58,111.92 R429.2
BATT_YELLOW#: length 102.6
  TOP w0.102: v2(107.02,110.69) 107.44,110.27 108.26,110.27 108.45,110.46 R431.2 ; v2(191.55,101.68) 192.25,100.98 v1(193.07,100.98) 193.26,100.98 194.08,101.8 LED7.3
  IN3 w0.122: v2(107.02,110.69) 108.13,111.8 134.01,111.8 134.32,111.48 138.93,111.48 139.28,111.83 157.22,111.83 160.07,108.99 160.07,106.45 160.86,105.65 160.86,103.34 161.37,102.83 166.21,102.83 172.63,96.41 179.36,96.41 183.99,101.04 190.92,101.04 v2(191.55,101.68)
BATT_YELLOW_LED#: length 23.3
  TOP w0.102: JLED1.3 124.33,100.44 124.75,100.86 124.75,101.31 125.1,101.66 125.1,103.23 124.75,103.58 124.75,108.93 125.68,109.86 125.68,110.69 124.88,111.49 v5(117.53,111.49) 114.75,111.49 R433.2
BAY_SMBCLK: length 3
  TOP w0.102: v1(22.85,6.9) 23.24,7.29 R452.2 23.8,7.85 23.94,7.99 U38.A7
BAY_SMBDAT: length 9.6
  TOP w0.102: U38.B7 23.69,10.59 v2(23.55,10.74) ; v2(23.17,6.13) 23.41,5.89 23.41,4.33 R453.2 22.77,3.83 v1(22,3.06)
  BOTTOM w0.102: v2(23.17,6.13) 23.17,6.26 23.8,6.9 23.8,10.48 v2(23.55,10.74)
BBS_BIT: length 25.8
  TOP w0.102: v1(166.74,75.26) 166.57,75.26 166.13,75.7 v2(166.13,75.73) 166.22,75.82 RC287.1 RC218.2
  IN3 w0.089: v2(146.86,76.95) 147.39,76.43 149.15,76.43 149.34,76.24 151.05,76.24 151.82,77 153.58,77 153.85,77.27
  IN3 w0.122: v2(166.13,75.73) 165.71,76.15 165.15,76.15 163.19,78.11 161.53,78.11 160.46,79.18 159.14,79.18 157.4,77.43 156.02,77.43 155.84,77.25 153.86,77.25 153.85,77.27
  BOTTOM w0.076: v2(146.86,76.95) 146.69,76.78 UC1.L8
BC_CLK_ECE1117: length 210.2
  TOP w0.102: v2(179.6,3.15) 179.95,3.5 179.95,3.64 180.25,3.94 181.27,3.94 181.86,4.52 182.88,4.52 183.83,3.57 187.54,3.57 188.93,2.18 194.02,2.18 194.22,2.38 195.68,2.38 195.89,2.18 199.55,2.18 201.22,3.85 201.22,5.12 201.13,5.21 200.57,5.21 200.45,5.33 JKBTP1.7 ; v2(30.85,12.36) 30.82,12.33 U38.A20
  IN2 w0.122: v2(179.6,3.15) 179.84,3.39 179.84,4.56 181.37,6.1 181.37,16.8 179.96,18.22 133.67,18.22 133.6,18.15 132.71,18.15 130.42,20.44 126.13,20.44 125.94,20.63 123.35,20.63 120.99,22.99 93.19,22.99 92.83,22.62 83.59,22.62 83.47,22.75 62.49,22.75 61.96,22.21 61.96,18.92 61.48,18.44 57.93,18.44 57.12,19.26 57.12,20.51 56.14,21.49 51.31,21.49 49.89,20.07 49.33,20.07 48.87,19.61 48.87,16.7 45.75,13.58 40.7,13.58 38.97,11.84 37.27,11.84 36.74,11.31 34.41,11.31 33.94,10.85 33.27,10.85 31.59,12.53 31.45,12.53 31.32,12.4 31.32,12.06 31.19,11.94 30.16,11.94 30.04,12.06 30.04,12.31 30.16,12.43 30.77,12.43 v2(30.85,12.36)
BC_CLK_ECE5048: length 24
  TOP w0.102: U37.A30 26.38,37.27 v2(26.39,37.28) ; v2(23.81,21.44) 23.44,21.06 U38.A43
  IN1 w0.084: v2(23.81,21.44) 23.81,21.66 25.25,23.09 25.25,25.3 24.37,26.17 24.3,26.17 24.21,26.26 24.21,29.81 24.88,30.47 24.88,32.25 24.43,32.7 23.28,32.7 22.9,33.08 22.9,36.27 23.67,37.04 24.28,37.04 24.6,37.36 26.3,37.36 v2(26.39,37.28)
BC_DAT_ECE1117: length 212.3
  TOP w0.102: v2(28.04,11.56) 28.4,11.91 28.58,11.91 28.74,12.08 U38.B21 ; v2(180.18,3.15) 180.18,3.54 180.35,3.71 v3(180.96,3.71) 181.37,3.71 181.95,4.29 182.78,4.29 183.74,3.34 187.45,3.34 188.84,1.95 194.11,1.95 194.32,2.15 195.59,2.15 195.79,1.95 199.65,1.95 201.45,3.75 JKBTP1.9 ; R344.2 35.74,12.09 v2(36.09,11.73)
  IN2 w0.122: v2(180.18,3.15) 180.09,3.24 180.09,4.46 181.62,5.99 181.62,16.9 180.06,18.47 133.57,18.47 133.5,18.4 132.81,18.4 130.52,20.69 126.23,20.69 126.04,20.88 123.45,20.88 121.09,23.24 93.09,23.24 92.72,22.87 83.69,22.87 83.57,22.99 62.39,22.99 61.71,22.31 61.71,19.02 61.38,18.69 58.04,18.69 57.37,19.36 57.37,20.61 56.24,21.73 51.2,21.73 49.78,20.31 49.22,20.31 48.62,19.71 48.62,16.8 45.64,13.83 40.6,13.83 38.86,12.09 37.17,12.09 36.64,11.56 36.27,11.56 v2(36.09,11.73) 35.92,11.56 34.31,11.56 33.84,11.09 33.37,11.09 31.69,12.77 30.12,12.77 29.29,11.94 28.42,11.94 v2(28.04,11.56)
BC_DAT_ECE5048: length 25.7
  TOP w0.102: v2(23.09,37.03) 23.1,37.02 U37.B31 ; v2(23.01,21.61) 23.01,22.75 23.29,23.02 R343.2 ; U38.B45 23.69,18.37 v2(23.69,18.36)
  IN1 w0.084: v2(23.09,37.03) 22.69,36.62 22.69,32.99 23.19,32.49 24.34,32.49 24.66,32.16 24.66,30.56 24,29.9 24,23.62 23.01,22.63 v2(23.01,21.61) 23.44,21.19 23.44,19.32 23.69,19.07 v2(23.69,18.36)
BC_INT#_ECE1117: length 205.5
  TOP w0.102: v2(31.06,11.51) 30.74,11.83 U38.A19 ; JKBTP1.10 201.95,3.45 202.26,3.14 202.26,2.26 201.72,1.72 195.57,1.72 195.47,1.82 v1(195,1.82) 194.43,1.82 194.33,1.72 186.56,1.72 v2(185.38,2.9)
  IN2 w0.122: v2(31.06,11.51) 31.06,11.46 31.7,10.82 31.7,10.49 32.3,9.9 37.59,9.9 41.03,13.33 45.85,13.33 49.28,16.76 49.28,19.33 49.71,19.76 50.04,19.76 51.21,20.93 52.2,20.93 53.82,19.3 56.69,19.3 57.8,18.19 69.07,18.19 69.55,18.67 122.4,18.67 124.11,20.38 125.84,20.38 126.26,19.96 130.55,19.96 132.65,17.86 133.74,17.86 133.83,17.94 179.88,17.94 180.62,17.2 181.13,16.7 181.13,11.99 179.85,10.71 179.85,8.88 178.25,7.27 178.25,3.25 179.02,2.48 181.18,2.48 181.68,2.99 182.71,2.99 182.8,2.9 v2(185.38,2.9)
BC_INT#_ECE5048: length 23.9
  TOP w0.102: v2(26.72,36.75) 26.7,36.77 U37.A29 ; U38.A42 23.94,20.74 v2(23.9,20.78)
  IN1 w0.084: v2(23.9,20.78) 23.9,20.76 24.54,21.4 24.54,21.49 25.48,22.43 25.48,26.8 26.98,28.3 26.98,28.9 25.86,30.02 25.86,32.42 24.77,33.51 23.37,33.51 23.11,33.77 23.11,34.26 23.53,34.68 24.91,34.68 25.87,35.64 25.87,35.9 v2(26.72,36.75)
BCM5882_ALERT#: length 238.5
  TOP w0.102: U37.B62 15.65,33.45 v2(16.43,33.45) ; JUSH1.7 186.26,5.18 186.45,4.99 188.01,4.99 188.61,4.39 192.25,4.39 194.23,6.38 194.23,15.18 194.59,15.53 194.59,19.09 194.34,19.34 194.34,20.19 194.04,20.48 194.04,20.76 192.58,22.22 188.09,22.22 186.37,23.94 186.37,29.98 185.47,30.88 185.47,35.32 v5(186.47,36.31) 187.09,36.93 v2(187.09,37.08)
  IN3 w0.122: v2(187.09,37.08) 186.47,37.7 136.73,37.7 131.9,32.87 131.9,31.68 131.61,31.38 130.12,31.38 128.58,29.84 127.35,29.84 125.03,32.16 122.78,32.16 118.39,36.55 67.09,36.55 65.66,37.99 57.11,37.99 56.34,37.21 50.94,37.21 44.96,31.23 40.79,31.23 39.84,30.28 34.37,30.28 33.31,29.22 31.75,29.22 31.45,29.51 29.69,29.51 27.72,27.54 26.7,27.54 26.39,27.23 24.09,27.23 23.86,26.99 21.43,26.99 20.91,26.47 20.05,26.47 19.46,27.06 17.69,27.06 16.87,27.88 16.87,28.38 17.44,28.96 17.44,32.76 17.24,32.97 16.92,32.97 v2(16.43,33.45)
BEEP: length 408.1
  TOP w0.102: R151.2 273.3,24.57 v2(273.81,25.08) ; v1(207.16,3.8) 206.45,4.51 v2(206.45,5.44) ; v2(28.31,10.63) 28.61,10.63 29.06,11.08 U38.B19
  IN2 w0.122: v2(28.31,10.63) 29.18,10.63 29.57,11.01 31.16,11.01 31.46,10.71 31.46,10.39 32.9,8.94 36.99,8.94 40.14,12.09 45.05,12.09 49.58,16.62 49.58,17.91 50.39,18.72 50.39,19.68 51.13,20.42 52.3,20.42 53.7,19.02 56.6,19.02 57.68,17.95 69.17,17.95 69.65,18.42 122.51,18.42 124.22,20.13 125.73,20.13 126.16,19.71 130.2,19.71 131.22,18.68 131.22,17.78 131.59,17.42 133.66,17.42 133.93,17.69 179.78,17.69 180.88,16.59 180.88,12.09 179.6,10.82 179.6,8.98 178,7.38 178,3.15 178.92,2.23 181.28,2.23 181.79,2.74 182.44,2.74 183.02,2.16 195.49,2.16 197.26,3.93 205.62,3.93 206.41,4.73 206.41,5.4 v2(206.45,5.44)
  IN3 w0.122: v2(206.45,5.44) 208.41,5.44 208.85,5.88 208.85,22.26 209.66,23.07 209.66,25.78 210.23,26.35 210.23,28.34 209.75,28.82 208.75,28.82 204.78,32.79 204.78,36.2 207.65,39.07 207.65,47.46 206.99,48.11 206.99,51.25 207.38,51.64 207.38,55.56 206.77,56.18 205.94,56.18 205.43,56.68 205.43,59.5 206.41,60.48 206.41,64.28 205.96,64.73 205.96,68.18 209.47,71.69 212.13,71.69 212.79,72.35 212.79,76.56 214.69,78.46 218.76,78.46 219.34,77.88 222.76,77.88 225.03,80.15 235.87,80.15 237.62,78.4 242.8,78.4 245.7,75.5 246.85,75.5 247.85,74.5 255.38,74.5 256.75,73.13 258.64,73.13 260.08,71.69 266.24,71.69 266.81,71.13 266.81,49.64 270.68,45.77 270.97,45.77 271.97,44.77 271.97,40.92 274.41,38.48 274.41,29.68 274.29,29.56 274.29,28.34 273.3,27.36 273.3,25.59 v2(273.81,25.08)
BIA_PWM: length 5.6
  TOP w0.102: R95.1 60.09,79.48 LE1.2 60.22,79.35 v1(60.22,78) 60.22,77.85 60.56,77.52 D10.1
BIA_PWM_EC: length 137.6
  TOP w0.102: D10.2 60.37,74.34 59.88,74.83 59.88,76.64 v1(57.28,79.24) 56.67,79.85 v2(56.67,79.99) ; v2(27.85,13.26) 27.97,13.26 28.38,13.67 28.71,13.67 29.12,14.08 U38.B25
  IN2 w0.122: v2(56.67,79.99) 56.67,75.62 54.75,73.7 54.75,68.2 53.6,67.05 53.6,61.6 54.63,60.58 54.63,55.67 54.28,55.32 54.28,50.98 51.52,48.23 50.3,48.23 48.84,49.69 42.95,49.69 37.94,44.68 35.69,44.68 34.75,45.62 32.01,45.62 27.68,41.28 25.35,41.28 24.21,40.14 14.07,40.14 14.02,40.09 11.91,40.09 10.15,38.34 8.26,38.34 7.27,37.35 7.27,33.33 8.11,32.48 8.11,31.59 10.21,29.5 10.21,27.32 10.38,27.15 11.01,27.15 12.72,25.44 12.72,23.9 14.75,21.87 15.41,21.87 16.61,20.68 16.61,19.54 14.74,17.67 14.74,15.78 15.49,15.02 17.11,15.02 18.06,14.08 20.21,14.08 20.31,13.98 23.13,13.98 23.8,13.31 27.8,13.31 v2(27.85,13.26)
BLUE_DOCK: length 127.3
  TOP w0.102: v2(214.88,94.18) 214.88,93.43 214.02,92.57 214.02,89.72 209.35,85.05 R351.1 209.36,80.33 R76.2
  IN2 w0.122: v2(214.88,94.18) 213.76,95.3 209.94,95.3 209.31,94.67 203.32,94.67 201.82,96.17 188.24,96.17 v2(186.88,94.8)
  BOTTOM w0.102: JDOCK1.45 124.45,99.67 125.3,98.82 125.3,98.65 126.84,97.11 126.84,95.96 130.07,92.73 v1(131.64,92.73) 135.41,92.73 137.25,94.56 143.35,94.56 144.02,93.89 145.23,93.89 146.07,93.05 153.76,93.05 155.68,91.13 155.68,89.2 156.9,87.99 160.01,87.99 160.92,87.07 162.51,87.07 163.37,87.93 163.37,88.65 162.74,89.28 162.74,92.28 163.21,92.75 165.66,92.75 166.37,92.04 181.05,92.04 181.38,91.71 183.92,91.71 184.86,92.65 186.07,92.65 186.88,93.46 v2(186.88,94.8)
BOARD_ID: length 10.3
  TOP w0.102: v1(25.35,3) 24.99,3.35 R392.2 C368.1 24.99,5.74 v2(24.97,5.77) ; v2(24.44,11.23) 24.94,10.72 24.94,10.57 25.19,10.32 U38.B10
  BOTTOM w0.102: v2(24.97,5.77) 25.13,5.93 25.13,6.79 24.96,6.97 24.96,10.71 v2(24.44,11.23)
BOOT_1.35V: length 1.8
  TOP w0.102: PR200.2 111.43,10.63 112.26,11.45 v1(112.65,11.45)
BQ24715_REGN: length 114.6
  TOP w0.102: PR711.1 54.89,15.3
  TOP w0.254: v2(83.55,73) v1(80.92,70.36) 80.59,70.04 78.82,70.04 78.58,69.8 78.58,68.54 75.3,65.26 75.3,62.83 73.91,61.45 73.91,51.41 72.54,50.03 72.54,43.89 64.44,35.79 64.44,27.44 63.98,26.98 63.98,19 62.29,17.31 57.45,17.31 57.21,17.07 55.7,17.07 55.03,17.74 53.94,17.74 53.62,17.42 53.62,16.99 54.08,16.53 54.08,16.12 PR711.1 ; PU700.16 53.57,10.14 54.85,11.43 PC709.1 55.89,11.43 56.06,11.59 56.06,13.83 PD702.2 55.57,14.33 v2(54.89,14.33) 54.89,15.3 ; v2(49.56,6.47) 49.22,6.47 48.5,5.75 PR747.1
  IN4 w0.254: v2(54.89,14.33) 53.34,14.33 50.9,11.89 50.9,11 50.32,10.41 50.32,7.24 v2(49.56,6.47)
  BOTTOM w0.254: PR739.1 95.12,80.5 94.29,79.67 93.27,79.67 92.63,79.03 92.63,78.46 91.71,77.53 90.63,77.53 90.21,77.95 86.86,77.95 84.82,75.92 84.82,74.27 v2(83.55,73)
BREATH_LED#: length 302.4
  TOP w0.102: U37.B39 22.18,38.63 22.14,38.59 22.14,38.12 v2(21.79,37.77) ; v2(110.67,99.08) v1(110.67,99.69)
  IN2 w0.122: v2(110.67,99.08) 111.53,99.95 111.99,99.95 114.72,102.68 115.2,102.68 116.71,104.19 116.71,104.67 119.28,107.24 130.94,107.24 134.73,111.04 138.81,111.04 v2(139.38,110.46)
  IN3 w0.122: v2(231.64,108.93) 232.75,107.81 232.75,94.37 231.7,93.32 228.12,93.32 226.11,95.34 224.88,95.34 223.67,96.55 217.07,96.55 216.86,96.75 212.22,96.75 211.99,96.53 207.15,96.53 206.53,97.14 206.53,98.42 206.15,98.81 203.43,98.81 202.77,99.47 201.96,99.47 200.05,101.38 199.18,101.38 198.35,100.54 185.5,100.54 181.33,96.37 180.03,96.37 179.57,95.91 172.43,95.91 166,102.34 161.16,102.34 159.57,103.93 159.57,108.77 157.08,111.26 150.31,111.26 149.48,110.43 149.48,110.27 148.6,109.4 139.94,109.4 139.38,109.96 v2(139.38,110.46) ; v2(21.79,37.77) 21.79,37.58 22.76,36.61 23.26,36.61 23.62,36.97 24.24,36.97 24.79,37.52 24.79,38.82 25.87,39.9 28.03,39.9 29.92,41.79 34.71,41.79 39.69,46.76 55.01,46.76 58.17,49.93 58.17,55.37 57.26,56.29 57.26,59.87 58.17,60.78 58.17,63.01 60.28,65.11 60.28,66.46 59.94,66.8 59.94,68.24 58.58,69.59 58.58,72.67 59.51,73.6 59.51,80.6 63.5,84.59 67.39,84.59 68.15,85.35 69.76,85.35 71.5,87.09 71.5,88.22 74.31,91.03 86.97,91.03 89.75,93.82 95.09,93.82 97.53,96.26 100.3,96.26 103.13,99.08 v2(110.67,99.08)
  BOTTOM w0.102: R436.1 231.7,108.99 v2(231.64,108.93) 231.3,108.59 Q28.1 ; v2(139.38,110.46) 139.45,110.4 JDOCK1.98
BREATH_LED#_Q: length 9.1
  TOP w0.102: v2(230.3,101.07) 229.93,101.43 227.81,101.43 LED1.1 ; v2(231.33,105.36) 231.33,105.43 v1(231.7,105.8)
  IN2 w0.122: v2(231.33,105.36) 231.33,103.03 230.3,102.01 v2(230.3,101.07)
  BOTTOM w0.102: v2(231.33,105.36) 231.3,105.39 Q28.6
BREATH_WHITE_LED#: length 143.2
  TOP w0.102: JLED1.5 124.29,102.04 124.6,102.35 124.6,102.95 123.38,104.16 v2(123.38,105.05)
  IN3 w0.122: v2(232.35,110.68) 233,110.02 233,94.22 231.85,93.07 228.03,93.07 226,95.09 224.78,95.09 223.57,96.3 217.75,96.3 217.05,95.59 213.93,95.59 213.5,96.03 205.34,96.03 204.2,97.17 201.61,97.17 200.32,98.46 185.58,98.46 181.99,94.88 180.65,94.88 180.12,94.35 169.52,94.35 166.79,97.07 161.6,97.07 160.8,97.87 153.91,97.87 147.78,104 147.78,105.51 146.57,106.72 125.04,106.72 v2(123.38,105.05)
  BOTTOM w0.102: v2(232.35,110.68) 232.3,110.73 R436.2
BREATH_WHITE_LED_SNIFF: length 10
  TOP w0.102: R434.1 224.52,99.64 LED1.2 226.83,101.96 228.08,101.96 228.32,101.71 229.43,101.71 230.48,102.77 v1(230.95,102.77)
BST_3V:
  vias: v1(199.54,50.08)
BST_5V:
  vias: v1(194.03,50.06)
BST_+V1.05SP: length 1.2
  TOP w0.102: v1(237.05,70.79) 236.74,71.09 PR301.1
BT_LED#: length 20
  TOP w0.102: v1(204.81,40.75) 204.93,40.87 Q30.1 205.84,40.46 205.63,40.25 R229.1 205.63,39.26 v2(206.01,38.87)
  IN1 w0.084: v2(206.01,38.87) 205.76,38.63 205.76,37.17 205.12,36.53 205.12,32.88 209.39,28.61 210.74,28.61 212.13,30 JMINI1.46
BT_RADIO_DIS#: length 232.5
  TOP w0.102: U37.A13 22.43,28.88 22.82,28.49 22.82,27.96 v2(23,27.77) 22.9,27.77 22.29,27.16 R298.2 ; v2(196.76,33.82) 197.35,33.82 199,32.17 201.57,32.17 201.7,32.04 v1(202.24,32.04) 203.31,32.04 204.01,31.34 204.01,31.01 205.02,30.01 205.45,30.01 205.97,29.49 207.15,29.49 207.7,28.94 R225.1 208.47,28.42 209.17,28.42 209.31,28.56 210.2,28.56 D14.1
  IN3 w0.122: v2(196.76,33.82) 195.53,32.59 194.07,32.59 192.76,33.9 189.84,33.9 188.29,32.35 187.4,32.35 186.36,33.39 186.03,33.39 184.92,34.5 139.54,34.5 133.12,28.09 133.12,27.56 132.64,27.08 132.23,26.67 131.83,26.67 130.75,25.6 130.75,25.15 v2(130.61,25.01)
  BOTTOM w0.102: v2(23,27.77) 23.46,28.23 23.86,28.23 24.12,27.98 24.12,27.75 25.94,25.92 27.85,25.92 28.08,26.15 28.08,34.01 28.94,34.87 28.94,37.3 29.92,38.28 31.48,38.28 40.71,47.51 42.44,47.51 43.48,48.56 45.82,48.56 46.41,47.97 46.95,47.97 48.51,46.41 49.51,46.41 52.65,43.26 55.58,43.26 56.08,42.77 63.31,42.77 65.05,41.02 125.39,41.02 129.29,37.13 129.29,33.05 129.63,32.71 129.63,30.58 130.47,29.74 130.47,25.15 v2(130.61,25.01)
BT_RADIO_DIS#_R: length 10.8
  TOP w0.102: D14.2 210.81,29.62 v1(211.58,30.39) ; D14.2 v2(210.54,29.04) ; D14.2 209.54,29.62 R225.2
  IN1 w0.084: v2(212.67,33.11) 212.62,33.11 210.54,31.03 v2(210.54,29.04)
  BOTTOM w0.102: v2(212.67,33.11) 212.64,33.11 212.09,32.56 212.09,32.13 211.96,32 JMINI1.51
CAM_MIC_CBL_DET#: length 117.5
  TOP w0.102: v2(148.93,80.62) 148.84,80.53 v1(148.84,79.44) 148.84,78.23 149.56,77.52 150.55,77.52 151.15,78.12 152.42,78.12 152.95,77.6 156.55,77.6 157.07,77.08 157.43,77.08 157.63,76.87 160.83,76.87 RC193.2
  IN1 w0.084: v2(65.67,80.39) 65.67,80.93 68.43,83.69 68.51,83.69 69.38,84.55 69.38,85.13 70.51,86.26 70.51,87.07 72.92,89.48 81.35,89.48 82.11,88.73 97.42,88.73 99.19,86.96 101.83,86.96 104.59,89.73 107.06,89.73 111.58,85.2 v2(111.58,84.66) 114.35,81.89 140.06,81.89 140.11,81.94 142.04,81.94 142.28,82.19 148.09,82.19 148.93,81.34 v2(148.93,80.62)
  BOTTOM w0.076: v2(148.93,80.62) 149.02,80.53 149.02,79.6 UC1.F4
  BOTTOM w0.102: JEDP1.30 65.97,76.4 65.67,77.45 v2(65.67,80.39)
CARD_SMBCLK: length 2.5
  TOP w0.102: RP3.5 17.6,18.34 18.05,18.78 18.49,18.78 18.95,18.33 U38.A49
CARD_SMBDAT: length 5
  TOP w0.102: U38.B52 19.71,18.58 19.1,19.19 19.1,19.55 18.81,19.84 RP3.8 v1(17.07,21.05)
CCD_OFF: length 111.8
  TOP w0.102: U37.B43 20.18,38.39 19.65,37.86 v2(19.58,37.86) ; v1(81.1,92.61) 81.52,93.03 v2(81.52,93.76) 81.52,95.67 R102.1
  IN3 w0.122: v2(19.58,37.86) 19.6,37.86 20.81,39.06 24.69,39.06 25.77,40.14 27.93,40.14 29.82,42.04 34.61,42.04 39.59,47.01 54.39,47.01 56.54,49.16 56.54,49.55 57.92,50.94 57.92,55.27 57.01,56.18 57.01,59.62 56.26,60.38 56.26,63.14 56.89,63.77 58.59,63.77 60.03,65.22 60.03,66.35 59.69,66.7 59.69,68.14 58.34,69.49 58.34,72.78 59.26,73.7 59.26,80.7 63.4,84.84 67.29,84.84 68.05,85.6 69.65,85.6 71.25,87.2 71.25,88.32 75.24,92.31 77.78,92.31 79.23,93.76 v2(81.52,93.76)
CD3301_DCIN: length 5.5
  TOP w0.102: v1(1.13,23.15) PR835.2
  TOP w0.254: PU800.1 4.78,23.69 PC813.1 3.99,23.15 PR835.2
CD3301_SDC_IN: length 2.1
  TOP w0.254: PU800.6 7.28,23.11 PR854.2
CD_PBATT_OFF: length 2.9
  TOP w0.254: PR843.1 3.67,32.61 4.78,31.5 PU800.27
CFD_PWRBTN#_XDP: length 3.2
  TOP w0.102: JXDP1.41 68.07,59.63 v1(68.73,58.98) 69.37,58.98 RC107.2
CFG0: length 85.9
  TOP w0.102: JXDP1.9 68.07,51.63 69.11,52.67 v1(70,52.67) 70.88,52.67 v2(70.91,52.71)
  IN2 w0.122: v2(111.51,69.75) 111.96,70.21 112.47,70.21 112.59,70.09 112.59,66.22 111.82,65.45 111.65,65.45 111.15,65.95 110.98,65.95 110.81,65.77 110.81,65.6 111.3,65.11 111.3,64.93 111.11,64.74 110.92,64.74 110.28,65.38 110.11,65.38 109.94,65.21 109.94,65.03 110.59,64.39 110.59,64.21 110.41,64.04 110.24,64.04 109.54,64.75 109.36,64.75 109.19,64.57 109.19,64.4 109.9,63.7 109.9,63.52 109.67,63.3 109.5,63.3 108.75,64.06 108.58,64.06 108.41,63.88 108.41,63.71 109.16,62.96 109.16,62.79 108.98,62.61 108.81,62.61 107.84,63.58 107.72,63.58 107.55,63.41 107.55,63.19 108.47,62.27 108.47,62.1 108.29,61.92 108.12,61.92 107.47,62.58 107.32,62.58 107.15,62.4 107.15,62.21 107.74,61.61 107.74,60.98 103.67,56.91 103.67,56.22 103.79,56.1 105.02,56.1 105.14,55.97 105.14,55.58 105.02,55.45 103.09,55.45 102.82,55.19 102.68,55.19 102.41,55.45 102.22,55.45 101.96,55.2 101.96,55.02 102.16,54.83 102.16,54.65 101.99,54.48 101.81,54.48 101.62,54.68 101.44,54.68 101.27,54.51 101.27,54.33 101.5,54.1 101.5,53.93 101.33,53.76 101.16,53.76 100.93,53.99 100.75,53.99 100.58,53.82 100.58,53.65 100.84,53.38 100.84,53.2 100.68,53.04 100.5,53.04 100.24,53.3 100.06,53.3 99.89,53.13 99.89,52.96 100.12,52.72 100.12,52.55 99.95,52.38 99.78,52.38 99.55,52.61 99.37,52.61 99.13,52.37 75.42,52.37 75.3,52.49 75.3,52.74 75.16,52.88 74.69,52.88 74.56,52.76 74.56,52.51 74.44,52.39 74.2,52.39 74.08,52.51 74.08,52.76 73.95,52.88 73.71,52.88 73.59,52.76 73.59,52.51 73.47,52.39 73.22,52.39 73.1,52.51 73.1,52.76 72.98,52.88 71.08,52.88 v2(70.91,52.71)
  BOTTOM w0.076: v2(111.51,69.75) 111.8,70.05 112.32,70.05 112.44,69.93 112.84,69.93 113,70.1 113.79,70.1 113.83,70.06 114.07,70.06 114.36,70.35 UC1.AC60
  BOTTOM w0.102: RC232.1 109.16,70.46 110.13,70.46 110.24,70.36 110.34,70.36 110.6,70.09 110.9,70.09 111.24,69.75 v2(111.51,69.75)
CFG1: length 83.1
  TOP w0.102: JXDP1.11 v2(65.16,52.13)
  IN2 w0.122: v2(109.78,70.87) 109.78,70.67 108.76,69.66 108.76,66.21 106.64,64.09 106.64,60.58 98.93,52.87 95.68,52.87 95.56,52.99 95.56,53.43 95.43,53.56 95.19,53.56 95.07,53.43 95.07,52.99 94.95,52.87 94.7,52.87 94.58,52.99 94.58,53.43 94.46,53.56 94.21,53.56 94.09,53.43 94.09,52.99 93.97,52.87 93.73,52.87 93.61,52.99 93.61,53.43 93.48,53.56 93.24,53.56 93.12,53.43 93.12,52.99 93,52.87 92.75,52.87 92.63,52.99 92.63,53.43 92.51,53.56 92.26,53.56 92.14,53.43 92.14,52.99 92.02,52.87 91.78,52.87 91.65,52.99 91.65,53.43 91.53,53.56 91.29,53.56 91.17,53.43 91.17,52.99 91.04,52.87 90.8,52.87 90.68,52.99 90.68,53.43 90.56,53.56 90.31,53.56 90.19,53.43 90.19,52.99 90.07,52.87 89.83,52.87 89.7,52.99 89.7,53.43 89.58,53.56 89.34,53.56 89.22,53.43 89.22,52.94 89.14,52.87 88.81,52.87 88.73,52.95 88.73,53.46 88.63,53.56 88.33,53.56 88.24,53.47 88.24,52.95 88.16,52.87 87.84,52.87 87.75,52.95 87.75,53.48 87.68,53.56 87.34,53.56 87.27,53.48 87.27,52.92 87.21,52.87 86.85,52.87 86.78,52.93 86.78,53.47 86.69,53.56 86.37,53.56 86.29,53.47 86.29,52.96 86.19,52.87 85.89,52.87 85.8,52.96 85.8,53.45 85.7,53.56 85.41,53.56 85.31,53.46 85.31,52.97 85.21,52.87 84.92,52.87 84.83,52.96 84.83,53.46 84.73,53.56 84.43,53.56 84.34,53.46 84.34,52.94 84.26,52.87 83.94,52.87 83.85,52.95 83.85,53.47 83.77,53.56 83.45,53.56 83.36,53.47 83.36,52.95 83.28,52.87 82.96,52.87 82.88,52.95 82.88,53.47 82.79,53.56 82.47,53.56 82.39,53.47 82.39,52.95 82.31,52.87 81.98,52.87 81.9,52.95 81.9,53.48 81.83,53.56 81.5,53.56 81.41,53.47 81.41,52.94 81.34,52.87 81,52.87 80.93,52.95 80.93,53.47 80.84,53.56 80.53,53.56 80.44,53.46 80.44,52.95 80.35,52.87 80.03,52.87 79.95,52.94 79.95,53.48 79.87,53.56 79.63,53.56 79.46,53.39 79.46,52.99 79.34,52.87 76.07,52.87 75.56,53.38 66.51,53.38 65.27,52.13 v2(65.16,52.13)
  BOTTOM w0.076: UC1.AC62 113.06,70.39 112.77,70.1 112.51,70.1 112.39,70.22 111.68,70.22 111.57,70.12 111.13,70.12 110.97,70.27 110.69,70.27 110.39,70.57 110.27,70.57 110.1,70.74 109.91,70.74
  BOTTOM w0.102: 109.91,70.74 109.9,70.74 v2(109.78,70.87) 109.78,70.92 109.6,71.09 RC233.1
CFG2: length 81.8
  TOP w0.102: JXDP1.15 v2(65.33,53.13)
  IN1 w0.084: v2(65.33,53.13) 65.78,53.13 65.92,52.99 65.92,52.5 65.84,52.41 65.65,52.41 65.57,52.33 65.57,52.16 65.65,52.08 65.84,52.08 65.92,51.99 65.92,50.62 65.99,50.55 66.23,50.55 66.3,50.62 66.3,73.07 72.06,78.83 78.09,78.83 79.36,80.1 80.03,80.1 80.62,79.51 81.18,79.51 81.92,78.77 88.58,78.77 89.42,77.92 91.44,77.92 94.82,74.55 106.08,74.55 107.25,73.38 108.15,73.38 108.38,73.15 108.38,72.18 109.29,71.27 110.2,71.27 110.44,71.03 v2(110.44,70.94)
  BOTTOM w0.076: v2(110.44,70.94) 110.45,70.94 v1(110.81,70.59) 110.9,70.59 111.11,70.37 111.59,70.37 111.61,70.39 UC1.AC63
CFG3: length 82.9
  TOP w0.102: JXDP1.17 68.71,53.63 68.79,53.72 v2(68.79,54.04) 69.12,54.04 RC99.2
  IN2 w0.122: v2(68.79,54.04) 68.96,53.87 75.77,53.87 76.28,53.36 76.66,53.36 76.78,53.49 76.78,53.93 76.91,54.05 77.15,54.05 77.27,53.93 77.27,53.49 77.39,53.36 77.64,53.36 77.76,53.49 77.76,53.93 77.88,54.05 78.13,54.05 78.25,53.93 78.25,53.49 78.37,53.36 78.73,53.36 79.42,54.05 98.37,54.05 99.92,55.61 99.92,56.19 100.04,56.31 100.81,56.31 100.91,56.41 100.91,56.65 100.76,56.8 100.04,56.8 99.92,56.92 99.92,57.16 100.04,57.29 101.65,57.29 101.84,57.47 101.84,57.64 101.7,57.77 100.04,57.77 99.92,57.9 99.92,58.14 100.04,58.26 102.43,58.26 102.56,58.39 102.56,58.62 102.43,58.75 100.04,58.75 99.92,58.87 99.92,59.12 100.04,59.24 100.68,59.24 100.8,59.36 100.8,59.6 100.68,59.72 100.04,59.72 99.92,59.85 99.92,62.98 101.73,64.79 104.53,64.79 104.68,64.64 104.68,64.35 104.8,64.22 105.04,64.22 105.16,64.35 105.16,64.64 105.29,64.76 105.52,64.76 105.65,64.64 105.65,63.2 105.78,63.07 106.01,63.07 106.14,63.2 106.14,64.64 106.26,64.76 106.61,64.76 108.27,66.42 108.27,67.72 108.03,67.96 107.24,67.96 106.88,68.32 106.88,69.72 109.5,72.34 110.35,72.34 110.47,72.21 110.47,72.05 110.35,71.92 v2(110.27,71.92)
  BOTTOM w0.076: UC1.AA63 112.52,71.01 111.78,71.01 111.44,71.35 111.14,71.35
  BOTTOM w0.102: 111.14,71.35 111,71.35 110.78,71.56 110.39,71.56 110.27,71.69 v2(110.27,71.92)
CFG3_R: length 33.4
  TOP w0.102: v1(71.98,54.58) 71.03,54.58 v2(71.02,54.57) 70.49,54.04 RC99.1 ; v2(62.6,64.13) JXDP1.60
  IN2 w0.122: v2(71.02,54.57) 70.13,54.57 69.94,54.76 69.94,56.03 69.19,56.78 67.69,56.78 67.16,56.25 67.16,55.52 65.52,53.89 64.24,53.89 63.8,53.44 61.98,53.44 61.8,53.26 59.36,53.26 58.9,53.72 58.9,57.62 58.32,58.2 58.32,62.38 60.07,64.13 v2(62.6,64.13)
CFG4: length 84.9
  TOP w0.102: JXDP1.27 64.36,56.13 64.16,55.93 64.16,54.45 64.27,54.34 64.27,53.38 64.12,53.23 64.12,51.17 v2(64.34,50.95) ; RC238.1 108.57,57.7 v1(107.67,58.6) v2(106.99,59.28)
  IN2 w0.089: v2(114.3,70.76) 114.22,70.76 112.89,69.43 112.89,64.38 109.91,61.39
  IN2 w0.122: v2(64.34,50.95) 64.34,50.91 64.05,50.62 63.91,50.62 63.82,50.71 63.82,51.32 63.97,51.47 65.44,51.47 66.85,52.88 70.16,52.88 70.74,52.29 71.09,52.29 71.42,52.63 72.56,52.63 73.07,52.12 100.11,52.12 100.32,52.33 100.5,52.33 100.71,52.12 100.89,52.12 101.05,52.29 101.05,52.46 100.84,52.68 100.84,52.85 101.01,53.02 101.19,53.02 102.09,52.12 102.27,52.12 102.43,52.29 102.43,52.46 101.53,53.37 101.53,53.54 101.7,53.71 101.88,53.71 102.72,52.87 102.9,52.87 103.07,53.03 103.07,53.21 102.22,54.06 102.22,54.23 103.19,55.2 105.27,55.2 105.39,55.33 105.39,56.22 105.27,56.35 104.3,56.35 104.06,56.59 104.06,56.94 106.39,59.28 v2(106.99,59.28) 107.79,59.28 109.91,61.39
  BOTTOM w0.076: v2(114.3,70.76) 114.6,71.06 UC1.AA60
CFG5: length 82.5
  TOP w0.102: JXDP1.29 67.85,56.63 68.36,56.12 68.83,56.12 69,55.96 v1(69.05,55.96) v2(71.65,55.96)
  IN2 w0.089: v2(111.45,71.96) 111.45,72.64 111.81,73 111.81,74.27 111.11,74.97 109.91,74.97
  IN2 w0.122: v2(71.65,55.96) 71.98,55.63 72.46,55.63 72.58,55.51 72.58,55.18 72.71,55.05 72.95,55.05 73.07,55.18 73.07,55.51 73.19,55.63 73.44,55.63 73.56,55.51 73.56,55.18 73.68,55.05 73.93,55.05 74.05,55.18 74.05,55.51 74.17,55.63 74.41,55.63 74.53,55.51 74.53,55.18 74.66,55.05 74.9,55.05 75.02,55.18 75.02,55.51 75.14,55.63 75.39,55.63 75.51,55.51 75.51,55.18 75.63,55.05 75.88,55.05 76,55.18 76,55.51 76.12,55.63 98.54,55.63 98.93,56.02 98.93,63.39 101.15,65.61 101.15,71.72 101.26,71.83 101.52,71.83 101.61,71.74 101.61,69.44 101.71,69.34 102,69.34 102.08,69.43 102.08,71.63 102.22,71.77 102.46,71.77 102.57,71.66 102.57,70.49 102.67,70.39 102.91,70.39 103.06,70.54 103.06,71.7 103.19,71.84 103.44,71.84 103.55,71.73 103.55,71.02 103.67,70.89 103.91,70.89 104.03,71.02 104.03,71.73 104.15,71.85 104.4,71.85 104.52,71.73 104.52,71.02 104.64,70.89 104.89,70.89 105.01,71.02 105.01,71.73 105.14,71.86 105.39,71.86 105.5,71.75 105.5,71.02 105.62,70.89 105.99,70.89 106.12,71.02 106.12,71.68 106.28,71.83 106.93,71.83 108.48,73.38 108.48,74.17 109.27,74.97 109.91,74.97
  BOTTOM w0.076: UC1.Y62 113.06,71.89 112.77,71.59 112.45,71.59 112.23,71.37 111.89,71.37 111.45,71.82 v2(111.45,71.96)
CFG6: length 84
  TOP w0.102: JXDP1.33 65.14,57.63 63.93,56.43 63.93,54.36 64.05,54.24 64.05,53.49 63.87,53.31 63.87,50.85 v2(64.37,50.35)
  IN2 w0.089: 118.73,62.88 118.73,69.73 115.79,72.68 114.03,72.68 v2(113.61,72.26)
  IN2 w0.122: v2(64.37,50.35) 64.77,50.76 64.77,50.85 65.14,51.22 65.54,51.22 66.3,51.98 68.75,51.98 69.23,51.5 73.53,51.5 73.9,51.87 106.08,51.87 109.17,54.95 111.31,54.95 115.7,59.34 115.7,59.84 118.73,62.88
  BOTTOM w0.076: v2(113.61,72.26) 113.64,72.26 113.95,71.95 UC1.Y61
CFG7: length 83.9
  TOP w0.102: v2(65.15,60.63) 65.15,60.32 64.76,59.93 64.76,58.83 65.45,58.13 JXDP1.35
  IN2 w0.089: 109.91,75.35 110.99,75.35 112.51,73.82 112.51,71.47 112.19,71.15 111.65,71.15 v2(110.85,71.94)
  IN2 w0.122: 109.91,75.35 109.02,75.35 108.7,75.03 106.02,75.03 105.9,74.91 105.9,73.87 105.77,73.75 105.53,73.75 105.41,73.87 105.41,74.91 105.29,75.03 105.04,75.03 104.92,74.91 104.92,73.87 104.8,73.75 104.55,73.75 104.43,73.87 104.43,74.91 104.31,75.03 103.6,75.03 100.9,72.32 100.9,65.72 98.68,63.5 98.68,56.13 98.43,55.88 72.74,55.88 72.19,56.44 70.94,56.44 69.56,57.82 68.38,57.82 65.57,60.63 v2(65.15,60.63)
  BOTTOM w0.076: v2(110.85,71.94) 111.21,71.59 111.44,71.59 111.82,71.21 112.3,71.21 112.52,71.43 112.84,71.43 113,71.59 113.79,71.59 113.83,71.56 114.3,71.56 UC1.Y60
CFG8: length 84.2
  TOP w0.102: JXDP1.10 v2(62.6,51.63)
  IN2 w0.122: v2(109.53,73.06) 109.53,72.71 106.63,69.82 106.63,67.84 106.76,67.71 107.89,67.71 108.02,67.58 108.02,66.54 107.89,66.41 106.78,66.41 106.66,66.28 106.66,65.16 106.53,65.04 106.18,65.04 106.06,65.16 106.06,66.5 105.93,66.62 105.59,66.62 105.46,66.5 105.46,65.16 105.33,65.04 105.07,65.04 104.94,65.16 104.94,66.19 104.81,66.32 104.55,66.32 104.42,66.19 104.42,65.16 104.29,65.04 101.63,65.04 99.67,63.08 99.67,55.71 98.26,54.3 76.64,54.3 76.54,54.2 76.54,53.96 76.42,53.84 76.17,53.84 76.05,53.96 76.05,54.2 75.95,54.3 75.61,54.3 75.43,54.12 69.28,54.12 69.15,54.25 69.15,54.95 69.04,55.06 68.48,55.06 68.38,54.95 68.38,53.96 68.29,53.87 67.97,53.87 67.89,53.96 67.89,55.14 67.8,55.22 67.48,55.22 67.4,55.14 67.4,53.96 67.31,53.87 66.99,53.87 66.91,53.95 66.91,54.55 66.83,54.63 66.65,54.63 66.42,54.41 66.42,53.99 65.98,53.55 64.26,53.55 64.12,53.41 64.12,52.66 63.98,52.52 62.74,52.52 62.6,52.37 v2(62.6,51.63)
  BOTTOM w0.076: 111.14,72.41 111.58,72.41 111.84,72.16 112.51,72.16 112.52,72.18 112.84,72.18 UC1.V62
  BOTTOM w0.102: 111.14,72.41 110.17,72.41 v2(109.53,73.06) 109.33,72.87 RC241.1
CFG9: length 83.4
  TOP w0.102: JXDP1.12 63.48,52.13 63.64,52.3 v2(63.64,53.87)
  IN2 w0.122: v2(110.11,73.18) 109.72,73.57 109.37,73.57 106.2,70.4 105.48,70.4 104.46,69.37 104.46,66.58 103.32,65.45 101.68,65.45 99.42,63.19 99.42,55.82 98.74,55.14 98.35,55.14 98.26,55.04 98.26,54.65 98.16,54.55 97.89,54.55 97.77,54.67 97.77,55.01 97.65,55.13 97.41,55.13 97.28,55.01 97.28,54.67 97.16,54.55 96.92,54.55 96.8,54.67 96.8,55.01 96.68,55.13 96.43,55.13 96.31,55.01 96.31,54.67 96.19,54.55 95.94,54.55 95.82,54.67 95.82,55.01 95.7,55.13 95.46,55.13 95.33,55.01 95.33,54.67 95.21,54.55 94.97,54.55 94.85,54.67 94.85,55.01 94.72,55.13 94.48,55.13 94.36,55.01 94.36,54.67 94.24,54.55 93.99,54.55 93.87,54.67 93.87,55.01 93.75,55.13 93.51,55.13 93.38,55.01 93.38,54.67 93.26,54.55 93.02,54.55 92.9,54.67 92.9,55.01 92.77,55.13 92.53,55.13 92.41,55.01 92.41,54.67 92.29,54.55 92.04,54.55 91.92,54.67 91.92,55.01 91.8,55.13 91.55,55.13 91.43,55.01 91.43,54.67 91.31,54.55 91.07,54.55 90.94,54.67 90.94,55.01 90.82,55.13 90.58,55.13 90.46,55.01 90.46,54.67 90.34,54.55 90.09,54.55 89.97,54.67 89.97,55.01 89.85,55.13 89.6,55.13 89.48,55.01 89.48,54.67 89.36,54.55 89.12,54.55 88.99,54.67 88.99,55.01 88.87,55.13 88.63,55.13 88.51,55.01 88.51,54.67 88.38,54.55 88.14,54.55 88.02,54.67 88.02,55.01 87.9,55.13 87.65,55.13 87.53,55.01 87.53,54.67 87.41,54.55 71.77,54.55 69.29,57.03 67.43,57.03 66.9,56.5 66.9,55.62 65.42,54.13 63.89,54.13 63.64,53.89 v2(63.64,53.87)
  BOTTOM w0.076: UC1.V61 113.69,72.93 113.18,72.93 112.94,72.69 112.94,72.52 112.77,72.34 112.28,72.34 112.26,72.33 111.91,72.33 111.58,72.66 110.63,72.66 v2(110.11,73.18) 109.91,73.38
  BOTTOM w0.102: RC240.1 109.53,73.76 109.91,73.38
CFG10: length 113.1
  TOP w0.102: v2(62.6,52.93) 62.4,53.13 JXDP1.16 ; v2(104.47,56.76) 103.77,56.06 RC239.1 103.04,56.06 v1(102.48,55.5)
  IN1 w0.084: v2(114.21,72.25) 114.21,72.5 112.91,73.8 109.69,73.8 109.06,74.44 109.06,75.79 108.19,76.66 94.4,76.66 92.09,78.98 91.13,78.98 89.45,80.67 83.66,80.67 82.91,81.42 77.33,81.42 75.58,79.68 72.01,79.68 65.66,73.33 65.66,57.22 65.49,57.04 64.55,57.04 64.2,56.68 64.2,54.84 63.94,54.58 62.64,54.58 62.45,54.38 62.45,53.09 v2(62.6,52.93)
  IN2 w0.089: v2(114.21,72.25) 114.21,72.17 114.68,71.7 115.39,71.7 116.23,70.87 116.51,70.87 117.96,69.42 117.96,67.26 117.78,67.08 117.78,62.71 115.5,60.44 115.5,59.42 112.11,56.02 110.72,56.02 110.09,56.65
  IN2 w0.122: v2(104.47,56.76) 104.48,56.76 104.6,56.65 110.09,56.65
  BOTTOM w0.076: UC1.V60 114.6,72.67 114.21,72.28 v2(114.21,72.25)
CFG11: length 82.3
  TOP w0.102: JXDP1.18 62.47,53.63 63.17,52.93 v2(63.23,52.93)
  IN1 w0.084: v2(63.23,52.93) 62.66,53.51 62.66,54.16 62.86,54.37 63.91,54.37 64.02,54.25 65.68,54.25 65.87,54.44 65.87,73.24 71.89,79.25 77.38,79.25 79.34,81.21 82.82,81.21 83.58,80.46 89.36,80.46 91.05,78.77 92,78.77 94.53,76.24 107.05,76.24 107.3,75.98 107.3,75.48 109.19,73.59 110.31,73.59 v2(110.72,73.19)
  BOTTOM w0.076: v2(110.72,73.19) 111.08,72.82 111.61,72.82 111.91,73.11 112.27,73.11 112.46,72.93 112.84,72.93 113,73.09 113.79,73.09 113.83,73.06 114.3,73.06 UC1.U60
CFG12: length 82.6
  TOP w0.102: JXDP1.28 62.99,56.13 64.53,57.68 v2(64.53,60.65)
  IN2 w0.089: v2(111.17,74.33) 110.79,73.95 109.91,73.95
  IN2 w0.122: v2(64.53,60.65) 65.13,60.06 65.44,60.06 68.21,57.28 69.4,57.28 71.88,54.8 76.35,54.8 76.45,54.9 76.45,55.29 76.54,55.38 76.84,55.38 76.94,55.28 76.94,54.89 77.03,54.8 77.33,54.8 77.43,54.89 77.43,55.3 77.51,55.38 77.83,55.38 77.91,55.3 77.91,54.89 78,54.8 78.31,54.8 78.4,54.89 78.4,55.3 78.49,55.38 78.8,55.38 78.89,55.3 78.89,54.88 78.97,54.8 79.29,54.8 79.38,54.89 79.38,55.3 79.46,55.38 79.78,55.38 79.86,55.3 79.86,54.88 79.95,54.8 80.25,54.8 80.35,54.9 80.35,55.28 80.45,55.38 80.75,55.38 80.84,55.29 80.84,54.89 80.92,54.8 81.24,54.8 81.33,54.88 81.33,55.29 81.42,55.38 81.73,55.38 81.81,55.29 81.81,54.89 81.9,54.8 82.21,54.8 82.3,54.89 82.3,55.29 82.4,55.38 82.69,55.38 82.79,55.28 82.79,54.89 82.88,54.8 83.19,54.8 83.28,54.89 83.28,55.29 83.38,55.38 83.67,55.38 83.76,55.29 83.76,54.89 83.86,54.8 84.15,54.8 84.25,54.9 84.25,55.28 84.35,55.38 84.65,55.38 84.74,55.29 84.74,54.9 84.84,54.8 85.13,54.8 85.23,54.9 85.23,55.29 85.32,55.38 85.62,55.38 85.72,55.29 85.72,54.89 85.8,54.8 86.11,54.8 86.2,54.9 86.2,55.29 86.3,55.38 86.6,55.38 86.69,55.29 86.69,54.89 86.78,54.8 87.1,54.8 87.18,54.88 87.18,55.3 87.26,55.38 98.64,55.38 99.17,55.92 99.17,63.29 102.71,66.82 102.71,69.84 103.51,70.64 106.1,70.64 109.4,73.95 109.91,73.95
  BOTTOM w0.076: UC1.T63 112.56,74.05 111.45,74.05 v2(111.17,74.33)
CFG13: length 82.8
  TOP w0.102: v2(65.14,62.76) 64.61,62.76 64.01,62.17 64.01,57.77 62.87,56.63 JXDP1.30
  IN1 w0.084: v2(110.61,74.4) 110.23,74.02 109.78,74.02 109.27,74.52 109.27,75.88 108.27,76.87 94.49,76.87 92.17,79.19 91.22,79.19 89.53,80.88 83.75,80.88 82.99,81.64 82.54,81.64 82.45,81.72 82.45,82.14 82.37,82.22 82.2,82.22 82.12,82.14 82.12,81.72 82.03,81.64 81.87,81.64 81.78,81.72 81.78,82.16 81.7,82.24 81.53,82.24 81.45,82.16 81.45,81.72 81.36,81.64 81.2,81.64 81.11,81.72 81.11,82.16 81.03,82.24 79.62,82.24 79.53,82.16 79.53,81.72 79.45,81.64 79.28,81.64 79.2,81.72 79.2,82.16 79.11,82.24 78.94,82.24 78.86,82.16 78.86,81.72 78.78,81.64 78.61,81.64 78.53,81.72 78.53,82.14 78.44,82.22 78.27,82.22 78.19,82.14 78.19,81.72 78.11,81.64 77.25,81.64 76.16,80.55 75.14,80.55 75.06,80.46 75.06,79.99 74.97,79.91 74.81,79.91 74.72,79.99 74.72,80.46 74.64,80.55 73.74,80.55 73.66,80.46 73.66,79.98 73.57,79.9 73.41,79.9 73.32,79.98 73.32,80.46 73.24,80.55 72.58,80.55 65.43,73.39 65.43,63.05 v2(65.14,62.76)
  BOTTOM w0.076: UC1.T62 112.99,73.82 111.15,73.82 110.61,74.37 v2(110.61,74.4)
CFG14: length 83.1
  TOP w0.102: v2(63.5,61.58) 63.5,58.78 62.36,57.63 JXDP1.34 ; v1(113.93,74.6) 114.29,74.24 v2(114.29,73.76)
  IN1 w0.084: v2(63.5,61.58) 63.5,62.81 65,64.32 65,68.36 64.92,68.44 64.33,68.44 64.25,68.53 64.25,68.7 64.33,68.78 64.92,68.78 65,68.86 65,69.03 64.92,69.12 64.33,69.12 64.25,69.2 64.25,69.37 64.33,69.45 64.92,69.45 65,69.53 65,69.7 64.92,69.79 64.33,69.79 64.25,69.87 64.25,70.04 64.33,70.12 64.92,70.12 65,70.21 65,70.37 64.92,70.46 64.33,70.46 64.25,70.54 64.25,70.71 64.33,70.79 64.92,70.79 65,70.88 65,71.04 64.92,71.13 64.33,71.13 64.25,71.21 64.25,71.38 64.33,71.46 64.92,71.46 65,71.55 65,73.57 72.41,80.97 75.98,80.97 77.68,82.66 82.56,82.66 83.92,81.3 90.83,81.3 94.83,77.3 108.45,77.3 110.98,74.77 111.26,74.77 111.89,74.13 113.92,74.13 114.29,73.76 v2(114.29,73.76)
  BOTTOM w0.076: UC1.T61 114.29,73.83 v2(114.29,73.76)
CFG15: length 83.2
  TOP w0.102: v2(62.92,61.65) 62.92,61.57 63.22,61.26 63.22,59.05 62.3,58.13 JXDP1.36
  IN1 w0.084: v2(62.92,61.65) 63.08,61.81 63.08,62.82 63.89,63.63 63.89,71.97 64.58,72.67 64.58,73.44 68.09,76.94 68.09,77.81 68.51,78.23 69.3,78.23 72.25,81.18 75.89,81.18 77.59,82.87 83.14,82.87 83.57,82.44 84.96,82.44 85.26,82.14 92.01,82.14 93.63,80.52 97.79,80.52 97.87,80.44 97.87,79.57 97.95,79.49 98.12,79.49 98.21,79.57 98.21,80.44 98.29,80.52 98.46,80.52 98.54,80.44 98.54,79.57 98.62,79.49 98.79,79.49 98.88,79.57 98.88,80.44 98.96,80.52 99.13,80.52 99.21,80.44 99.21,79.57 99.3,79.49 99.46,79.49 99.55,79.57 99.55,80.44 99.63,80.52 100.24,80.52 101.21,79.55 106.66,79.55 108.77,77.44 110.02,77.44 110.56,76.91 110.56,75.71 111.87,74.4 114.41,74.4 114.92,73.89 v2(114.92,73.76)
  BOTTOM w0.076: v2(114.92,73.76) 114.92,73.85 UC1.T60
CFG16: length 83.5
  TOP w0.102: JXDP1.6 62.39,50.63 v2(62.79,51.03)
  IN1 w0.084: v2(62.79,51.03) 63.16,51.4 65.57,51.4 65.71,51.26 65.71,50.44 65.81,50.34 66.4,50.34 66.51,50.45 66.51,70.4 69.5,73.4 69.5,75.6 72.52,78.62 78.18,78.62 79.22,79.67 80,79.67 80.44,79.22 81.11,79.22 81.78,78.56 88.49,78.56 89.34,77.71 91.35,77.71 94.73,74.34 105.98,74.34 107.16,73.15 107.93,73.15 108.17,72.9 108.17,71.49 109.21,70.45 110.99,70.45 v2(111.28,70.74)
  BOTTOM w0.076: UC1.AA62 113.24,71.08 113.24,71.08 113.24,71.08 112.84,70.68 111.34,70.68 v2(111.28,70.74)
CFG17: length 83.7
  TOP w0.102: v2(109.64,71.89) 109.63,71.88 v1(108.93,71.88) ; v2(63.4,51) 63.4,50.88 62.66,50.13 JXDP1.4
  IN2 w0.122: v2(109.64,71.89) 109.4,71.89 109.1,71.58 109.1,71.41 109.36,71.15 109.36,71 109.16,70.81 109.01,70.81 108.75,71.07 108.58,71.07 108.41,70.89 108.41,70.72 108.84,70.29 108.84,70.19 108.61,69.96 108.48,69.96 108.06,70.38 107.89,70.38 107.13,69.62 107.13,68.9 107.24,68.79 107.99,68.79 108.51,68.26 108.51,66.32 106.39,64.19 106.39,60.68 103.37,57.67 103.2,57.67 102.88,57.99 102.71,57.99 102.53,57.82 102.53,57.65 102.86,57.32 102.86,57.15 102.68,56.98 102.51,56.98 102.19,57.3 102.02,57.3 101.84,57.13 101.84,56.96 102.17,56.63 102.17,56.46 101.99,56.29 101.82,56.29 101.5,56.61 101.33,56.61 101.15,56.44 101.15,56.27 101.48,55.94 101.48,55.77 101.3,55.6 101.13,55.6 100.81,55.92 100.64,55.92 100.47,55.75 100.47,55.58 100.79,55.25 100.79,55.08 100.61,54.91 100.44,54.91 100.12,55.23 99.95,55.23 99.78,55.06 99.78,54.89 100.1,54.56 100.1,54.39 99.93,54.22 99.75,54.22 99.43,54.54 99.26,54.54 99.09,54.37 99.09,54.2 99.41,53.87 99.41,53.7 99.03,53.33 98.83,53.33 98.73,53.43 98.73,53.73 98.66,53.8 98.33,53.8 98.24,53.72 98.24,53.21 98.15,53.12 97.85,53.12 97.76,53.21 97.76,53.72 97.67,53.8 97.35,53.8 97.27,53.72 97.27,53.21 97.17,53.12 96.87,53.12 96.78,53.21 96.78,53.71 96.69,53.8 96.39,53.8 96.29,53.71 96.29,53.2 96.21,53.12 95.88,53.12 95.8,53.19 95.8,53.68 95.68,53.8 79.52,53.8 78.84,53.12 76.17,53.12 75.66,53.63 66.41,53.63 65.49,52.71 64.53,52.71 63.4,51.58 v2(63.4,51)
  BOTTOM w0.076: 111.14,71.15 111.41,71.15 111.72,70.85 112.77,70.85 113,71.08 113,71.26 113.18,71.43 113.42,71.43 113.67,71.18 UC1.AA61
  BOTTOM w0.102: v2(109.64,71.89) 109.64,71.82 110.12,71.35 110.72,71.35 110.92,71.15 111.14,71.15
CFG18: length 83.1
  TOP w0.102: v2(109.97,74.4) v1(109.23,74.4) ; v2(62.61,55.13) JXDP1.24
  IN1 w0.084: v2(62.61,55.13) 62.61,54.94 62.76,54.79 63.21,54.79 63.3,54.87 63.3,55.74 63.38,55.83 63.55,55.83 63.63,55.74 63.63,54.87 63.71,54.79 63.85,54.79 63.99,54.93 63.99,57.35 64.07,57.44 65.38,57.44 65.45,57.51 65.45,57.68 65.36,57.77 64.07,57.77 63.99,57.86 63.99,62.84 65.22,64.06 65.22,73.48 72.49,80.76 76.07,80.76 77.76,82.45 82.47,82.45 83.84,81.09 90.74,81.09 94.75,77.08 108.36,77.08 109.97,75.48 v2(109.97,74.4)
  BOTTOM w0.076: v2(109.97,74.4) 110.77,73.6 112.44,73.6 UC1.U63
CFG19: length 82.5
  TOP w0.102: JXDP1.22 62.31,54.63 63.05,53.89 v2(63.06,53.89)
  IN1 w0.084: v2(111.42,73.19) 111.24,73.19 110.7,72.64 109.38,72.64 109.02,73.01 109.02,73.47 107.09,75.4 107.09,75.9 106.96,76.03 94.44,76.03 91.91,78.56 89.87,78.56 89.14,79.29 89.14,79.86 88.76,80.24 83.49,80.24 82.73,81 79.42,81 77.47,79.04 71.97,79.04 66.08,73.15 66.08,53.69 65.93,53.53 64.35,53.53 64.23,53.42 64.23,52.39 64.11,52.26 63.76,52.26 63.63,52.39 63.63,53.31 v2(63.06,53.89)
  BOTTOM w0.076: v2(111.42,73.19) 111.57,73.34 112.28,73.34 112.52,73.09 112.77,73.09 113.06,73.39 UC1.U62
CFG_RCOMP: length 11.8
  IN4 w0.084: v2(107.39,66.83) 107.82,66.83 109.56,68.57 109.56,70.05 109.84,70.33 110.54,70.33 110.82,70.61 110.82,70.97 111.02,71.17 112.35,71.17 112.45,71.27 112.45,72.34 v2(112.07,72.72)
  BOTTOM w0.102: RC235.1 v2(107.39,66.83) 107.39,65.94 v1(107.47,65.86)
  BOTTOM w0.178: v2(112.07,72.72) 112.15,72.64 UC1.V63
CHAGER_SRC: length 1.2
  TOP w0.102: 62.54,15.05 v1(62.54,16.2)
  vias: v3(57.76,13.79) v3(58.39,13.8) v3(59.04,13.78) v3(59.65,13.6) v3(61.24,14.27) v3(61.24,13.61) v3(61.94,14.27) v3(61.94,13.61)
CHARGE_EN: length 1.9
  TOP w0.102: U37.A45 17.93,40.23 18.34,40.64 R313.2
CHARGE_PBATT: length 9.4
  TOP w0.102: v2(27.08,26.64) 27.1,26.62 27.1,25.21 T110.1 ; v2(23.42,30.58) 23.68,30.32 U37.B16
  BOTTOM w0.102: v2(23.42,30.58) 23.74,30.26 23.99,30.26 24.63,29.63 26.47,29.63 27.08,29.02 27.08,26.65 v2(27.08,26.64)
CHARGER_CELL_PIN: length 86.9
  TOP w0.102: v1(87.31,11.09) 88.19,11.96 v2(88.19,12.62)
  TOP w0.254: v2(129.15,8.48) 129.18,8.45 PD818.2 ; v2(55.26,5.47) 55.46,5.47 55.82,5.12 PR750.1
  IN1 w0.254: v2(88.19,12.62) 88.19,11.35 91.06,8.48 106.03,8.48 106.22,8.67 111.18,8.67 111.94,9.44 119.11,9.44 120,8.55 121.34,8.55 121.76,8.97 128.66,8.97 v2(129.15,8.48)
  IN3 w0.254: v2(88.19,12.62) 87.71,13.11 86.84,13.11 86.51,12.78 86.51,9.96 85.95,9.4 78.24,9.4 74.61,5.77 71.97,5.77 71.43,5.23 63.34,5.23 62.45,6.12 56.38,6.12 55.73,5.47 v2(55.26,5.47)
CHARGER_SMBCLK: length 73.4
  TOP w0.102: PU700.9 53.07,5.74 52.93,5.61 52.93,5.45 53.07,5.31 53.27,5.31 53.78,4.8 53.89,4.8 v2(54.04,4.95) ; v2(20.9,18.48) 20.91,18.48 21.19,18.76 U38.B50 ; v2(33.9,23.66) 33.9,24.62 34.53,25.26 R350.2
  IN1 w0.084: v2(39.85,7.21) 39.66,7.03 39.42,7.03 39.15,7.3 38.06,7.3 36.66,5.89 35.2,5.89 34.47,6.63 32.58,6.63 31.54,7.67 27.99,7.67 27.2,6.88 25.02,6.88 24.58,7.32 23.05,7.32 22.62,7.75 22.62,8.46 21.28,9.8 21.1,9.8 20.33,10.57 20.33,13.54 20.59,13.8 20.79,13.8 21.37,14.38 21.37,14.98 20.99,15.36 20.46,15.36 20.24,15.58 20.24,18.1 20.63,18.48 v2(20.9,18.48)
  IN2 w0.122: v2(33.9,23.66) 33.85,23.61 31.6,23.61 30.14,22.16 24.67,22.16 23.86,22.96 21.96,22.96 20.61,21.61 20.61,18.77 v2(20.9,18.48) ; v2(54.04,4.95) 53.88,4.8 53.79,4.8 53.46,5.13 52.7,5.13 52.37,4.8 49.7,4.8 48.43,6.07 45.88,6.07 44.7,4.9 41.23,4.9 40.91,5.21 40.91,6.68 40.55,7.05 40.01,7.05 v2(39.85,7.21)
CHARGER_SMBDAT: length 58.6
  TOP w0.102: U38.A47 21.44,21.26 v2(21.32,21.37) 21.13,21.56 R348.2 ; PU700.8 52.57,5.75 52.7,5.61 52.7,5.36 52.98,5.08 53.18,5.08 v3(53.42,4.84) 53.68,4.57 53.86,4.57 v2(54.06,4.37)
  IN1 w0.084: v2(21.32,21.37) 21.01,21.06 21.01,19.23 20.54,18.76 20.54,18.69 20.03,18.18 20.03,15.49 20.37,15.15 20.9,15.15 21.16,14.89 21.16,14.47 20.7,14.01 20.5,14.01 20.12,13.63 20.12,10.48 21.01,9.59 21.19,9.59 22.41,8.37 22.41,7.67 22.96,7.11 24.44,7.11 24.88,6.67 27.29,6.67 28.07,7.45 31.45,7.45 32.49,6.41 34.38,6.41 35.12,5.68 36.75,5.68 38.15,7.09 39.06,7.09 39.33,6.82 39.66,6.82 v2(39.85,6.63)
  IN2 w0.122: v2(54.06,4.37) 53.88,4.55 53.68,4.55 53.35,4.88 52.81,4.88 52.48,4.55 49.6,4.55 48.32,5.82 45.98,5.82 44.81,4.65 41.12,4.65 40.67,5.1 40.67,6.58 40.45,6.8 40.01,6.8 v2(39.85,6.63)
CHG_LGATE: length 5.2
  IN2 w1.016: 56.73,9.05 59.93,5.85
  BOTTOM w0.102: v3(54.38,9.47) 53.96,9.47 v1(53.76,9.68)
  vias: v3(55.04,9.47) v3(60.35,4.98) v3(61.04,4.98)
CHG_UGATE: length 16.7
  IN2 w1.016: 69.11,12.52 68.12,11.53 60.19,11.53 59.56,12.15 56.81,12.15 55.83,13.13 54.31,13.13 53.7,12.52
  vias: v1(68.54,14.72) v3(52.76,11.35) v3(52.76,10.69) v3(68.91,13.69) v3(69.55,13.69)
CHGVR_DCIN: length 2.1
  TOP w0.254: PR833.2 2.91,26.06 2.91,26.26 3.25,26.6 PU800.35
CLK_27M_IN: length 6.6
  TOP w0.089: U6.K1 191.26,78.95 190.45,78.14
  TOP w0.203: R66.1 187.06,77.05 R107.2 187.13,77.11 187.64,76.61 188.49,76.61 189.15,77.27 v1(189.15,77.38) 189.69,77.38 190.45,78.14
CLK_27M_IN_R: length 6.2
  TOP w0.203: C42.1 188.02,77.11 187.52,77.62 187.52,77.86 187.35,78.03 R107.1 186.88,78.03 186.59,77.74 186.59,76.72 186.3,76.43 185.15,76.43 184.16,77.42 Y1.1
CLK_27M_OUT: length 7
  TOP w0.089: U6.L1 191.07,78.3 190.42,77.65
  TOP w0.203: 190.42,77.65 v1(188.9,76.12) C43.1 187.06,75.23 R66.2 185.88,75.21 Y1.3
CLK_BIASREF: length 6.1
  BOTTOM w0.076: 136.13,85.57 v1(136.23,85.47) 136.23,82.55 135.64,81.96 135.64,81.78 136,81.43 UC1.C26
  BOTTOM w0.102: RC45.1 135.31,86.4 136.13,85.57
CLK_DDC2_DOCK: length 120.1
  TOP w0.102: v2(215.37,81.66) 215.32,81.61 215.32,80.48 R77.2
  IN1 w0.084: v2(124.99,110.01) 124.83,109.84 124.83,107.58 125.35,107.06 139.08,107.06 140.59,105.56 140.59,104.63 141.91,103.31 144.41,103.31 148.53,99.18 148.53,97.9 150.63,95.8 155.25,95.8 156.55,94.5 165.43,94.5 167.52,92.41 181.88,92.41 185.02,95.55 187.22,95.55 188.78,97.12 194.53,97.12 195.97,95.68 195.97,95.32 196.33,94.97 200.84,94.97 204.26,91.54 204.26,90.4 207.16,87.5 207.16,85.7 206.31,84.85 206.31,82.97 205.85,82.5 205.57,82.5 v2(205.35,82.28)
  IN2 w0.122: v2(215.37,81.66) 215.14,81.43 215.14,81.13 214.89,80.88 213.12,80.88 211.55,82.45 205.51,82.45 v2(205.35,82.28)
  BOTTOM w0.102: v2(124.99,110.01) 124.81,109.83 124.81,109.74 124.95,109.6 JDOCK1.48
CLK_KBD: length 203.7
  TOP w0.102: U38.A38 25.94,20.7 v2(26,20.76) 26.51,21.27 26.51,21.91 R354.2
  IN1 w0.084: v2(45.94,22.35) 46.16,22.13 46.32,22.13 46.54,22.36 46.54,25.07 49.01,27.54 49.01,28.4 50.15,29.54 51.99,29.54 52.5,29.03 54.6,29.03 56.31,30.75 58.14,30.75 59.02,31.63 59.02,38.05 57.43,39.63 57.43,47.63 58.73,48.92 58.73,55.19 60.68,57.15 60.68,64.71 62.32,66.36 62.32,69.17 59.7,71.79 59.7,77.86 63.3,81.46 63.82,81.46 67.41,85.04 67.41,86.95 72.05,91.59 83.23,91.59 83.98,90.84 88.24,90.84 91.18,93.78 102.81,93.78 105.15,96.11 114.43,96.11 116.83,98.51 116.83,107.18 114.97,109.03 112.33,109.03 112.25,108.95 112.25,108.42 112.4,108.27 v2(112.42,108.27)
  IN4 w0.084: v2(45.94,22.35) 45.74,22.16 39,22.16 38.9,22.26 37.78,22.26 37.31,21.79 37.31,21.27 36.39,20.35 32.21,20.35 31.93,20.63 29.64,20.63 28.77,19.76 27.02,19.76 26.02,20.76 v2(26,20.76)
  BOTTOM w0.102: v2(112.42,108.27) 112.27,108.42 112.27,111.18 112.73,111.63 132.8,111.63 133.59,110.85 133.59,109.74 133.45,109.6 JDOCK1.78
CLK_MSE: length 176.4
  TOP w0.102: R356.2 26.02,22.19 26.02,21.41 v2(26.04,21.4) 26.04,21.41 25.44,20.82 U38.A39
  IN1 w0.084: v2(131.88,98.09) 132.04,98.25 132.04,99.71 131.73,100.03 128.93,100.03 126.87,102.08 121.67,102.08 114.78,95.19 105.12,95.19 103.08,93.14 91.44,93.14 88.5,90.21 83.64,90.21 82.88,90.96 72.31,90.96 68.04,86.69 68.04,84.61 64.51,81.09 64.51,80.64 v2(64.66,80.5)
  IN4 w0.084: v2(26.04,21.4) 26.47,21.83 28.19,21.83 28.98,21.05 32.1,21.05 32.38,20.77 35.69,20.77 37.63,22.71 38.78,22.71 40.16,24.09 42.83,24.09 43.38,23.54 45.79,23.54 48.92,26.67 48.92,28.6 51,30.68 51,34.19 60.98,44.17 61.6,44.17 63.37,45.95 63.37,48.7 61.57,50.51 61.57,64.62 63.42,66.48 63.42,73.85 65.99,76.42 65.99,77.14 64.41,78.71 64.41,80.25 v2(64.66,80.5)
  BOTTOM w0.102: JDOCK1.71 131.95,99.73 132.06,99.61 132.06,98.27 v2(131.88,98.09)
CLK_PCI_5048: length 4.1
  TOP w0.102: R324.1 RC61.2 v1(27.66,35.65) 27.53,35.65 26.91,36.27 U37.A28
CLK_PCI_DOCK: length 114
  TOP w0.102: v2(172.26,53.7) 171.17,53.7 165.14,47.66 v1(161.39,47.66) 153.9,47.66 152.21,49.35 152.21,51.79 151.45,52.55 150.53,52.55 150.29,52.31 150.29,51.03 149.53,50.27 RC64.2
  IN2 w0.122: v2(172.26,53.7) 172.26,55.25 171.19,56.32 171.19,60.24 171.86,60.91 173.12,60.91 174.73,62.52 174.73,64.78 169.17,70.34 169.17,72.9 169.93,73.65 169.93,76.33 169.3,76.95 169.3,78.88 171.56,81.14 171.56,81.51 172.11,82.05 172.11,83.08 171.47,83.72 171.47,87.57 172.23,88.34 172.23,90.42 162,100.66 161.34,100.66 158.23,97.55 154.37,97.55 152.24,99.68 145.93,99.68 145.81,99.55 v2(145.81,98.23)
  BOTTOM w0.102: JDOCK1.121 145.45,98.59 v2(145.81,98.23) 145.39,97.81 R273.1
CLK_PCI_LPDEBUG: length 131
  TOP w0.102: v2(60.1,41.5) 60.1,40.91 59.18,39.99 v1(59.18,31.71) 59.18,31.23 60.13,30.28 60.13,27.11 59.46,26.44 59.46,24.88 v2(58.92,24.33) ; v2(149.89,52.05) 149.71,52.05 148.82,51.16 RC66.2
  IN2 w0.089: v2(149.89,52.05) 150.29,51.64 150.29,51.41
  IN2 w0.122: v2(58.92,24.33) 58.92,24.23 58.69,24 57.33,24 57.12,24.21 50.64,24.21 50.02,23.6 v2(49.31,23.6) ; 150.29,51.41 150.29,48.47 144.37,42.54 126.73,42.54 125.68,41.5 v2(60.1,41.5)
  BOTTOM w0.102: v2(49.31,23.6) 49.41,23.49 49.41,21.8 49.06,21.45 JMINI3.19
CLK_PCI_MEC: length 3.3
  TOP w0.102: U38.A29 30.86,16.83 v1(31.09,17.07) 31.3,17.27 R382.1 32.87,18.15 RC63.2
CLK_PCI_TPM_TCM: length 5.8
  TOP w0.102: U25.21 39.87,37.53 39.54,37.87 39.54,38.43 38.09,39.88 v1(37.95,39.88) 36.92,39.88 RC58.2
CLK_PCIE_LAN: length 171.4
  TOP w0.102: U21.44 253.13,73.97 253.15,73.95 253.15,72.95 253.73,72.36 253.87,72.36 v2(254.03,72.21)
  IN1 w0.084: v2(123.92,91.95) 124.16,91.72 124.16,91.59 124.16,91.58 124.16,91.53 124.72,90.97 125.36,90.97 126.61,92.23 131.88,92.23 135.81,88.31 150.36,88.31 152.93,85.74 155.92,85.74 157.08,86.9 159.58,86.9 161.68,84.8 161.68,81.59 161.9,81.37 162.57,81.37 163.32,80.62 166.83,80.62 168.08,79.37 169.01,79.37 169.53,78.84 173.75,78.84 174.73,77.86 175.99,77.86 176.08,77.76 177.35,77.76 182.56,72.55 185.09,72.55 185.46,72.93 201.62,72.93 204.48,75.79 204.48,76.46 205.33,77.31 206.24,77.31 209.31,80.38 210.49,80.38 214.61,84.49 220.46,84.49 221.15,85.18 223.29,85.18 224.37,84.1 234.72,84.1 235.6,84.98 238.09,84.98 239.83,83.24 241.27,83.24 243.92,80.59 246.03,80.59 247.91,78.71 247.91,73.18 248.96,72.13 250.62,72.13 250.87,71.87 252.73,71.87 253.28,72.43 253.81,72.43 v2(254.03,72.21)
  BOTTOM w0.076: UC1.B42 125.93,81.87 125.93,85.32 125.87,85.38
  BOTTOM w0.102: v2(123.92,91.95) 124.11,91.77 124.11,90.13 124.35,89.89 124.35,86.91 125.87,85.38
CLK_PCIE_LAN#: length 171
  TOP w0.102: v2(254.03,72.79) 253.91,72.67 253.8,72.67 253.42,73.06 253.42,73.95 253.53,74.06 U21.45
  IN1 w0.084: v2(254.03,72.79) 253.84,72.6 253.21,72.6 252.65,72.05 250.94,72.05 250.69,72.3 249.04,72.3 248.08,73.25 248.08,78.79 246.11,80.76 243.99,80.76 241.34,83.41 239.9,83.41 238.16,85.15 235.53,85.15 234.65,84.27 224.44,84.27 223.36,85.35 221.07,85.35 220.39,84.67 214.53,84.67 210.42,80.55 209.24,80.55 206.17,77.48 205.26,77.48 204.31,76.53 204.31,75.86 201.55,73.1 185.39,73.1 185.02,72.73 182.63,72.73 177.42,77.93 176.15,77.93 176.06,78.03 174.81,78.03 173.82,79.01 169.6,79.01 169.08,79.54 168.15,79.54 166.9,80.79 163.39,80.79 162.64,81.54 161.98,81.54 161.85,81.66 161.85,84.87 159.65,87.07 157.01,87.07 155.85,85.91 153,85.91 150.43,88.48 135.88,88.48 131.96,92.4 126.54,92.4 125.29,91.15 124.79,91.15 124.33,91.6 124.33,91.78 v2(124.51,91.95)
  BOTTOM w0.076: UC1.C41 126.53,81.74 126.17,82.09 126.17,85.46 126.06,85.57
  BOTTOM w0.102: 126.06,85.57 124.62,87.02 v3(124.62,89.52) 124.62,90 124.37,90.24 124.37,91.82 v2(124.51,91.95)
