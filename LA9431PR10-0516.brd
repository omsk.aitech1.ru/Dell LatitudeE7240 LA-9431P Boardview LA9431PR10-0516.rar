# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPC_DOCK_HPD: length 85.4
  TOP w0.102: v2(193.68,87.31) 193.68,87.33 193.66,87.31 193.66,86.51 193.85,86.32 193.85,85.45 194.11,85.19 194.36,85.19 194.71,84.85 U6.A6
  IN3 w0.122: v2(126.14,94.88) 126.47,95.21 129.3,95.21 130.43,94.09 136.53,94.09 136.92,94.48 148.79,94.48 151.12,92.15 151.12,90.83 152.97,88.98 159.63,88.98 160.29,89.64 165.84,89.64 167.31,88.17 174.53,88.17 176.15,86.55 185.17,86.55 186.17,87.55 189.53,87.55 190.24,86.85 193.21,86.85 v2(193.68,87.31)
  BOTTOM w0.102: JDOCK1.39 122.95,98.41 122.67,98.13 122.67,96.97 C310.1 R268.1 124.9,96.92 v1(125.1,96.72) 125.81,96.01 125.81,95.41 126.14,95.08 v2(126.14,94.88)
DPC_DOCK_LANE_N0: length 5.2
  BOTTOM w0.089: R252.2 114.73,96.4 114.73,96.68 115.86,97.81 v3(115.86,98.68) 115.86,99.41 115.95,99.5 JDOCK1.11
DPC_DOCK_LANE_N1: length 5
  BOTTOM w0.089: R255.2 116.59,96.32 116.59,97.08 117.36,97.85 v3(117.36,98.55) 117.36,99.41 117.45,99.5 JDOCK1.17
DPC_DOCK_LANE_N2: length 4.9
  BOTTOM w0.089: JDOCK1.23 118.95,99.5 118.86,99.41 v3(118.86,98.59) 118.86,97.38 118.38,96.9 118.38,96.31 R263.2
DPC_DOCK_LANE_N3: length 4.8
  BOTTOM w0.089: R266.2 120.15,96.32 120.15,97.51 120.36,97.72 v3(120.36,98.6) 120.36,99.41 120.45,99.5 JDOCK1.29
DPC_DOCK_LANE_P0: length 5.1
  BOTTOM w0.089: R259.2 114.41,96.24 114.41,96.81 v3(114.78,97.18) 115.54,97.94 115.54,99.41 115.45,99.5 JDOCK1.9
DPC_DOCK_LANE_P1: length 5
  BOTTOM w0.089: JDOCK1.15 116.95,99.5 117.04,99.41 117.04,97.98 116.27,97.22 v3(116.27,97) 116.27,96.32 R253.2
DPC_DOCK_LANE_P2: length 4.9
  BOTTOM w0.089: JDOCK1.21 118.45,99.5 118.54,99.41 118.54,97.51 v3(118.27,97.24) 118.06,97.04 118.06,96.33 R257.2
DPC_DOCK_LANE_P3: length 4.8
  BOTTOM w0.089: R265.2 119.83,96.32 v3(119.83,97.1) 119.83,97.64 120.04,97.85 120.04,99.41 119.95,99.5 JDOCK1.27
DPC_HPD: length 33.4
  TOP w0.102: U19.18 166.27,87.46 166.17,87.57 164.41,87.57 C451.1 163.82,88.16 163.67,88.16 163.02,87.5 160.79,87.5 159.93,88.37 157.09,88.37 v1(156.57,88.88) 155.69,89.76 155.69,91.13 154.62,92.2 154.06,92.2 152.84,90.98 v2(152.4,90.98)
  BOTTOM w0.076: UC1.A8 146.61,82.94 146.61,83.6 146.86,83.86 146.86,84.64 146.74,84.76 146.74,85.26 146.84,85.36 146.84,85.56 146.85,85.57
  BOTTOM w0.102: v2(152.4,90.98) 151.55,91.83 148.92,91.83 RC151.2 147.64,91.05 146.75,90.16 146.75,89.34 146.85,89.24 146.85,85.57
DPC_LANE_N0: length 93.2
  TOP w0.089: v2(194.52,86.91) 194.77,86.66 194.77,85.92 195.4,85.29 195.4,84.85 U6.A7
  IN4 w0.084: v2(113.86,90.87) 113.96,90.97 114.19,90.97 114.35,90.81 114.35,90.37 117.22,87.5 135.2,87.5 135.37,87.67 149.98,87.67 151.16,88.85 155.89,88.85 156.25,89.21 165.66,89.21 167.21,87.66 177.86,87.66 178.11,87.41 181.03,87.41 183.46,89.85 189.59,89.85 190.05,89.38 191.33,89.38 192.48,88.23 194.59,88.23 194.72,88.11 194.72,87.11 v2(194.52,86.91)
  BOTTOM w0.089: C295.2 114.87,93.57 114.74,93.57 114.66,93.49 114.66,91.51 114.25,91.1 114.04,91.1 113.86,90.91 v2(113.86,90.87)
DPC_LANE_N0_C: length 1.1
  BOTTOM w0.089: R252.1 114.8,94.82 114.8,94.56 C295.1
DPC_LANE_N1: length 94.9
  TOP w0.089: v2(195.56,87.59) 195.83,87.32 195.83,86.49 196.01,86.32 U6.A8
  IN4 w0.084: v2(115.21,90.77) 115.27,90.84 115.94,90.84 118.02,88.76 131.42,88.76 131.83,88.35 134.85,88.35 135.08,88.58 145.61,88.58 148.61,91.58 152.64,91.58 154.35,89.86 155.7,89.86 155.89,90.05 166.01,90.05 167.56,88.51 177.28,88.51 177.83,89.05 179.64,89.05 179.84,89.25 181.67,89.25 183.11,90.69 189.46,90.69 190.38,91.61 191.37,91.61 193.83,89.15 195.38,89.15 195.76,88.77 195.76,87.79 v2(195.56,87.59)
  BOTTOM w0.089: C299.2 116.77,93.45 116.51,93.45 116.44,93.38 116.44,91.72 115.76,91.04 115.47,91.04 v2(115.21,90.77)
DPC_LANE_N1_C: length 1.1
  BOTTOM w0.089: C299.1 116.57,94.56 116.57,94.82 R255.1
DPC_LANE_N2: length 93.4
  TOP w0.089: v2(196.64,86.91) 196.91,86.64 196.91,85.88 196.7,85.67 196.7,84.85 U6.A9
  IN4 w0.084: v2(196.64,86.91) 196.84,87.11 196.84,89.38 193.77,92.46 188.63,92.46 188.15,91.97 184.26,91.97 183.83,91.54 182.76,91.54 182.12,90.9 157.85,90.9 157.51,91.25 155.45,91.25 154.09,92.61 150.25,92.61 149.94,92.91 141.57,92.91 140.66,93.83 136.39,93.83 134.7,92.13 131.1,92.13 128.62,89.65 118.95,89.65 117.56,91.05 117.43,91.05 v2(117.28,90.9)
  BOTTOM w0.089: C306.2 118.56,93.43 118.28,93.43 118.22,93.38 118.22,93.02 118.08,92.88 118.08,91.84 117.95,91.71 117.95,91.4 117.69,91.15 117.53,91.15 v2(117.28,90.9)
DPC_LANE_N2_C: length 1.1
  BOTTOM w0.089: R263.1 118.35,94.82 118.35,94.56 C306.1
DPC_LANE_N3: length 94.9
  TOP w0.089: U6.A10 197.35,84.85 197.35,85.44 197.73,85.81 197.73,87.63 v2(197.69,87.67)
  IN4 w0.084: v2(118.94,90.96) 119.08,91.1 125.86,91.1 126.98,92.22 128.03,92.22 128.79,92.98 134.35,92.98 136.04,94.67 141.03,94.67 141.95,93.76 150.3,93.76 150.6,93.45 154.48,93.45 155.83,92.1 157.87,92.1 158.23,91.75 181.77,91.75 182.66,92.64 182.89,92.64 183.28,93.03 187.56,93.03 188.25,93.72 197.08,93.72 197.54,93.26 197.54,90.35 197.86,90.02 197.86,87.84 v2(197.69,87.67)
  BOTTOM w0.089: C301.2 120.26,93.51 120.07,93.51 120,93.44 120,93.02 119.86,92.88 119.86,91.53 119.56,91.23 119.21,91.23 v2(118.94,90.96)
DPC_LANE_N3_C: length 1.1
  BOTTOM w0.089: C301.1 120.13,94.56 120.13,94.82 R266.1
DPC_LANE_P0: length 93.1
  TOP w0.089: v2(195.1,86.91) 195.08,86.89 195.08,86.05 195.72,85.42 195.72,84.51 U6.B7
  IN4 w0.084: v2(113.86,91.45) 113.96,91.35 114.35,91.35 114.73,90.97 114.73,90.53 117.37,87.88 135.05,87.88 135.22,88.05 149.83,88.05 151,89.23 155.73,89.23 156.09,89.59 165.82,89.59 167.37,88.04 178.02,88.04 178.26,87.79 180.87,87.79 183.3,90.23 189.74,90.23 190.21,89.76 191.49,89.76 192.64,88.61 194.75,88.61 195.1,88.27 195.1,86.92 v2(195.1,86.91)
  BOTTOM w0.089: v2(113.86,91.45) 113.9,91.41 114.12,91.41 114.34,91.64 114.34,93.21 C302.2
DPC_LANE_P0_C: length 1.1
  BOTTOM w0.089: C302.1 114.48,94.52 114.48,94.85 R259.1
DPC_LANE_P1: length 95
  TOP w0.089: v2(196.15,87.59) 196.15,86.63 196.32,86.45 196.32,84.47 U6.B8
  IN4 w0.084: v2(196.15,87.59) 196.15,88.92 195.54,89.53 193.99,89.53 191.52,92 190.23,92 189.3,91.07 182.95,91.07 181.51,89.63 179.68,89.63 179.48,89.43 177.67,89.43 177.12,88.89 167.72,88.89 166.17,90.43 155.73,90.43 155.54,90.25 154.51,90.25 152.79,91.96 148.45,91.96 145.45,88.96 134.93,88.96 134.69,88.73 131.99,88.73 131.58,89.14 118.18,89.14 116.1,91.22 115.34,91.22 v2(115.21,91.36)
  BOTTOM w0.089: C297.2 116.12,93.21 116.12,91.85 115.63,91.36 v2(115.21,91.36)
DPC_LANE_P1_C: length 1.1
  BOTTOM w0.089: R253.1 116.26,94.85 116.26,94.52 C297.1
DPC_LANE_P2: length 93.4
  TOP w0.089: v2(197.22,86.91) 197.22,85.74 197.02,85.54 197.02,84.51 U6.B9
  IN4 w0.084: v2(117.28,91.48) 117.34,91.43 117.72,91.43 119.11,90.03 128.46,90.03 130.94,92.51 134.54,92.51 136.23,94.21 140.82,94.21 141.73,93.29 150.1,93.29 150.41,92.99 154.25,92.99 155.61,91.63 157.66,91.63 158.01,91.28 181.96,91.28 182.6,91.92 183.67,91.92 184.1,92.35 187.99,92.35 188.48,92.84 193.92,92.84 197.22,89.54 v2(197.22,86.91)
  BOTTOM w0.089: C304.2 117.77,91.98 117.63,91.84 117.63,91.53 117.56,91.46 117.3,91.46 v2(117.28,91.48)
DPC_LANE_P2_C: length 1.1
  BOTTOM w0.089: C304.1 118.03,94.52 118.03,94.85 R257.1
DPC_LANE_P3: length 94.9
  TOP w0.089: v2(198.28,87.67) 198.05,87.43 198.05,85.68 197.67,85.31 197.67,84.51 U6.B10
  IN4 w0.084: v2(198.28,87.67) 198.24,87.7 198.24,90.18 197.92,90.51 197.92,93.42 197.24,94.1 188.09,94.1 187.4,93.41 183.12,93.41 182.73,93.02 182.5,93.02 181.61,92.13 158.39,92.13 158.03,92.48 155.99,92.48 154.63,93.83 150.76,93.83 150.45,94.14 142.11,94.14 141.19,95.05 135.88,95.05 134.19,93.36 128.63,93.36 127.87,92.6 126.82,92.6 125.7,91.48 119.01,91.48 v2(118.94,91.55)
  BOTTOM w0.089: C300.2 119.54,91.72 119.37,91.55 v2(118.94,91.55)
DPC_LANE_P3_C: length 1.1
  BOTTOM w0.089: R265.1 119.81,94.85 119.81,94.52 C300.1
DSCHRG_MOSFET_GC: length 1.7
  TOP w0.254: PU800.29 2.71,29.6 PR841.2
DSWODVREN: length 20.8
  BOTTOM w0.076: UC1.AW7 147.44,60.54 147.44,60.05 147.27,59.88 147.27,58.81 150.16,55.92 150.93,55.92 151.5,55.35 v1(151.63,55.35) 151.77,55.35 152.39,54.72 152.39,54.52 152.76,54.15 153.85,54.15
  BOTTOM w0.102: RC73.1 RC78.2 161.85,54.76 161.24,54.15 153.85,54.15
DYN_TUR_CURRNT_SET#: length 135.8
  TOP w0.102: R363.2 27.55,22 v2(27.55,21.44) 27.55,20.59 27.44,20.48 U38.A35
  TOP w0.254: PQ712.2 93.07,92.34 92.81,92.6 91.94,92.6 91.67,92.33 91.67,84.87 v1(90.92,84.12) 90.92,83.22 91.26,82.88 v2(91.49,82.88)
  IN4 w0.084: v2(91.49,82.88) 84.48,82.88 82.91,84.44 79.58,84.44 78.78,83.64 75.17,83.64 74.47,82.94 67.63,82.94 66.65,81.97 66.65,81.44 67.69,80.4 68.83,80.4 69.2,80.03 69.2,77.76 66.45,75.01 66.45,47.86 61.03,42.43 59.85,42.43 51.42,34 51.42,30.5 50.09,29.18 50.09,27.83 49.44,27.18 49.44,25.32 48.12,24 48.12,23.24 47.82,22.94 46.56,22.94 46.16,23.33 43.29,23.33 42.74,23.88 40.25,23.88 38.86,22.5 37.71,22.5 37.1,21.88 37.1,21.39 36.27,20.56 32.3,20.56 32.01,20.84 29.55,20.84 28.96,20.24 28.17,20.24 27.55,20.87 v2(27.55,21.44)
EC5048_TX: length 349.1
  TOP w0.102: v2(11.11,4) 11.09,4 v1(10.73,4.36) 10.41,4.67 10.41,7.95 R397.2 ; v2(17.01,30.77) 17.01,30.52 16.68,30.19 U37.B2
  IN1 w0.084: v2(18.52,5.59) 18.52,5.89 19.05,6.43 20.19,6.43 21.61,7.84 21.61,8.28 21.03,8.86 20.93,8.95 19.79,8.95 19.17,9.58 19.17,13.82 19.04,13.95 19.04,23.87 18.54,24.37 18.54,25.54 17.88,26.2 17.88,29.53 17.01,30.4 v2(17.01,30.77)
  IN2 w0.122: v2(11.11,4) 12.09,3.02 43.16,3.02 43.8,3.66 44.29,3.66 44.93,3.02 49.37,3.02 50.08,3.72 52.17,3.72 52.83,3.06 54.9,3.06 55.82,3.98 59.14,3.98 59.29,3.83 70.33,3.83 72.06,5.56 75.06,5.56 76.56,7.06 76.56,14.66 78.88,16.98 127.79,16.98 128.54,16.23 132.5,16.23 132.81,16.54 134.6,16.54 135.2,17.14 178.16,17.14 179.22,16.08 179.22,15.74 178.79,15.3 178.79,9.93 177.5,8.65 177.5,2.71 178.79,1.42 208,1.42 211.73,5.16 211.73,16.7 210.97,17.46 v2(209.84,17.46)
  IN4 w0.084: v2(11.11,4) 11.77,4.66 13.59,4.66 14.41,5.48 18.41,5.48 v2(18.52,5.59)
  BOTTOM w0.102: JDEG1.2 9.17,41.71 8.59,41.12 7.31,41.12 6.4,40.22 6.4,38.85 6.24,38.68 4,38.68 1.09,35.78 1.09,31.43 3.26,29.25 3.26,23.59 7.05,19.81 7.05,10.25 6.73,9.93 4.73,9.93 4.64,10.02 2.93,10.02 2.3,9.38 2.3,7.95 2.76,7.49 2.76,7.49 3.18,7.06 3.34,7.06 7.12,3.29 9.28,3.29 9.45,3.46 9.59,3.46 9.69,3.36 10.3,3.36 10.93,4 v2(11.11,4) ; v2(209.84,17.46) 210.78,18.4 JMINI1.17
EC_32KHZ_ECE5048: length 39.9
  TOP w0.102: U37.B35 24.18,38.45 23.74,38.01 23.25,38.01 v2(22.98,37.73) ; v1(11.14,32.56) 11.6,33.02 v2(11.61,33.02) ; R379.1 13.15,16.17 v2(13.01,16.31)
  IN1 w0.084: v2(13.01,16.31) 12.42,16.89 12.42,18.19 13.09,18.86 13.09,19.95 13.79,20.65 13.79,21.77 12.32,23.24 12.32,31.75 12.21,31.86 12.21,32.42 v2(11.61,33.02)
  IN2 w0.122: v2(22.98,37.73) 22.98,37.69 22.44,37.15 21.35,37.15 21.2,36.99 18.2,36.99 17.92,36.72 17.92,34.36 17.44,33.87 15.05,33.87 14.61,34.31 13.31,34.31 13.03,34.59 13.03,34.75 12.81,34.96 11.28,34.96 10.78,34.46 10.78,33.44 11.2,33.02 v2(11.61,33.02)
EC_WAKE#: length 196.6
  TOP w0.102: RC206.1 165.76,64.62 v2(165.54,64.39) ; U38.B23 29.03,13.08 28.71,12.76 28.18,12.76 v2(27.8,12.38)
  IN1 w0.084: v2(27.8,12.38) 27.39,12.79 27.39,16.06 28.21,16.88 28.83,16.88 29.27,17.32 29.27,19.58 30.22,20.53 30.22,23.2 30.44,23.41 30.44,24.58 30.06,24.95 30.06,26.4 32.36,28.7 32.36,29.96 32.05,30.28 v2(31.94,30.28)
  IN2 w0.089: 149.12,51.41 149.12,53.72 149.28,53.88 149.28,56.1 149.61,56.42 149.61,58.13 149.28,58.45 149.28,58.7 149.92,59.33 149.92,60.02 149.91,60.03 149.91,62.42 149.25,63.07 149.25,63.31 149.45,63.51 149.45,64.2 149.28,64.38 149.28,64.68 148.92,65.04 v2(148.83,65.04)
  IN2 w0.122: v2(31.94,30.28) 32.15,30.28 32.44,30.56 32.44,30.9 33.9,32.36 34.63,32.36 36.44,34.17 41.94,34.17 44.97,37.21 46.08,37.21 49.57,40.7 50.89,40.7 52.97,42.78 54.34,42.78 54.62,42.5 117.52,42.5 118.57,43.55 143.95,43.55 148.94,48.54 148.94,51.16 149.12,51.34 149.12,51.41
  IN3 w0.089: 153.85,63.19 151.61,63.19 150.65,64.16 150.65,64.88 150.34,65.19 148.98,65.19 v2(148.83,65.04)
  IN3 w0.122: v2(165.54,64.39) 164.64,64.39 164.05,64.98 163.32,64.98 162.61,64.27 161.85,64.27 160.6,65.52 156.63,65.52 154.31,63.19 153.85,63.19
  BOTTOM w0.076: v2(148.83,65.04) 148.68,65.04 148.38,64.74 UC1.AN5
  BOTTOM w0.102: v2(165.54,64.39) 166.16,64.39 166.34,64.21 166.34,62.89 165.74,62.28 165.74,61.3 166.45,60.59 v1(166.45,59.75) 166.45,57.78 166.88,57.35 RC301.2
EDID_SELECT#: length 13.6
  TOP w0.102: v2(11.8,32.17) 11.8,32.09 T118.1 ; v2(17.27,34.62) 16.67,34.02 U37.B61
  IN2 w0.122: v2(11.8,32.17) 11.16,32.17 10.53,32.8 10.53,34.57 11.2,35.23 14.67,35.23 15.78,34.12 16.75,34.12 17.25,34.62 v2(17.27,34.62)
EDP_BIA_PWM: length 112.4
  TOP w0.102: v2(87.78,83.77) 87.25,83.24 85.17,83.24 84.46,83.95 83.34,83.95 81.89,82.5 79.78,82.5 78.73,81.44 78.73,80.84 78.24,80.35 76.62,80.35 74.93,78.66 69.79,78.66 69.32,78.19 v1(64.8,78.19) 64.08,78.19 62.41,76.51 D10.3
  IN3 w0.122: v2(87.78,83.77) 88.17,83.77 90.68,86.28 93.66,86.28 95.25,87.86 97.66,87.86 100.26,90.47 100.89,90.47 101.48,89.88 102.26,89.88 102.73,90.35 105.68,90.35 106.08,89.96 107.51,89.96 108.35,90.8 112.42,90.8 113.27,89.95 115.57,89.95 116.63,91 116.63,92.18 117.57,93.12 119.37,93.12 119.76,92.73 119.76,91.59 120.09,91.26 121.68,91.26 122.96,92.54 124.32,92.54 125.3,93.53 126.77,93.53 127.13,93.89 128.98,93.89 131.3,91.57 135.05,91.57 137.72,88.9 140.44,88.9 141.68,90.14 141.68,90.6 142.42,91.34 v2(142.42,92.4)
  BOTTOM w0.076: UC1.B8 146.44,82.23 146.44,83.76 146.7,84.01 146.7,84.57 146.47,84.8 146.47,85.37 146.61,85.51 146.61,85.57
  BOTTOM w0.102: 146.61,85.57 146.61,87.62 146.28,87.95 146.28,91.57 144.97,92.87 142.61,92.87 142.42,92.68 v2(142.42,92.4)
EDP_COMP: length 6.3
  TOP w0.508: v2(140.27,81.57) v1(139.04,81.57) 137.82,80.35 137.82,78.41 137.39,77.98 RC134.2
  BOTTOM w0.254: v2(140.27,81.57) UC1.D20
EDP_CPU_AUX: length 92.5
  IN4 w0.091: v2(124.39,84.44) 124.18,84.64 124.18,84.96 123.99,85.15 123.32,85.15 122.97,84.8 122.97,83.04 122.3,82.37 114.08,82.37 112.16,80.45 108.67,80.45 108.33,80.11 107.3,80.11 107.21,80.21 98.79,80.21 94.91,84.08 88.91,84.08 86.89,86.1 85.48,86.1 84.85,85.47 82.25,85.47 81.87,85.1 75.35,85.1 75.1,84.86 72.81,84.86 72.16,84.21 67.95,84.21 65.58,81.84 63.53,81.84 58.85,77.16 58.85,73.89 58.4,73.44 58.4,69.63 59.39,68.63 59.39,66.67 58.96,66.24 58.96,66.06 v2(58.77,65.87)
  BOTTOM w0.076: v2(124.39,84.44) 124.54,84.28 124.54,82.73 124.02,82.21 UC1.B45
  BOTTOM w0.102: v2(58.77,65.87) 58.95,66.05 58.95,66.26 59.72,67.03 59.72,67.35 59.5,67.57 C55.1
EDP_CPU_AUX#: length 92.6
  IN4 w0.091: v2(59.35,65.87) 59.13,66.08 59.13,66.17 59.56,66.6 59.56,68.71 58.57,69.7 58.57,73.36 59.02,73.82 59.02,77.09 63.6,81.67 65.65,81.67 68.02,84.04 72.23,84.04 72.88,84.68 75.17,84.68 75.42,84.93 81.95,84.93 82.32,85.3 84.92,85.3 85.55,85.93 86.82,85.93 88.84,83.91 94.84,83.91 98.71,80.04 107.13,80.04 107.23,79.94 108.4,79.94 108.74,80.28 112.23,80.28 114.15,82.2 122.37,82.2 123.14,82.97 123.14,84.73 123.39,84.98 123.92,84.98 124.01,84.89 124.01,84.56 123.88,84.43 v2(123.57,84.43)
  BOTTOM w0.076: v2(123.57,84.43) 123.57,84.49 123.7,84.62 123.88,84.62 124,84.49 124,84.24 124.38,83.87 124.38,82.8 124.27,82.7 124.14,82.7 UC1.A45
  BOTTOM w0.102: C54.1 59.93,67.69 59.93,66.94 59.17,66.17 59.17,66.05 v2(59.35,65.87)
EDP_CPU_AUX#_C: length 5.1
  BOTTOM w0.102: JEDP1.9 56.57,71.58 56.64,71.4 56.64,71.37 56.71,71.31 56.71,71.3 57.92,70.09 57.92,70.08 58.05,69.95 58.47,69.95 v3(58.8,69.62) 59.11,69.32 59.23,69.19 59.38,69.19 C54.2
EDP_CPU_AUX_C: length 5.3
  BOTTOM w0.102: C55.2 59.08,68.58 59.08,69.04 59.02,69.1 58.84,69.27 58.83,69.27 58.45,69.65 58.45,69.66 58.38,69.74 57.96,69.74 57.71,69.99 57.71,69.99 57.69,69.99 v3(57.58,70.1) 56.49,71.2 56.49,71.22 56.44,71.32 56.13,71.4 JEDP1.8
EDP_CPU_HPD: length 140.8
  IN3 w0.122: v2(66.99,65.02) 66.55,65.46 66.55,74.4 68.36,76.21 69.74,76.21 74.33,80.8 78.7,80.8 79.28,81.38 82.44,81.38 83.64,82.59 86.71,82.59 87.35,83.23 87.35,84.05 88.42,85.11 89.05,85.11 90.45,86.52 93.56,86.52 95.14,88.11 97.53,88.11 100.84,91.42 106.44,91.42 106.82,91.81 107.58,91.81 107.81,92.04 108.13,92.36 111.43,92.36 113.59,90.19 115.47,90.19 116.38,91.11 116.38,92.29 117.47,93.37 119.48,93.37 120.01,92.84 120.01,91.7 120.19,91.51 121.58,91.51 122.89,92.82 124.24,92.82 125.2,93.78 126.67,93.78 127.03,94.14 129.08,94.14 131.4,91.82 135.16,91.82 137.83,89.15 140.33,89.15 141.43,90.24 141.43,90.7 141.92,91.19 141.92,92.56 142.68,93.32 148.48,93.32 149.44,92.35 149.44,89.57 150.67,88.34 151.23,88.34 v2(151.97,87.6)
  BOTTOM w0.076: UC1.D6 148.13,81.03 148.43,81.33 148.62,81.33 148.83,81.53 148.83,81.64 149.07,81.87 149.53,81.87 149.69,82.03 149.69,82.65 149.71,82.68 149.71,83.37 150.51,84.17 150.51,85.57
  BOTTOM w0.102: JEDP1.16 59.87,72.68 59.87,72.43 60.12,72.17 61.33,72.17 61.65,71.86 62.6,71.86 63.55,70.9 63.55,69.63 64.19,69 64.19,65.63 v1(64.8,65.02) v2(66.99,65.02) ; CC450.1 152.27,87.6 v2(151.97,87.6) 151.45,87.08 RC158.1 151.45,86.51 150.51,85.57
EDP_CPU_LANE_N0: length 91.4
  IN4 w0.091: v2(122.38,85.06) 121.52,85.06 120.07,83.6 107.95,83.6 104.49,87.07 101.45,87.07 99.53,85.15 97.95,85.15 96.81,86.28 88.95,86.28 87.16,88.07 85.24,88.07 83.93,86.76 81.68,86.76 81.36,86.44 74.2,86.44 72.64,88.01 70.43,88.01 68.75,86.33 68.09,86.33 65.44,83.68 62.45,83.68 60.86,82.09 60.86,81.15 57.05,77.33 57.05,68.16 57.65,67.56 v2(57.65,67.22)
  BOTTOM w0.076: UC1.C45 123.81,81.72 123.81,81.96 123.73,82.04 123.73,83.36 123.47,83.62 123.2,83.89 123.2,84.78 122.95,85.04 122.4,85.04 v2(122.38,85.06)
  BOTTOM w0.102: C56.1 57.44,67.81 57.65,67.6 v2(57.65,67.22)
EDP_CPU_LANE_N0_C: length 6.3
  BOTTOM w0.102: C56.2 57.11,68.84 57.11,69.48 56.92,69.67 56.85,69.67 56.74,69.57 56.74,69.55 56.37,69.18 56.35,69.18 56.21,69.03 55.78,69.03 55.48,69.33 55.48,69.69 56.16,70.37 56.16,70.43 55.97,70.62 55.58,70.62 55.35,70.85 55.35,70.87 55.17,70.94 54.91,71.66
EDP_CPU_LANE_N1: length 90.2
  IN4 w0.084: v2(122.42,83.87) 121.44,83.87 121.03,83.46
  IN4 w0.091: v2(57.52,64.62) 57.5,64.64 57.5,65.97 58.73,67.2 58.73,68.03 57.69,69.06 57.69,76.94 63.26,82.51 65.18,82.51 68.26,85.58 74.9,85.58 75.11,85.8 81.65,85.8 81.98,86.12 84.37,86.12 85.01,86.76 87.26,86.76 88.83,85.19 95.6,85.19 97.59,83.2 97.72,83.2 98.01,83.49 98.34,83.49 98.58,83.25 98.58,82.92 98.29,82.63 98.29,82.5 98.43,82.36 98.56,82.36 98.81,82.62 99.13,82.62 99.38,82.37 99.38,82.05 99.12,81.79 99.12,81.66 99.93,80.85 107.24,80.85 109.29,82.91 120.47,82.91 121.03,83.46
  BOTTOM w0.076: v2(122.42,83.87) 122.79,83.49 122.79,83.35 123.11,83.03 123.11,82.91 123.02,82.81 UC1.A47
  BOTTOM w0.102: v2(57.52,64.62) 57.52,65.06 57.39,65.19 C57.1
EDP_CPU_LANE_N1_C: length 6.5
  BOTTOM w0.102: C57.2 57.07,66.24 57.07,66.72 54.47,69.33 54.47,70.29 JEDP1.4
EDP_CPU_LANE_P0: length 91.5
  IN4 w0.091: v2(58.22,67.41) 58.04,67.41 57.22,68.23 57.22,77.26 61.04,81.08 61.04,82.02 62.52,83.5 65.51,83.5 68.16,86.16 68.82,86.16 70.5,87.83 72.57,87.83 74.13,86.27 81.43,86.27 81.75,86.59 84,86.59 85.31,87.9 87.09,87.9 88.88,86.11 96.74,86.11 97.88,84.97 99.6,84.97 101.52,86.89 104.42,86.89 107.88,83.43 120.14,83.43 121.59,84.89 122.02,84.89 122.38,84.53 v2(122.38,84.47)
  BOTTOM w0.076: UC1.B46 123.3,81.84 123.18,81.97 123.18,82.05 123.29,82.16 123.43,82.16 123.54,82.27 123.54,83.28 123.01,83.81 123.01,84.71 122.87,84.85 122.71,84.85 122.38,84.52 v2(122.38,84.47)
  BOTTOM w0.102: v2(58.22,67.41) 58.03,67.41 57.9,67.54 57.9,67.93 C59.1
EDP_CPU_LANE_P0_C: length 6.3
  BOTTOM w0.102: JEDP1.7 55.63,71.16 55.55,71.03 55.58,70.93 55.67,70.84 56.06,70.84 56.38,70.52 56.38,70.28 55.7,69.6 55.7,69.42 55.87,69.25 56.12,69.25 56.76,69.89 57.01,69.89 57.33,69.57 57.33,69.25 57.61,68.97 C59.2
EDP_CPU_LANE_P1: length 90.1
  IN4 w0.084: v2(122.42,83.29) 122,83.71 121.51,83.71 121.2,83.39 121.2,83.39 121.16,83.35 121.16,83.35 121.15,83.34
  IN4 w0.091: 121.15,83.34 120.54,82.73 109.36,82.73 107.31,80.68 99.86,80.68 98.95,81.59 98.95,81.87 99.21,82.12 99.21,82.3 99.06,82.45 98.88,82.45 98.63,82.19 98.35,82.19 98.11,82.43 98.11,82.7 98.41,83 98.41,83.18 98.26,83.32 98.09,83.32 97.79,83.02 97.52,83.02 95.52,85.02 88.75,85.02 87.18,86.59 85.08,86.59 84.44,85.95 82.05,85.95 81.72,85.62 75.18,85.62 74.97,85.41 68.33,85.41 65.25,82.33 63.34,82.33 57.87,76.86 57.87,69.13 58.9,68.1 58.9,67.13 57.67,65.9 57.67,65.03 57.9,64.81 v2(58.09,64.81)
  BOTTOM w0.076: v2(122.42,83.29) 122.6,83.1 122.6,82.65 122.9,82.36 UC1.B47
  BOTTOM w0.102: C60.1 58.02,65.5 57.81,65.29 57.81,64.96 57.96,64.81 v2(58.09,64.81)
EDP_CPU_LANE_P1_C: length 6.6
  BOTTOM w0.102: JEDP1.5 54.73,70.69 54.63,70.47 54.69,70.34 54.69,69.42 57.29,66.81 57.29,66.56 57.49,66.36 C60.2
EN: length 11.1
  TOP w0.102: PC119.1 192.94,45.06 v1(192.38,44.5)
  TOP w0.203: PU100.20 194.96,48.45 ; PU100.6 198.69,48.45 198.86,48.28 198.86,48.03 198.73,47.9 v2(198.4,47.9)
  TOP w0.254: 194.96,48.45 v2(194.36,47.85) 193.59,47.08 PR113.1 192.95,46.01 PC119.1
  BOTTOM w0.254: v2(194.36,47.85) 198.35,47.85 v2(198.4,47.9)
EN_+V1.05SP: length 3.2
  TOP w0.254: PR303.2 PR304.2 PC308.1 239.51,74.33 239.26,74.08 PU300.3
EN_DK_PWRBAR: length 38.5
  TOP w0.254: PR874.1 PR866.2 v2(10.9,29.76) 10.55,29.76 10.4,29.6 PU800.17
  IN2 w0.122: v2(30.05,40.88) 29.57,40.4 25.32,40.4 24.55,39.63 15.75,39.63 15.07,38.96 14.34,38.96 14.24,39.06 14.24,39.43 13.83,39.84 13.28,39.84 12.79,39.35 11.52,39.35 10.26,38.09 8.36,38.09 7.7,37.42 7.7,33.57 8.44,32.83 8.44,32.48 10.9,30.02 v2(10.9,29.76)
  BOTTOM w0.102: PQ827.1 29.55,41.38 v2(30.05,40.88)
EN_DOCK_PWR_BAR: length 28.6
  TOP w0.102: v2(22.37,37.7) 23.15,38.49 23.15,38.68 23.18,38.71 U37.B37 ; v2(14.55,29.07) 14.2,29.07 v1(13.72,29.55) 13.51,29.76 PR866.1
  IN2 w0.122: v2(26.99,37.33) 26.62,37.71 26.11,37.71 25.78,37.38 25.78,33.8 25.16,33.19 25.16,31.22 23.63,29.68 18.79,29.68 18.16,29.06 16.57,29.06 16.56,29.05 14.57,29.05 v2(14.55,29.07)
  IN4 w0.084: v2(22.37,37.7) 22.37,37.71 22.83,38.18 23.22,38.18 23.39,38 26.67,38 26.99,37.68 v2(26.99,37.33)
EN_I2S_NB_CODEC#: length 375.7
  TOP w0.102: v2(23.57,38.42) 23.68,38.52 U37.B36
  TOP w0.254: U17.48 269.03,31.07 268.67,30.71 v2(268.67,30.29)
  IN2 w0.122: v2(268.67,30.29) 269.6,30.29 274.06,34.75 274.06,38.39 271.89,40.55 271.89,45.49 268.92,48.46 268.92,75.6 268.48,76.04 262.94,76.04 262.71,75.81 260.72,75.81 259.95,76.58 256.06,76.58 254.62,78.02 253.1,78.02 252.78,78.33 252.02,78.33 251.57,77.89 250.81,77.89 250.3,77.38 247.26,77.38 245.29,79.35 242.93,79.35 240.46,81.82 238.73,81.82 237.63,82.92 224.86,82.92 223.2,84.58 221.41,84.58 216.63,79.8 208.33,79.8 206.25,77.72 204.91,77.72 204.43,77.24 204.43,76.15 204.56,76.02 205.68,76.02 205.86,75.84 205.86,74.79 203.31,72.25 203.31,69.22 203.77,68.77 203.77,65.12 203.57,64.92 203.57,62.6 203.76,62.41 203.76,55.39 203.46,55.09 203.46,53.75 204.32,52.89 204.32,42.76 v2(204.54,42.54)
  IN3 w0.122: v2(131.79,27.41) 132.26,27.41 132.6,27.75 132.6,28.27 139.33,35 185.13,35 186.25,33.88 186.57,33.88 187.6,32.84 188.03,32.84 189.67,34.49 191.4,34.49 192.66,35.75 194.46,35.75 194.65,35.55 195.85,35.55 197.84,37.54 197.84,38.58 199,39.75 200.58,39.75 202.46,41.63 203.63,41.63 v2(204.54,42.54)
  BOTTOM w0.102: v2(23.57,38.42) 23.57,38.46 23.66,38.37 25.71,38.37 25.88,38.54 26.02,38.54 27.36,39.89 28.5,39.89 28.79,40.18 31.33,40.18 34.48,43.34 34.48,45.44 v1(34.57,45.53) 35.04,46 35.04,46.6 38,49.56 39.11,49.56 40.83,51.27 46.02,51.27 47.17,50.13 47.8,50.13 49.51,48.42 50.35,48.42 52.81,45.96 57.28,45.96 58.37,44.87 65.65,44.87 66.35,44.17 124.43,44.17 130.47,38.14 130.47,33.57 130.77,33.27 130.77,31.4 132.11,30.07 132.11,28.47 131.64,28 131.64,27.56 v2(131.79,27.41)
EN_INVPWR: length 103.9
  TOP w0.102: U38.A25 30.8,14.83 31.14,14.49 v2(31.37,14.49) 31.37,14.9 31.56,15.09 R371.2 ; Q4.2 71.73,66.66 72.12,66.27 74.57,66.27 74.77,66.08 74.77,63.05 73.38,61.67 73.38,51.63 71.63,49.87 v1(71.63,45.58) 71.63,43.48 63.81,35.66 63.81,27.24 63.49,26.92 63.49,19.24 61.86,17.61 57.33,17.61 57.09,17.37 55.83,17.37 54.66,18.54 54.66,19.23 53.9,19.99 53.9,21.69 v2(54.38,22.17)
  IN2 w0.122: v2(54.38,22.17) 54.08,22.48 51,22.48 50.39,21.87 48.67,21.87 48.34,21.54 48.34,16.87 45.54,14.08 39.43,14.08 37.9,12.55 36.06,12.55 35.48,11.98 32.84,11.98 32.12,12.7 32.12,14.2 31.83,14.49 v2(31.37,14.49)
EN_LCDPWR: length 4.9
  TOP w0.102: D2.1 54.79,69.06 R104.2 54.19,69.66 53.82,69.66 v1(53.68,69.81) 53.42,70.06 53.42,70.92 53.08,71.27 U9.3
ENVDD_PCH: length 194.8
  TOP w0.102: v2(22.55,38.46) 22.68,38.59 U37.B38 ; D2.3 58.9,69.71 60.12,68.49 60.12,65.38 59.87,65.13 v2(59.17,65.13) ; v2(25.81,39.24) 29.03,42.47 v2(32.23,42.47)
  IN1 w0.084: v2(69.49,86.03) 69.98,86.03 70.3,86.35 70.3,87.16 72.84,89.69 81.44,89.69 82.2,88.94 97.51,88.94 99.27,87.17 101.74,87.17 103,88.43 103,89.37 103.57,89.94 107.14,89.94 115.02,82.07 137.7,82.07 138.41,82.78 140.03,82.78 140.45,82.36 146.77,82.36 v2(147.94,83.53)
  IN2 w0.122: v2(150.05,90.84) 149.33,90.12 149.33,88.49 146.94,86.09 146.94,84.53 147.94,83.53 v2(147.94,83.53)
  IN3 w0.122: v2(32.23,42.47) 34.69,42.47 39.48,47.26 54.29,47.26 56.29,49.26 56.29,49.66 57.68,51.05 57.68,55.17 56.76,56.08 56.76,59.52 56.01,60.27 56.01,63.25 56.78,64.02 58.4,64.02 59.17,64.79 v2(59.17,65.13) 59.59,65.13 59.78,65.32 59.78,66.25 59.44,66.59 59.44,68.04 58.02,69.45 58.02,72.81 59.01,73.8 59.01,80.81 63.29,85.09 65.28,85.09 66,85.81 67.91,85.81 68.12,86.03 v2(69.49,86.03)
  BOTTOM w0.076: UC1.C6 147.5,81.95 148.06,82.51 148.06,83.4 v2(147.94,83.53)
  BOTTOM w0.102: v2(150.05,90.84) 150.05,90.84 149.85,91.05 RC152.2 ; v2(22.55,38.46) 22.53,38.46 23.27,39.19 25.76,39.19 v2(25.81,39.24)
ERC1: length 2.4
  TOP w0.254: PC815.1 5.78,23.49 PU800.3
ERC2: length 2.4
  TOP w0.254: PC817.1 11.43,27.44 v1(10.97,27.44) 10.53,27.44 10.37,27.6 PU800.13
ERC3: length 3.9
  TOP w0.102: v1(13.07,26.07) PC816.1
  TOP w0.254: PU800.12 10.2,27.1 10.3,27 10.93,27 11.35,26.58 11.35,26.39 PC816.1
ESATA_USB_PWR_EN#: length 263.4
  TOP w0.102: v2(20.6,41.27) 20.13,41.74 R295.2 ; v2(19.61,38.46) 19.68,38.53 U37.B44
  IN1 w0.084: v2(19.61,38.46) 20.6,39.45 v2(20.6,41.27)
  IN3 w0.122: v2(165.74,63.85) 166.79,63.85 167.74,64.79 168.25,64.79 168.49,65.04 168.49,65.77 168.07,66.19 168.07,66.74 169.31,67.98 171.43,67.98 174.83,71.38 180.54,71.38 181.17,72.01 184.66,72.01 185.58,72.94 189.2,72.94 189.96,73.7 191.13,73.7 193.73,76.3 197.57,76.3 200.43,79.16 200.43,80.18 201.74,81.5 205.51,81.5 207.2,83.19 207.78,83.19 210.31,85.72 212.62,85.72 213.46,86.56 223.58,86.56 224.32,85.83 v2(225.07,85.83) ; v2(165.02,39.62) 161.85,42.8 v2(124.05,42.8)
  IN4 w0.084: v2(19.61,38.46) 20.01,38.85 24.04,38.85 24.56,38.33 27.14,38.33 v2(27.3,38.17)
  BOTTOM w0.102: v2(124.05,42.8) 123.69,43.17 122.53,43.17 122.38,43.01 64.68,43.01 63.75,43.94 57.94,43.94 56.88,45.01 52.45,45.01 49.97,47.5 48.96,47.5 47.4,49.06 46.86,49.06 46.27,49.65 43.03,49.65 41.98,48.6 39.56,48.6 39.26,48.3 38.15,48.3 37.22,47.37 37.22,44.72 31.76,39.26 30.25,39.26 28.98,37.99 27.49,37.99 v2(27.3,38.17) ; v2(225.07,85.83) 226.58,85.83 227.13,86.38 U32.4 ; v2(165.74,63.85) 165.33,63.43 165.33,62.71 165.51,62.53 165.51,61.15 166.09,60.57 166.09,59.6 166.22,59.47 166.22,58.2 v1(166.09,58.08) 166.09,57.61 166.34,57.35 166.34,40.94 v2(165.02,39.62)
F-IMAX: length 3.6
  TOP w0.203: v2(88.37,70.36) 88.37,70.43 88.85,70.92 PU500.10
  TOP w0.254: PR503.1 87.88,69.77 88.37,70.26 v2(88.37,70.36)
  BOTTOM w0.102: v1(88.01,69.81) 88.01,70 v2(88.37,70.36)
  BOTTOM w0.254: PR508.2 88.37,71.06 v2(88.37,70.36)
FAN1_PWM: length 61.4
  TOP w0.102: v2(30.89,14.16) 30.72,14.33 U38.A24 ; v2(56.45,50.42) 56.45,50.44 55.25,51.65 v1(55.25,51.71) 52.98,53.97 51.89,53.97 51.27,54.6 JFAN1.3 ; R408.2 v2(33.59,15.09)
  IN1 w0.084: v2(33.59,15.09) 34.35,14.33 37.48,14.33 40.71,17.56 40.71,21.45 41.77,22.51 41.77,23.82 42.17,24.23 44.31,24.23 44.56,24.47 44.56,28.78 45.31,29.53 45.31,31.15 46.48,32.32 46.48,39.27 48.53,41.31 48.53,42.07 56.14,49.68 56.14,50.11 v2(56.45,50.42)
  BOTTOM w0.102: v2(33.59,15.09) 33.49,15.19 31.25,15.19 30.89,14.82 v2(30.89,14.16)
FAN1_TACH: length 65.2
  TOP w0.102: R376.2 v2(37.44,13.32) ; JFAN1.2 53.02,54.56 53.02,54.27 53.51,53.78 53.76,53.78 v1(54.14,53.4) 54.14,53.36 v2(56.5,51) ; v2(28.44,12.36) 28.58,12.5 28.92,12.5 29.01,12.58 U38.B22
  IN1 w0.084: v2(56.5,51) 56.87,50.63 56.87,50.12 48.74,41.98 48.74,41.22 46.69,39.18 46.69,32.23 45.6,31.14 45.6,27.5 44.77,26.67 44.77,24.39 44.4,24.02 42.26,24.02 41.98,23.73 41.98,22.42 40.92,21.36 40.92,17.47 37.44,13.99 v2(37.44,13.32)
  BOTTOM w0.102: v2(28.44,12.36) 29.17,12.36 29.58,11.95 35.5,11.95 36.87,13.32 v2(37.44,13.32)
FB_+V1.05SP: length 3.6
  TOP w0.102: PR308.2 v1(239.94,77.24)
  TOP w0.254: PU300.4 239.18,74.58 239.83,75.22 PR307.2 PR308.2
FP_POA_EN: length 18.8
  TOP w0.102: v2(20.17,25.14) 20.34,25.31 T100.1 ; U37.A44 18.43,40.34 18.63,40.54 18.63,40.89 v2(18.83,41.1)
  IN1 w0.084: v2(20.17,25.14) 20.17,26.18 19.54,26.8 19.54,27.07 18.9,27.71 18.9,37.11 19.16,37.38 19.16,38.85 18.63,39.38 18.63,40.89 v2(18.83,41.1)
FWP#: length 12
  TOP w0.102: v2(14.91,8.46) 14.24,8.46 v1(13.72,8.98) 13.67,9.03 R399.2 R393.2 ; v2(21.01,12.16) 20.92,12.08 U38.B65
  BOTTOM w0.102: v2(14.91,8.46) 15.4,8.46 17.78,10.85 18.53,10.85 19.72,12.04 20.88,12.04 v2(21.01,12.16)
GFB: length 3.8
  TOP w0.102: PR532.1 v1(94.26,74.32)
  TOP w0.203: PR532.1 93.64,74.73 93.27,74.73 92.99,74.44 PU500.23
GPIO_PSID_SELECT: length 127.1
  TOP w0.102: v2(18.48,27.75) 18.69,27.75 18.93,28 U37.A6
  TOP w0.254: v2(79.59,98.12) 79.67,98.05 v1(79.67,97.08) 79.6,97.01 PU111.6
  IN1 w0.084: v2(79.59,98.12) 79.59,97.16 79.11,96.68 71.91,96.68 61.51,86.29 58.81,86.29 53.96,81.44 53.96,76.75 v2(54.34,76.36)
  IN4 w0.084: v2(54.34,76.36) 54.34,74.88 52.89,73.43 52.89,65.93 54,64.81 54,61.97 54.98,60.99 54.98,56.63 54.18,55.83 54.18,51.5 52.45,49.77 50.81,49.77 47.01,45.97 40.54,45.97 38.37,43.81 34.71,43.81 34.19,43.29 31.89,43.29 31.5,42.9 29.74,42.9 27.31,40.47 25.59,40.47 24.61,39.49 16.37,39.49 15.28,38.39 15.28,29.37 15.33,29.32 15.33,27.85 15.95,27.23 17.64,27.23 18.17,27.75 v2(18.48,27.75)
GPU_SMBCLK: length 7.7
  TOP w0.102: U38.B49 21.69,18.46 v2(22.25,17.9) ; RP3.6 17.71,18.84 17.89,19.02 18.24,19.02 v2(18.64,19.43)
  IN4 w0.084: v2(18.64,19.43) 18.64,19.25 19.82,18.07 21.58,18.07 21.75,17.9 v2(22.25,17.9)
GPU_SMBDAT: length 7.3
  TOP w0.102: RP3.7 17.97,19.34 v2(18.06,19.43) ; v2(22.24,18.52) 22.19,18.57 U38.B48
  IN4 w0.084: v2(22.24,18.52) 22.02,18.52 21.59,18.95 20.7,18.95 20.22,18.47 19.73,18.47 19.11,19.08 19.11,19.54 18.83,19.83 18.46,19.83 v2(18.06,19.43)
GREEN_DOCK: length 114.4
  TOP w0.102: R75.2 210.25,83.71 R312.1 210.24,83.91 209.96,84.19 209.96,84.8 214.63,89.47 214.63,92.25 215.58,93.2 v2(215.58,94.09)
  IN2 w0.122: v2(186.25,94.36) 186.25,95.14 187.91,96.8 203.15,96.8 204.65,95.3 209.05,95.3 209.68,95.93 214.3,95.93 215.58,94.65 v2(215.58,94.09)
  BOTTOM w0.102: v2(186.25,94.36) 186.25,93.78 185.73,93.26 168.4,93.26 v1(166.82,94.84) 165.25,96.41 159.72,96.41 159.48,96.64 157.35,96.64 156.96,97.03 155.52,97.03 152.77,94.27 146.57,94.27 145.73,95.11 144.53,95.11 143.85,95.78 136.74,95.78 134.91,93.95 130.57,93.95 129.08,95.44 129.08,99.47 128.95,99.6 JDOCK1.59
H_CATERR#: length 19.4
  BOTTOM w0.076: 109.91,77.83 110.27,77.46 110.85,77.46 111.27,77.04 112.33,77.04 112.52,76.84 112.77,76.84 112.94,77.01 112.94,77.19 113.18,77.42 113.69,77.42 UC1.K61
  BOTTOM w0.102: 109.91,77.83 109.12,78.61 107.66,78.61 107.06,79.21 v1(107.06,79.96) 107.06,84.82 107.49,85.25 107.49,86.31 106.87,86.93 105.76,86.93 104.78,87.91 RC113.2
H_CPU_SVIDALRT#: length 4.6
  BOTTOM w0.076: UC1.L62 113.3,76.31 113.08,76.09 112.08,76.09 111.68,76.49 111.01,76.49 110.87,76.63 v1(110.66,76.63) 110.17,76.63 109.91,76.36
  BOTTOM w0.102: 109.91,76.36 109.35,76.36 RC248.1
H_CPUPWRGD: length 84.7
  TOP w0.102: CC90.1 111.57,89.64 111.57,90.02 v1(112.04,90.49) 112.7,89.83 v2(112.7,89.57) ; v2(71.62,57.04) 71.34,57.04 RC106.1
  IN2 w0.122: v2(71.62,57.04) 72.19,57.61 72.19,58.57 71.92,58.84 70.73,58.84 70.61,58.95 70.61,63.63 72.53,65.54 72.53,67.81 72.89,68.17 72.89,73.36 73.23,73.7 73.23,76.5 79.23,82.5 81.53,82.5 85.18,86.15 92.6,86.15 95.27,88.82 97.3,88.82 100.29,91.82 101.44,91.82 104.13,94.5 107.81,94.5 109.31,93 109.78,93 110.92,91.86 110.92,91.52 112.7,89.73 v2(112.7,89.57)
  BOTTOM w0.076: 112.93,85.57 112.93,84.9 114.88,82.95 114.88,82.57 114.75,82.45 114.4,82.45 114.29,82.34 114.29,82.02 114.27,82 UC1.C61
  BOTTOM w0.102: 112.93,85.57 112.93,87.05 RC115.1 112.46,88.43 112.46,89.33 v2(112.7,89.57)
H_PROCHOT#: length 358.8
  TOP w0.102: PQ805.3 127.86,4.59 126.8,3.53 113.39,3.53 112.88,3.02 94.94,3.02 94.78,3.17 86.72,3.17 85.65,4.24 v1(85.65,10.01) 85.65,14.1 82.96,16.79 80.56,16.79 v2(80.06,16.29)
  TOP w0.254: v2(11.6,21.95) 12.63,21.95 Q9.1 13.07,20.6 R334.2 ; PR534.2 88.96,79.05 v2(89.58,79.67) 89.22,80.03 PC514.2 ; v2(98.36,99.03) 98.36,97.3 104.39,91.27 105.05,91.27 CC149.1 105.85,90.77 v2(106.25,90.37) ; v2(102.57,90.88) 102.15,91.3 PR728.2
  IN1 w0.254: v2(106.25,90.37) 105.33,91.29 102.97,91.29 v2(102.57,90.88) ; v2(80.06,16.29) 78.75,17.6 72.63,17.6 72.09,18.15 72.09,21.72 71.55,22.25 64.19,22.25 63.78,22.66 59.64,22.66 59.03,22.05 59.03,21.03 58.45,20.45 57.25,20.45 55.78,21.92 54.97,21.92 53.44,20.4 53.44,19.41 48.57,14.53 48.57,13.18 47.18,11.8 47.18,10.5 46.44,9.76 46.44,6.77 45.51,5.84 41.4,5.84 40.16,4.6 34.71,4.6 34,5.31 29.41,5.31 28.72,4.61 17.21,4.61 15.88,5.94 14.46,5.94 13.36,4.84 12.13,4.84 11.72,5.25 11.72,8.34 11.5,8.56 11.5,21.02 11.6,21.12 v2(11.6,21.95) 11.49,22.05 10.72,22.05 9.63,23.14 9.63,31.54 10.23,32.14 10.23,34.8 9.91,35.13 9.14,35.13 8.94,35.33 8.94,35.82 9.22,36.11 9.89,36.11 10.47,36.68 10.47,39.16 11.91,40.6 11.91,41.3 12.08,41.46 12.81,41.46 13.39,42.04 20.12,42.04 20.18,42.09 22.57,42.09 23.05,42.58 24.38,42.58 25.69,43.89 26.44,43.89 26.78,44.23 29.83,44.23 30.13,43.93 33.15,43.93 37.57,48.36 42.87,48.36 43.89,49.38 47.02,49.38 51.04,53.4 51.04,54.45 54.08,57.49 54.08,59.76 51.28,62.56 51.28,66.9 52.53,68.15 52.53,71.24 57.02,75.73 57.02,77.68 58.85,79.51 58.85,81.12 71.65,93.92 74.49,93.92 75.4,94.83 94.97,94.83 98.36,98.22 v2(98.36,99.03)
  IN2 w0.254: v2(89.58,79.67) 89.58,79.98 92.4,82.8 92.4,84.69 95.38,87.67 99.53,87.67 101.22,89.36 101.22,90.19 101.91,90.88 v2(102.57,90.88)
  BOTTOM w0.254: v2(106.25,90.37) 106.01,90.13 RC114.2 105.6,89.45 105.65,89.39 RC117.1
H_PROCHOT#_R: length 16.5
  IN2 w0.122: v2(110.3,78.04) 109.11,79.23 108.15,79.23 107.15,80.24 107.15,84.78 v2(108.13,85.76)
  BOTTOM w0.076: v2(110.3,78.04) 110.3,78 110.67,77.63 110.95,77.63 111.35,77.23 112.55,77.23 UC1.K63
  BOTTOM w0.102: v2(108.13,85.76) 108.13,86.33 v1(107.84,86.63) 107.13,87.33 106.29,87.33 RC117.2
H_THERMTRIP#: length 141.5
  TOP w0.102: v2(35.46,21.72) 35.31,21.56 35.31,21.08 35.38,21.01 Q12.3 v1(37.12,21.01) ; CC91.1 109.59,90.13 v2(110.17,90.13)
  IN1 w0.084: v2(62.07,77.32) 62.54,77.32 65.14,79.92 65.14,81.05 68.24,84.15 68.32,84.15 68.91,84.74 68.91,86.43 72.64,90.16 81.63,90.16 82.39,89.4 97.7,89.4 99.47,87.64 101.33,87.64 101.66,87.97 101.66,91.16 102.69,92.18 107.55,92.18 109.15,90.58 109.66,90.58 110.1,90.13 v2(110.17,90.13) ; v2(35.8,27.23) 35.65,27.08 35.65,24.65 35.46,24.46 v2(35.46,21.72)
  IN4 w0.084: v2(35.8,27.23) 35.9,27.13 41.52,27.13 42.12,26.54 45.11,26.54 45.76,27.19 45.76,29.06 47.66,30.97 47.66,34.1 53.94,40.38 54.01,40.38 55.41,41.78 55.41,44.63 56.46,45.68 59.91,45.68 60.45,46.22 60.45,48.3 60.52,48.36 60.52,65 62.32,66.81 62.32,77.06 v2(62.07,77.32)
  BOTTOM w0.102: v2(110.17,90.13) R24.2 RC172.1
H_THERMTRIP#_R: length 10.5
  BOTTOM w0.076: UC1.D60 114.4,81.01 113.96,81.45 113.96,81.68 113.63,82.02 113.63,82.27 113.47,82.42 113.06,82.42 112.81,82.66 112,82.66 111.11,83.55 111.11,83.91 111.19,83.98 111.73,83.98 111.81,84.06 111.81,84.21 111.73,84.29 111.19,84.29 111.11,84.37 111.11,85.57
  BOTTOM w0.102: 111.11,85.57 111.11,87.85 RC172.2
H_VCCST_PWRGD: length 83.1
  TOP w0.102: RC105.1 71.41,57.57 v2(71.63,57.78) ; UC4.4 111.64,95.21 v1(111.87,94.97) RC245.1 RC243.1 110.11,93.78 CC22.1 109.84,93.5 v2(106.46,93.5)
  IN1 w0.084: v2(106.46,93.5) 105.61,92.65 102.89,92.65 102.73,92.8 91.58,92.8 88.64,89.87 83.5,89.87 82.74,90.62 72.45,90.62 68.45,86.62 68.45,84.93 v2(68.44,84.92)
  IN2 w0.122: v2(68.44,84.92) 69.61,83.75 69.61,73.53 69.19,73.11 69.19,63.12 68.15,62.08 68.15,59.64 68.9,58.89 69.94,58.89 71.04,57.78 v2(71.63,57.78)
H_VCCST_PWRGD_XDP: length 13.5
  TOP w0.102: JXDP1.39 67.89,59.13 68.14,58.89 68.14,56.92 68.53,56.53 69.48,56.53 69.6,56.65 69.6,56.82 69.48,56.94 68.66,56.94 68.54,57.05 68.54,57.18 v1(68.67,57.3) 69.51,57.3 69.63,57.43 69.63,57.69 69.51,57.82 68.65,57.82 68.54,57.92 68.54,58.36 68.67,58.48 68.95,58.48 69.2,58.23 70.35,58.23 70.48,58.1 70.48,57.7 70.35,57.57 RC105.2 RC106.2
H_VR_EN: length 41.5
  TOP w0.102: v1(108.83,88.3) 108.29,88.84 RC256.2 107.29,88.34 RC246.1 106.83,87.25 106.83,86.46 107.09,86.21 v2(107.09,85.42)
  TOP w0.254: v2(84.32,71.73) PR536.1
  IN3 w0.254: v2(107.09,85.42) 107.09,86.69 106.69,87.08 105.87,87.08 104.99,87.96 101.78,87.96 97.82,84 91.02,84 90.12,83.1 90.12,79.04 88.72,77.65 86.72,77.65 86.03,76.96 86.03,76.52 85.2,75.7 85.2,72.62 v2(84.32,71.73)
H_VR_READY: length 52.2
  TOP w0.102: RC255.2 RC259.2 RC256.1 108.66,88.87 110.44,88.87 111.19,88.12 v1(111.73,88.12) 113.2,88.12 113.73,87.59 v2(113.73,86.84)
  TOP w0.254: v2(84.19,74.52) PR539.1
  IN3 w0.254: v2(113.73,86.84) 113.16,86.27 108.12,86.27 106.92,87.46 106.02,87.46 105.15,88.34 103.12,88.34 102.86,88.61 100.39,88.61 97.2,85.42 97.13,85.42 96.79,85.08 91.56,85.08 89.1,82.62 89.1,78.61 88.52,78.03 86.51,78.03 85.65,77.16 85.65,76.68 84.19,75.22 v2(84.19,74.52)
  BOTTOM w0.102: RC247.1 113.73,88.11 v2(113.73,86.84)
HDD_DET#: length 169.8
  IN2 w0.089: v2(152.45,73.14) 151.56,73.14 150.52,74.18 149.44,74.18 148.83,73.57 146.61,73.57 146.48,73.44 146.48,68.3 145.59,67.41 145.59,66.18 145.3,65.89 142.55,65.89 141.41,64.75 141.41,61.84 141.1,61.52 141.1,53.9 138.61,51.41 138.57,51.44 114.53,51.44 114.49,51.41
  IN2 w0.122: 114.49,51.41 113.82,50.74 74.74,50.74 74.27,50.26 68.52,50.26 67.76,49.5 64.38,49.5 v2(63.74,50.14)
  IN3 w0.122: v2(47.63,23.46) 48.46,22.62 48.46,19.94 47.18,18.65 47.18,12.23 49.64,9.77 v2(49.64,9.75)
  IN4 w0.084: v2(63.74,50.14) 63.74,45.44 60.94,42.64 59.76,42.64 51.21,34.08 51.21,30.59 49.23,28.61 49.23,25.88 47.63,24.28 v2(47.63,23.46)
  BOTTOM w0.076: 153.85,74.33 153.68,74.5 153.3,74.5 153.07,74.27 153.07,73.65 152.57,73.14 v2(152.45,73.14) 151.88,73.14 151.77,73.25 151.37,73.25 UC1.U1
  BOTTOM w0.102: RC11.1 157.56,74.29 156.35,74.29 v1(156.03,74.61) 155.74,74.32 155.44,74.32 155.07,73.95 154.23,73.95 153.85,74.33 ; JMINI3.51 49.3,8.65 49.52,8.86 49.52,9.63 v2(49.64,9.75)
HDD_DEVSLP: length 194
  TOP w0.102: R155.2 45.57,26.81 v1(44.48,25.72) v2(43.6,24.84)
  IN2 w0.122: v2(154.43,78.19) 156.15,78.19 159.06,75.28 159.06,72.23 160.47,70.82 160.47,66.76 161.86,65.37 161.86,64.83 163,63.69 163,62 163.61,61.39 163.61,60.37 164.44,59.54 164.44,58.92 164.95,58.42 164.95,56.93 165.73,56.16 165.73,55.79 166.17,55.35 166.17,50.29 162.91,47.03 149.46,33.58 134.02,33.58 133.19,32.75 125.35,32.75 124.62,33.48 63.07,33.48 61.77,32.18 55.84,32.18 55.04,31.37 54.03,31.37 52.1,29.44 51.1,29.44 50.42,28.76 50.42,27.33 49.61,26.52 46.66,26.52 45.2,25.05 43.82,25.05 v2(43.6,24.84)
  BOTTOM w0.076: UC1.L2 150.77,76.34 151.18,76.76 151.46,76.76 151.7,77 152.48,77 153.16,77.67 153.62,77.67 153.85,77.9
  BOTTOM w0.102: v2(154.43,78.19) 154.14,78.19 153.85,77.9 ; JMINI3.44 42.03,11.45 42.41,11.82 42.41,17.38 44.19,19.16 44.19,22.51 43.6,23.1 v2(43.6,24.84)
HDD_FALL_INT: length 9.5
  TOP w0.102: v2(155.56,73.06) 155.56,72.86 155.74,72.68 156.02,72.68 156.9,71.81 RP6.6
  IN2 w0.122: v2(155.56,73.06) 155.56,73.24 152.46,76.35 v2(152.46,76.42)
  BOTTOM w0.076: v2(152.46,76.42) 151.92,75.89 151.04,75.89 150.75,75.59 UC1.N2
HDMI_CEC: length 9.3
  TOP w0.102: JHDMI1.13 196.69,104.17 197.31,103.56 199.52,103.56 199.77,103.3 199.77,102.02 198.48,100.72 v1(198.48,99.26) 198.48,98.35 R473.2
HDMI_HPD_SINK: length 9.1
  TOP w0.102: R474.1 203.26,97.19 Q121.1 201.02,98.4 v1(201.02,99.2) 201.02,100.95 200.05,101.92 200.05,103.77 JHDMI1.19
HDMI_OB: length 11.2
  TOP w0.102: R463.2 R462.2 R466.2 R464.2 R469.2 R467.2 R468.2 R465.2 188.33,97.46 Q29.1 v1(187.96,95.28)
HOST_DEB_TX: length 53.1
  TOP w0.102: v2(6.54,5.54) 6.35,5.73 6.35,6.21 R400.1
  BOTTOM w0.102: v2(6.54,5.54) 6.4,5.68 5.38,5.68 4.18,6.87 4.18,7.34 2.57,8.95 2.57,9.3 3.01,9.74 4.6,9.74 4.64,9.7 6.9,9.7 7.28,10.08 7.28,19.9 3.61,23.57 3.61,29.23 1.32,31.52 1.32,35.6 4.18,38.46 6.34,38.46 6.63,38.75 6.63,40.12 7.35,40.84 8.67,40.84 9.67,41.85 JDEG1.3
HOST_DEBUG_RX: length 4.7
  TOP w0.102: v2(23.11,18.52) 23.19,18.59 U38.B46 ; R401.2 22.61,21.92 22.61,21.43 22.97,21.07 v2(22.97,20.98)
  IN1 w0.084: v2(23.11,18.52) 23.11,20.84 v2(22.97,20.98)
HOST_DEBUG_TX: length 240.9
  TOP w0.102: C241.1 210.38,14.8 JMINI1.16 ; v2(24.28,18.45) 24.19,18.54 U38.B44 ; RP1.5 7.32,4.89 v2(6.79,4.89) 6.39,4.89 5.89,5.38 R400.2
  IN2 w0.122: v2(24.28,18.45) 25.42,19.59 28.99,19.59 29.78,20.37 34.44,20.37 35.03,20.96 37.78,20.96 38.23,20.51 39,20.51 40.47,21.98 44.02,21.98 45.33,23.29 46.12,23.29 47.83,25 56.92,25 57.26,25.34 84.29,25.34 84.5,25.55 122.69,25.55 123.5,24.74 128.36,24.74 129.33,23.78 132.08,23.78 134.26,25.97 180.74,25.97 183.14,23.56 184.14,23.56 184.48,23.23 191.4,23.23 192.12,23.94 196.89,23.94 199.46,21.37 199.46,20.78 200.39,19.85 201.39,19.85 202.18,19.05 202.18,18.21 v2(201.85,17.88)
  IN3 w0.122: v2(24.28,18.45) 22.88,19.85 16.59,19.85 15.67,18.93 11.83,18.93 11.54,19.21 10.22,19.21 7.92,16.92 7.92,10.69 6.96,9.73 6.09,9.73 5.76,9.41 5.2,9.41 3.98,8.18 3.98,6.91 4.58,6.31 5.14,6.31 6.57,4.89 v2(6.79,4.89)
  BOTTOM w0.102: JMINI1.16 212.19,14.8 210.57,16.42 v1(207.75,16.42) 207.45,16.42 206.62,17.25 202.49,17.25 v2(201.85,17.88)
HSYNC_DOCK: length 124.5
  TOP w0.102: v2(207.14,81.36) 207.4,81.09 207.4,79.43 R84.2
  IN2 w0.122: v2(184.88,94.2) 184.87,94.2 184.87,95.57 187.37,98.06 203.69,98.06 205.19,96.56 208.52,96.56 209.37,97.41 216.43,97.41 217.93,95.91 v2(217.93,93.09)
  IN4 w0.084: v2(217.93,93.09) 212.83,87.99 211.25,87.99 209.46,86.19 209.46,83.21 207.6,81.36 v2(207.14,81.36)
  BOTTOM w0.102: v2(184.88,94.2) 184.55,93.87 168.65,93.87 164.88,97.64 155.27,97.64 152.52,94.88 146.82,94.88 145.99,95.72 144.78,95.72 144.11,96.39 136.49,96.39 134.66,94.56 130.83,94.56 129.85,95.54 129.85,98.53 130.45,99.13 JDOCK1.65
HW_GPS_DISABLE2#: length 232.3
  TOP w0.102: 25.42,38.77 24.85,39.34 24.85,41.59 R282.2 ; 25.42,38.77 v2(25.37,38.77) ; 25.42,38.77 25.17,38.52 U37.B34
  IN2 w0.122: v2(132.12,27.89) 132.67,28.44 135.95,28.44 137.98,30.47 160.75,30.47 176.42,46.14 v2(179.18,46.14)
  IN4 w0.084: v2(203.01,47.92) 204.08,48.98 204.08,51.24 204.92,52.09 204.92,63.38 v2(204.93,63.39)
  BOTTOM w0.102: JMINI2.51 205.86,63.75 205.5,63.39 v2(204.93,63.39) ; v2(132.12,27.89) 132.33,28.11 132.33,30.17 131,31.5 131,33.36 130.69,33.67 130.69,38.23 124.53,44.4 66.44,44.4 65.74,45.1 58.47,45.1 57.38,46.19 53.1,46.19 51.71,47.58 51.71,48.97 51.43,49.25 50.46,49.25 50.1,48.89 v1(49.87,48.89) 49.5,48.89 48.04,50.36 47.27,50.36 46.12,51.5 40.73,51.5 39.05,49.82 37.94,49.82 34.17,46.05 34.17,43.35 31.23,40.41 28.7,40.41 28.41,40.12 27.27,40.12 26.31,39.16 26.3,39.16 25.91,38.77 v2(25.37,38.77) ; v2(179.18,46.14) 179.36,46.32 201.41,46.32 v2(203.01,47.92)
I2C0_SCL: length 14.1
  BOTTOM w0.076: v2(151.92,78.66) 151.7,78.88 150.39,78.88 UC1.F3
  BOTTOM w0.102: v2(151.92,78.66) 152.37,79.12 152.37,79.42 152.73,79.77 154.26,79.77 154.67,80.19 155.18,80.19 156.11,79.25 156.11,78.86 156.66,78.31 157.44,78.31 157.68,78.56 157.68,78.84 157.97,79.12 159.19,79.12 159.59,79.52 160.62,79.52 160.73,79.41 160.73,79.26 160.52,79.04 RC208.2
I2C0_SDA: length 13.6
  BOTTOM w0.076: v2(151.92,79.25) 151.72,79.05 150.92,79.05 UC1.F2
  BOTTOM w0.102: RC204.2 161.15,79.04 160.96,79.23 160.96,79.5 160.72,79.75 159.5,79.75 159.21,79.46 v1(158.85,79.46) 157.99,79.46 157.45,78.93 157.45,78.65 157.34,78.54 156.76,78.54 156.34,78.96 156.34,79.35 155.27,80.42 154.58,80.42 154.17,80 152.63,80 152.15,79.52 152.15,79.43 151.96,79.25 v2(151.92,79.25)
I2C1_SCL_TCH_PAD: length 95.1
  TOP w0.102: v2(157.02,78.94) 157.37,79.29 159.91,79.29 160.36,78.83 160.72,78.83 161.21,78.33 RC203.2 RC176.2 162.88,78.33 164.19,79.64 167.34,79.64 167.84,79.14 167.84,77.72 168.81,76.76 171.08,76.76 172.73,75.11 172.73,72.58 171.99,71.84 171.99,68.44 172.93,67.5 174.9,67.5 178.24,64.16 178.24,58.01 177.69,57.45 177.69,53.75 178.24,53.19 178.24,48.66 182.65,44.25 v1(182.65,35.94) 182.65,23.23 183.44,22.44 183.81,22.44 184.38,21.87 185.67,21.87 185.95,21.59 185.95,20.95 187.3,19.61 187.3,18.36 188.2,17.46 188.96,17.46 R449.1
  BOTTOM w0.076: 153.85,80.26 152.18,80.26 151.29,79.38 UC1.F1
  BOTTOM w0.102: v2(157.02,78.94) 157.04,78.96 157.04,79.2 155.55,80.7 154.53,80.7 154.1,80.26 153.85,80.26
I2C1_SCL_VMM: length 54.4
  TOP w0.102: v2(191.79,85.57) 192.11,85.26 U6.A2 ; RC176.1 163.49,79.87 167.44,79.87 168.11,79.2 168.11,78.63 168.48,78.26 v2(168.59,78.26) 168.59,77.65 v1(168.71,77.53)
  IN3 w0.122: v2(191.79,85.57) 191.74,85.63 188.39,85.63 186.7,83.95 182.5,83.95 180.14,86.3 176.05,86.3 174.43,87.92 163.61,87.92 162.92,87.23 162.17,87.23 161.94,87 161.94,82.17 164.09,80.03 166.1,80.03 167.21,78.93 167.81,78.93 168.48,78.26 v2(168.59,78.26)
I2C1_SDA_TCH_PAD: length 101.5
  TOP w0.102: v2(172.01,77.7) 172.01,77.65 v1(173.19,76.47) 174,77.28 174.82,77.28 174.94,77.15 174.94,76.45 175.35,76.04 175.35,68.67 179.39,64.63 179.39,57.54 178.83,56.98 178.83,54.22 179.39,53.66 179.39,49.13 185.15,43.37 185.15,30.87 186.15,29.88 186.15,23.84 187.53,22.45 187.53,18.87 188.2,18.2 R450.1 ; v2(153.09,79.03) 153.53,79.48 153.9,79.48 154.51,78.87 155.64,78.87 155.64,78.85 RC174.2 156.41,78.07 157.1,77.38 RC201.2
  IN3 w0.089: v2(153.09,79.03) 152.34,78.29 151.01,78.29 150.45,77.72 150.12,77.72 v2(149.62,78.22)
  IN3 w0.122: v2(153.09,79.03) 153.53,79.48 154.29,79.48 154.49,79.28 155.14,79.28 156.03,80.17 160.76,80.17 161.28,80.7 162.17,80.7 163.72,79.14 165.74,79.14 168.11,76.77 171.08,76.77 v2(172.01,77.7)
  BOTTOM w0.076: UC1.G4 149.32,78.6 149.62,78.3 v2(149.62,78.22)
I2C1_SDA_VMM: length 51.1
  TOP w0.102: v2(191.01,84.94) 191.14,84.8 U6.A1 ; v2(153.4,78.07) 153.94,78.6 154.98,78.6 RC174.1
  IN2 w0.089: 152.67,82.36 153.85,83.54
  IN2 w0.122: v2(153.4,78.07) 152.67,78.8 152.67,82.36 ; v2(163.67,87.15) 163.38,87.44 156.93,87.44 154.89,85.39 154.89,84.58 153.85,83.54
  IN3 w0.122: v2(163.67,87.15) 164.19,87.68 174.32,87.68 175.94,86.05 180.04,86.05 182.41,83.68 189.46,83.68 190.72,84.94 v2(191.01,84.94)
I2S_BCLK: length 4.1
  TOP w0.102: R139.2 279.43,31.04 279.43,31.43 278.29,32.57 U17.16
I2S_DI#: length 4.1
  TOP w0.102: R144.2 278.92,39.01 v1(278.92,38.32) 278.92,37.88 277.6,36.57 U17.24
I2S_DO: length 3.7
  TOP w0.102: R142.2 v1(278.9,32.45) 278.28,33.07 U17.17
I2S_LRCLK: length 3.5
  TOP w0.102: R143.2 278.9,33.34 278.22,33.34 v1(278.03,33.53) 277.54,33.53 277.5,33.57 U17.18
I2S_MCLK: length 4.5
  TOP w0.102: U17.15 278.46,32.07 279.2,31.33 279.2,30.38 R137.2
IMON: length 4.7
  TOP w0.203: PU500.13 90.05,70.86 90.13,70.78 90.13,70.35 v2(90.16,70.35)
  BOTTOM w0.102: PR501.2 90.04,69.42 v1(90.79,68.67)
  BOTTOM w0.254: PR501.2 90.13,69.66 90.13,70.35 v2(90.16,70.35) 90.5,70.35 PC500.2
IMVP_PWRGD: length 105.7
  TOP w0.102: v2(13.96,31.85) 14.04,31.77 U37.A62 ; PR540.1 83.49,73.63 80.24,70.38 78.59,70.38 78.19,69.99 78.19,68.59 74.99,65.39 74.99,62.96 73.61,61.57 73.61,51.53 72.06,49.98 v2(72.06,49.06)
  IN4 w0.084: v2(52.02,51.66) 52.02,51.28 46.92,46.19 40.45,46.19 38.28,44.02 34.62,44.02 34.1,43.5 31.8,43.5 31.41,43.11 29.66,43.11 27.23,40.68 25.5,40.68 24.52,39.7 16.28,39.7 15.07,38.48 15.07,32 14.91,31.85 v2(13.96,31.85)
  BOTTOM w0.102: v2(72.06,49.06) 71.64,49.48 70,49.48 68.91,48.38 57.95,48.38 57.57,48.01 54.82,48.01 53.87,48.97 53.87,49.87 52.29,51.45 52.23,51.45 v2(52.02,51.66)
IMVP_VR_ON: length 113.4
  TOP w0.102: v2(16.37,31.52) U37.B66
  TOP w0.254: v2(78.66,53.89) v1(78.66,55.4) 77.51,56.55 77.51,64.72 78.66,65.87 78.66,67 82.51,70.85 PR537.1
  IN2 w0.122: v2(56.52,51.59) 56.07,51.59 51.96,47.48 49.64,47.48 48.49,48.63 43.3,48.63 38.04,43.37 35.32,43.37 31.6,39.66 25.63,39.66 24.85,38.87 16.32,38.87 15.37,37.92 11.14,37.92 10.56,37.34 9.04,37.34 8.63,36.93 8.63,34.48 9.13,33.98 10.01,33.98 10.26,33.73 10.26,31.86 10.86,31.27 v2(11.16,31.27)
  BOTTOM w0.102: v2(16.37,31.52) 14.69,31.52 14.44,31.27 v2(11.16,31.27)
  BOTTOM w0.254: v2(56.52,51.59) 58.7,51.59 59.41,52.3 63.49,52.3 63.81,52.62 66.03,52.62 66.97,53.56 68.99,53.56 69.32,53.89 v2(78.66,53.89)
INT_SPK_L+: length 17.4
  IN1 w0.102: 270.36,35.47 269.89,35.47
  IN1 w1.016: 270.36,35.47 270.37,35.48 270.85,35.48 272.49,33.84 273.77,33.84 278.13,29.49 278.13,27.2 279.76,25.58 279.76,23.46
  vias: v1(279.67,22.81) v2(268.43,35.52) v2(268.95,35.22) v2(280.19,22.58) v2(280.77,22.58)
INT_SPK_L-: length 14.5
  IN1 w1.016: 270.36,34.16 271.97,32.55 273.34,32.55 276.9,28.99 276.9,26.69 277.79,25.81 277.79,23.57
  vias: v1(278.8,20.33) v2(268.36,34.65) v2(268.97,34.57) v2(277.27,22.4) v2(277.83,22.61)
INT_SPK_R+: length 15.3
  IN1 w1.016: 275.65,21.6 272.48,21.6 269.65,24.43 269.65,31.17 268.68,32.13
  vias: v1(268.47,33.3) v2(267.55,33.97) v2(268.05,33.65) v2(276.48,22.38) v2(276.52,21.75)
INT_SPK_R-: length 10.6
  IN1 w1.016: 269.78,32.9 270.88,31.8 270.88,25.13 272.53,23.48
  vias: v1(272.29,22.75) v2(268.49,34.06) v2(268.99,33.74) v2(272.8,22.64) v2(273.39,22.66)
INT_SPKR_L+:
  vias: v1(280.26,16.64)
INT_SPKR_L-:
  vias: v1(277.6,16.98)
INT_SPKR_R+:
  vias: v1(274.83,17.32)
INT_SPKR_R-:
  vias: v1(272.71,17.13)
INTRUDER#: length 9
  TOP w0.102: RC7.2 146.89,55.46 147.94,55.46 v1(148.2,55.71) 148.2,58.71 v2(147.82,59.09)
  BOTTOM w0.076: UC1.AU6 148.26,61.81 148.26,61.38 148.19,61.32 148.19,59.47 v2(147.82,59.09)
IO_LDOSEL: length 5.3
  TOP w0.102: U27.18 254.44,20.1 254.41,20.14 R212.2 R214.1 252.13,21.61 v1(250.81,21.61)
IO_LOOP: length 2
  BOTTOM w0.102: JEDP1.29 66.05,74.7 66.29,74.46 R108.1
IRQ_SERIRQ: length 214.8
  TOP w0.102: v2(31.5,16.56) 31.26,16.33 U38.A28 ; v2(24.05,32.03) 24.77,32.03 U37.B21 ; v2(163.14,74.09) 163.14,74.82 RC178.2 ; U25.27 35.97,35.9 35.55,35.47 34.72,35.47 34.15,36.04 v2(34.15,36.4) 33.91,36.4 v1(33.41,35.9)
  IN1 w0.084: v2(34.15,36.4) 34.15,35.38 34.25,35.28 34.25,32 v2(34.18,31.93) 34.18,29.55 v2(34.42,29.3) 34.5,29.3 35.18,28.62 35.18,24.84 34.99,24.65 34.99,22.42 34.01,21.44 34.01,21.07 33.16,20.22 33.16,18.22 v2(31.5,16.56)
  IN2 w0.089: v2(149.62,73.72) 149.62,73.65 151.23,72.04 151.23,66.8 151.62,66.42 151.62,65.79 152.19,65.22 152.19,64.74 151.62,64.17 151.62,63.68 151.66,63.64 151.66,62.7 151.2,62.23 151.2,60.6 151.33,60.47 151.33,58.44 152.61,57.16 152.61,53.08 153.85,51.84
  IN2 w0.122: v2(34.42,29.3) 34.55,29.44 34.58,29.44 36.11,30.97 40.75,30.97 41.29,30.43 45.52,30.43 47.87,32.77 47.87,33.48 48.88,34.49 50.31,34.49 53.1,37.28 53.56,37.28 54.71,38.42 58.5,38.42 59.02,37.91 144.71,37.91 154.07,47.27 154.07,51.62 153.85,51.84
  IN3 w0.089: v2(149.62,73.72) 150.17,74.27 150.99,74.27 151.44,74.71 153.53,74.71 153.61,74.64 153.85,74.64
  IN3 w0.122: 153.85,74.64 154.7,74.64 155.32,74.02 157.75,74.02 158.56,73.21 160.55,73.21 161.98,74.64 162.6,74.64 v2(163.14,74.09)
  IN4 w0.084: v2(34.18,31.93) 33.82,32.28 28.54,32.28 28.07,31.81 27.43,31.81 26.54,30.93 25.51,30.93 24.41,32.03 v2(24.05,32.03)
  BOTTOM w0.076: UC1.T4 149.32,74.02 v2(149.62,73.72)
