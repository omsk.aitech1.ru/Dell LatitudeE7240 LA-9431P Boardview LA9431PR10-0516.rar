# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDP_LANE_N2: length 3.6
  TOP w0.089: C168.1 178.23,83.66 178.23,83.92 177.91,84.24 176.28,84.24 176.14,84.38 U19.38
MDP_LANE_N2_C: length 108.1
  TOP w0.089: v2(178.49,81.83) 178.37,81.83 178.08,82.11 178.08,82.63 178.17,82.71 178.27,82.71 C168.2
  IN2 w0.102: JMDP1.17 273.82,88.55 273.94,88.43 273.94,87.72 272.81,86.59 266.77,86.59 266.04,85.85 257.89,85.85 257.51,85.48 247.61,85.48 246.71,86.37 242.14,86.37 240.78,87.73 235.26,87.73 234.09,86.56 226.29,86.56 225.88,86.97 210.29,86.97 208.08,89.18 197.77,89.18 197.22,89.73 191.55,89.73 190.82,89 189.3,89 187.78,87.48 186.03,87.48 184.86,86.31 184.15,86.31 183.44,85.6 183.44,83.49 182.32,82.37 182.32,82.03 181.42,81.13 178.23,81.13 178.04,81.32 178.04,81.49 178.37,81.83 v2(178.49,81.83)
MDP_LANE_N3: length 3.2
  TOP w0.089: C172.1 176.42,82.89 176.42,83.13 176.14,83.41 175.95,83.41 175.14,84.22 U19.36
MDP_LANE_N3_C: length 109.6
  TOP w0.089: C172.2 176.53,81.86 176.37,81.86 176.28,81.77 176.28,81.18 176.46,81 178.29,81 179.18,81.89 179.18,82.38 v3(179.7,82.89) 180.54,83.74 180.54,84.07 v2(180.45,84.16)
  IN2 w0.102: v2(180.45,84.16) 180.78,84.49 180.78,85.46 183.19,87.86 183.19,88.76 183.54,89.12 186.32,89.12 186.6,89.39 188.49,89.39 188.93,89.83 190.58,89.83 191.22,90.47 197.52,90.47 198.07,89.92 208.41,89.92 209.52,88.81 217.33,88.81 218.41,87.73 226.21,87.73 226.62,87.32 232.96,87.32 235.35,89.71 240.13,89.71 242.66,87.18 247.04,87.18 248.01,86.21 257.13,86.21 257.51,86.59 263.46,86.59 264.63,87.76 265.3,87.76 265.52,87.54 265.52,87.26 v2(265.68,87.1)
  BOTTOM w0.089: v2(265.68,87.1) 265.56,87.22 265.56,87.46 265.83,87.73 268.9,87.73 270.56,89.39 270.56,90.39 270.63,90.46 270.78,90.46 270.89,90.35 271.08,90.35 271.79,90.35
  BOTTOM w0.102: JMDP1.12 271.79,90.35
MDP_LANE_P0: length 2.2
  TOP w0.089: C164.1 178.28,87.35 177.98,87.35 177.73,87.1 177.41,87.1 177.28,86.97 U19.41
MDP_LANE_P0_C: length 105.5
  TOP w0.089: v2(180.7,88.25) 179.98,87.53 179.56,87.53 179.45,87.43 C164.2
  IN2 w0.102: v2(180.7,88.25) 180.37,88.58 180.37,89.02 180.69,89.33 181.03,89.33 182.59,90.89 185.39,90.89 185.85,91.36 185.85,91.7 186.14,91.99 188,91.99 188.4,92.38 195.81,92.38 195.94,92.24 206.47,92.24 206.64,92.4 209.96,92.4 210.17,92.19 212.32,92.19 212.59,91.92 216.33,91.92 216.59,91.67 219.95,91.67 220.56,92.28 220.56,93.09 221.4,93.93 223.93,93.93 224.29,94.3 227.04,94.3 228.27,93.07 239.89,93.07 244.55,88.4 261.65,88.4 262.38,89.14 268.85,89.14 273.27,93.56 273.77,93.56 273.94,93.39 273.94,92.89 273.8,92.75 JMDP1.3
MDP_LANE_P1: length 2
  TOP w0.089: C166.1 177.83,85.58 177.65,85.58 177.41,85.83 177.41,86.01 177.36,86.06 177.22,86.06 177.12,85.97 U19.39
MDP_LANE_P1_C: length 106.6
  TOP w0.089: v2(179.66,84.77) 179.79,84.9 179.79,85.47 179.71,85.55 179.37,85.55 C166.2
  IN2 w0.102: JMDP1.9 274.42,90.78 273.6,90.78 273.3,91.07 271.55,91.07 268.97,88.49 264.23,88.49 263.66,87.92 244.19,87.92 239.55,92.56 227.23,92.56 226.34,93.45 222.19,93.45 221.67,92.92 221.67,92.6 220.1,91.03 215.56,91.03 215.47,91.12 213.6,91.12 213.31,90.83 211.27,90.83 210.81,91.29 210.16,91.29 209.54,91.91 206.83,91.91 206.58,91.67 195.25,91.67 195.02,91.9 190.48,91.9 189.25,90.66 188.54,90.66 188.16,90.28 186.45,90.28 186.03,89.86 183.05,89.86 182.38,89.2 182.38,88.26 179.83,85.7 179.83,84.94 v2(179.66,84.77)
MDP_LANE_P2: length 3.6
  TOP w0.089: C170.1 177.91,83.66 177.91,83.79 177.78,83.92 v3(176.58,83.92) 176.14,83.92 175.64,84.43 U19.37
MDP_LANE_P2_C: length 108.3
  TOP w0.089: C170.2 177.76,82.33 177.76,81.84 v2(177.78,81.83)
  IN2 w0.102: v2(177.78,81.83) 177.78,81.22 178.13,80.87 181.52,80.87 182.57,81.92 182.57,82.26 183.69,83.38 183.69,85.5 184.25,86.05 184.96,86.05 186.13,87.22 187.88,87.22 189.41,88.75 190.92,88.75 191.65,89.48 197.11,89.48 197.66,88.92 207.97,88.92 210.18,86.72 225.78,86.72 226.18,86.31 234.19,86.31 235.36,87.48 240.67,87.48 242.03,86.12 246.61,86.12 247.5,85.22 257.62,85.22 257.99,85.6 266.14,85.6 266.88,86.33 272.91,86.33 274.2,87.62 274.2,88.46 JMDP1.15
MDP_LANE_P3: length 3.2
  TOP w0.089: v3(175.12,83.79) 175.12,83.79 ; 175.12,83.79 175.81,83.1 176,83.1 176.1,83 176.1,82.89 C173.1 ; 175.12,83.79 174.82,84.09 174.82,84.29 174.64,84.47 U19.35
MDP_LANE_P3_C: length 109.7
  TOP w0.089: v2(181.03,84.16) 180.86,83.99 180.86,83.6 179.5,82.24 179.5,81.76 v3(178.89,81.15) 178.42,80.68 176.33,80.68 175.96,81.05 175.96,81.55 C173.2
  IN2 w0.102: v2(265.1,87.1) 265.27,87.26 265.27,87.44 265.2,87.5 264.73,87.5 263.56,86.33 257.61,86.33 257.24,85.96 247.91,85.96 246.94,86.93 242.55,86.93 240.03,89.46 235.45,89.46 233.06,87.07 226.51,87.07 226.11,87.48 218.3,87.48 217.22,88.56 209.41,88.56 208.31,89.66 197.97,89.66 197.42,90.22 191.32,90.22 190.68,89.57 189.03,89.57 188.6,89.14 186.71,89.14 186.43,88.86 183.65,88.86 183.44,88.65 183.44,87.76 181.03,85.35 v2(181.03,84.16)
  BOTTOM w0.089: v2(265.1,87.1) 265.24,87.24 265.24,87.6 265.7,88.05 268.77,88.05 270.24,89.52 270.24,90.53 270.5,90.78 270.71,90.78 270.88,90.95 JMDP1.10
ME_FWP: length 211.5
  TOP w0.102: RC9.1 164.86,48.36 v1(166.16,49.65) v2(170.22,53.72) ; U37.A8 19.93,27.17 R326.1 19.7,27.16 v2(19.18,26.64)
  IN2 w0.122: v2(170.22,53.72) 170.22,47.71 153.82,31.3 137.37,31.3 135.96,29.9 131.46,29.9 129.82,28.25 v2(129.82,27.89)
  BOTTOM w0.102: v2(129.82,27.89) 129.82,28.85 128.94,29.73 128.94,32.43 128.6,32.77 128.6,36.84 126.6,38.85 120.43,38.85 120.18,38.6 62.18,38.6 61.02,39.75 55.91,39.75 55.06,40.6 52.72,40.6 52.44,40.88 50.08,40.88 49.33,41.63 49.33,43.65 46.38,46.6 42.29,46.6 36.18,40.49 36.18,40.02 31.47,35.31 30.67,35.31 28.99,33.63 28.99,27.3 29.52,26.77 29.52,26.04 29.14,25.67 28.89,25.67 28.23,25.01 25.56,25.01 24.05,26.52 19.3,26.52 v2(19.18,26.64)
ME_RESET#: length 3.6
  TOP w0.102: UC2.2 170.42,72.55 170.28,72.41 RC76.1 RC81.2 169.29,71.48 v1(169.29,70.65)
ME_SUS_PWR_ACK: length 202.8
  TOP w0.102: U38.A8 24.44,8.49 v2(24.37,8.42) ; RP10.8 154.49,56.05 154.34,55.9 RC94.1 153.4,53.63 154.67,52.36 v1(156.72,52.36) 156.97,52.36 v2(157.34,52.73)
  IN3 w0.122: v2(135.46,16.03) 134.12,14.68 131.47,14.68 130.09,16.06 125.11,16.06 124.82,16.36 124.04,16.36 122.9,15.22 120.68,15.22 119.86,14.4 117.08,14.4 116.13,15.35 112.49,15.35 111.23,16.61 104.8,16.61 103.28,15.09 100.2,15.09 99.62,15.67 83.26,15.67 82.63,16.31 82.63,22.4 82.25,22.78 72.01,22.78 71.5,22.28 64.19,22.28 63.4,23.06 56.26,23.06 53.24,20.04 52.22,20.04 51.74,19.56 51.74,18.44 50.44,17.14 50.44,14.1 51.44,13.11 51.44,8.94 50.6,8.1 50.01,8.1 49.56,7.64 47.22,7.64 46.18,6.6 43.05,6.6 41.94,7.72 38.68,7.72 36.96,5.99 31.83,5.99 31.01,6.81 30.51,6.81 30.15,6.45 28.5,6.45 27.86,7.09 27.58,7.09 26.9,7.77 25.02,7.77 v2(24.37,8.42)
  BOTTOM w0.102: v2(135.46,16.03) 135.39,16.1 135.39,18.97 135.99,19.57 135.99,22.57 134.67,23.89 134.67,28.24 138.43,31.99 138.43,46.66 141,49.22 155.59,49.22 157.34,50.98 v2(157.34,52.73)
ME_SUS_PWR_ACK_R: length 33.9
  TOP w0.102: RC94.2 v1(153.4,57.85) 153.4,58.09 v2(153.1,58.39)
  IN2 w0.122: v2(165.72,59.42) 166.05,59.75 166.05,60.95 165.6,61.4 165.6,62.29 165.28,62.61 165.28,63.87 165.06,64.08 165.06,64.91 v2(164.17,65.8)
  IN3 w0.122: v2(153.1,58.39) 153.52,57.97 156.13,57.97 156.56,57.54 159.71,57.54 160.29,58.12 161.14,58.12 162.01,58.99 165.29,58.99 v2(165.72,59.42)
  BOTTOM w0.076: UC1.AV4 149.62,61.18 149.62,60.71 149.68,60.66 149.68,59.98
  BOTTOM w0.102: v2(153.1,58.39) 153.1,58.15 152.9,57.95 151.94,57.95 150.42,59.47 150.18,59.47 149.68,59.98 ; RC82.1 161.1,69.25 161.81,68.54 161.81,68.16 v2(164.17,65.8)
MEC_XTAL1: length 8.6
  TOP w0.203: v1(12.05,11.4) 13.37,12.72 Y4.1 14.3,12.72 14.92,12.09 C364.1 16.13,12.09 16.78,11.44 17.99,11.44 18.88,12.33 U38.A61
MEC_XTAL2: length 5
  TOP w0.203: v1(11.99,10.07) 12.14,10.22 Y4.2 14.17,10.22 15.11,11.16 C365.1 16.19,11.16 R378.2
MEC_XTAL2_R: length 3.6
  TOP w0.102: R378.1 17.26,10.84 v1(17.64,10.84) 17.96,10.84 18.95,11.83 U38.A62
MEDIACARD_IRQ#: length 219.5
  TOP w0.102: v2(148.17,71.24) 147.72,71.68 146.13,71.68 RC205.1 ; U27.16 254.45,20.9 254.36,20.99 253.92,20.99 253.53,20.6 v2(253.53,20.55) ; v2(267.77,75.09) 268.64,75.09 v1(268.88,74.85)
  IN2 w0.122: v2(253.53,20.55) 253.53,20.66 254.62,21.75 254.62,25.77 256.61,27.76 259.54,27.76 261.21,29.43 262.57,29.43 263.96,28.04 264.77,28.04 266.74,30.01 267.3,30.01 268.53,31.25 269.27,31.25 271.36,33.34 271.36,45.32 268.42,48.25 268.42,72.8 268.34,72.88 268.34,74.36 267.77,74.93 v2(267.77,75.09)
  IN3 w0.089: 153.85,71 153.18,71 152.9,70.71 151.5,70.71 150.74,71.47 149.66,71.47 149.02,70.84 148.56,70.84 v2(148.17,71.24)
  IN3 w0.122: v2(267.77,75.09) 267.77,75.77 267.12,76.41 267.12,80.5 264.69,82.93 258.98,82.93 257.66,84.25 243.21,84.25 239.87,87.58 239.87,88.7 239.16,89.42 234.35,89.42 234.09,89.16 226.78,89.16 225.28,87.67 218.04,87.67 217.95,87.58 215.3,87.58 213.97,88.91 210.65,88.91 210.38,89.18 204.21,89.18 202.76,87.73 202.76,86.96 200.25,84.45 200.25,83.4 199.54,82.68 199.54,79.61 197.17,77.25 192.74,77.25 192.47,77.52 190.16,77.52 189.09,76.45 188.44,76.45 187.9,75.91 187.9,74.51 187.6,74.22 183.6,74.22 182.63,73.24 176.89,73.24 176.23,72.58 173.21,72.58 172.36,71.73 169.05,71.73 168.63,71.31 165.09,71.31 164.69,71.7 164.25,71.7 163.79,72.16 161.44,72.16 160.52,71.24 157.61,71.24 157.37,71 153.85,71
  BOTTOM w0.076: UC1.AB6 147.99,71.06 v2(148.17,71.24)
MEDIACARD_PWREN: length 214.7
  TOP w0.102: U27.14 254.17,21.7 v2(253.99,21.88)
  IN2 w0.122: v2(253.99,21.88) 254.37,22.26 254.37,25.87 256.51,28.01 259.44,28.01 261.11,29.68 262.8,29.68 264.16,28.32 264.66,28.32 266.6,30.26 267.19,30.26 268.43,31.5 269.16,31.5 271.07,33.42 271.07,45.25 268.17,48.15 268.17,72.7 268.02,72.85 268.02,74.21 266.44,75.79 263.04,75.79 262.81,75.56 260.62,75.56 259.85,76.33 255.95,76.33 254.52,77.77 253,77.77 252.68,78.08 252.12,78.08 251.68,77.64 250.92,77.64 250.41,77.13 247.15,77.13 245.63,78.65 245.29,78.65 245.1,78.46 242.67,78.46 242.34,78.79 242.34,79.53 240.93,80.94 238.98,80.94 237.3,82.61 224.02,82.61 v2(222.57,84.06)
  IN3 w0.122: v2(222.57,84.06) 222.25,84.38 220.6,84.38 220.12,83.9 212.15,83.9 211.96,83.71 210.17,83.71 206.24,79.78 205.2,79.78 202.93,77.52 202.39,77.52 201.59,76.72 201.23,76.72 200.27,75.76 200.27,74.71 199.4,73.84 192.7,73.84 189.93,71.06 185.48,71.06 185.04,70.62 183.87,70.62 182.48,69.23 176.73,69.23 175.78,68.28 175.78,66.76 176.85,65.69 176.85,63.69 174.74,61.58 174.74,60.57 173.96,59.79 172,59.79 170.42,61.37 169.49,61.37 168.88,61.98 167.77,61.98 166.32,60.53 162.8,60.53 v2(162.31,60.03)
  BOTTOM w0.076: 153.85,63.03 152.46,63.03 152.24,63.24 151.85,63.24 151.49,63.6 UC1.AP1
  BOTTOM w0.102: v2(162.31,60.03) 162.42,60.15 162.42,63.59 160.11,65.9 159.65,65.9 159.17,66.38 RP5.5 v1(157.37,66.38) 156.99,66.38 154.95,64.34 154.95,64.1 153.88,63.03 153.85,63.03
MEDIACARD_RST#: length 206.2
  TOP w0.102: RP7.8 162.18,70.81 v2(162.32,70.67) ; v1(267.73,74.14) 267.42,74.45 v2(267.19,74.45) ; U26.2 v2(253.29,28.8)
  IN2 w0.122: v2(267.19,74.45) 267.19,73.32 267.92,72.59 267.92,48.05 269.74,46.23 269.74,43.63 270.83,42.54 270.83,33.52 269.05,31.75 268.33,31.75 267.11,30.53 266.35,30.53 265.75,29.93 261.01,29.93 259.88,28.8 v2(253.29,28.8)
  IN3 w0.122: v2(162.32,70.67) 162.47,70.53 162.66,70.53 163.26,69.93 166.47,69.93 166.54,69.86 168.23,69.86 169.35,70.98 172.66,70.98 173.52,71.83 176.54,71.83 177.2,72.49 184.79,72.49 185.48,73.18 189.1,73.18 189.86,73.94 191.02,73.94 193.66,76.58 197.49,76.58 200.21,79.3 200.21,80.44 201.51,81.75 205.4,81.75 207.09,83.44 207.68,83.44 210.21,85.97 212.33,85.97 213.2,86.83 218.26,86.83 218.35,86.92 227.91,86.92 228.19,87.2 232.83,87.2 234.55,88.91 238.9,88.91 239.33,88.48 239.33,87.41 243.18,83.56 243.18,82.88 244.65,81.41 246.08,81.41 247.75,79.73 254.76,79.73 255.52,80.49 257.94,80.49 259.87,82.42 264.49,82.42 266.62,80.29 266.62,75.02 v2(267.19,74.45)
  IN4 w0.084: v2(148.3,68.38) 148.68,68.75 149.27,68.75 149.47,68.55 150.41,68.55 150.97,69.11 150.97,69.33 151.57,69.94 154.99,69.94 155.08,70.03 158.49,70.03 159.28,70.82 162.17,70.82 v2(162.32,70.67)
  BOTTOM w0.076: UC1.AG6 147.99,67.9 148.3,68.22 v2(148.3,68.38)
MEM_SMBCLK: length 19.6
  TOP w0.102: QC1.6 163.23,71.97 162.97,71.7 162.97,70.88 162.83,70.74 162.83,70.05 163.04,69.84 RC28.2 163.04,68.76 v2(163.12,68.68)
  IN3 w0.122: v2(157.1,67.08) 157.32,67.3 160.22,67.3 160.38,67.45 162.4,67.45 162.94,68 162.94,68.5 v2(163.12,68.68)
  BOTTOM w0.076: UC1.AP2 150.86,63.6 151.15,63.9 151.43,63.9 151.92,63.41 152.45,63.41 152.46,63.41 153.85,63.41
  BOTTOM w0.102: 153.85,63.41 153.93,63.41 154.72,64.19 154.72,64.44 157.1,66.81 v2(157.1,67.08)
MEM_SMBDATA: length 20.5
  TOP w0.102: v2(166.74,68.74) 166.36,69.13 165.99,69.13 RC30.2 165.16,69.95 164.71,69.95 164.53,70.13 QC1.3
  IN3 w0.122: v2(166.74,68.74) 166.66,68.74 166.29,69.11 165.41,69.11 165.3,69.21 163,69.21 162.69,68.9 162.69,68.1 162.3,67.7 160.27,67.7 160.12,67.55 155.21,67.55 155.08,67.68 154.14,67.68 153.75,68.07 v2(153.75,68.12)
  BOTTOM w0.102: UC1.AH1 152.8,67.35 153.17,67.73 153.42,67.73 153.75,68.07 v2(153.75,68.12)
MINI1CLK_REQ#: length 97
  IN2 w0.122: v2(173.34,70.65) 173.75,70.65 175.17,69.23 175.17,68.17 177.65,65.7 177.65,63.29 177.34,62.99 177.34,58.67 175.91,57.24 175.91,51.98 185.73,42.16 v2(185.73,40.89)
  IN4 w0.084: v2(173.34,70.65) 173.43,70.74 173.43,73.43 172.76,74.1 168.58,74.1 167.43,75.26 163.86,75.26 163.22,74.62 160.71,74.62 160.64,74.69 159.54,74.69 158.37,75.86 157.28,75.86 v2(157.12,75.7)
  BOTTOM w0.076: UC1.T2 150.86,74.09 151.15,74.39 151.46,74.39 151.58,74.5 152.53,74.5 153.25,75.22 153.85,75.22
  BOTTOM w0.102: JMINI2.7 203.59,42.95 203.29,43.25 198.44,43.25 196.08,40.89 v2(185.73,40.89) ; 153.85,75.22 154.81,75.22 154.94,75.35 156.2,75.35 156.55,75.7 v2(157.12,75.7) 157.44,76.02 159.07,76.02 159.33,75.75 161.47,75.75 162.67,76.96 164.08,76.96 165.06,77.94 165.06,78.06 165.32,78.31 RP4.6
MINI2CLK_REQ#: length 126.5
  TOP w0.102: v2(165.09,81.24) 165.52,80.81 170.2,80.81 171.56,79.44 171.56,77.57 173.65,75.48 173.65,72.2 172.9,71.46 172.9,68.89 173.38,68.41 175.28,68.41 179.16,64.54 179.16,57.63 178.6,57.08 178.6,54.13 179.16,53.57 179.16,49.04 184.92,43.27 184.92,27.64 185.73,26.84 185.73,23.42 186.18,22.96 v2(186.18,22.3)
  IN2 w0.122: v2(186.18,22.3) 193.12,22.3 194.23,21.18 194.23,18.87 195.94,17.17 v2(200.76,17.17)
  BOTTOM w0.076: UC1.N1 152.16,75.59 152.81,76.24 152.81,76.29 153.85,77.33
  BOTTOM w0.102: JMINI1.7 209.44,11.2 208.6,12.04 208.6,14.79 206.38,17.02 200.91,17.02 v2(200.76,17.17) ; RP4.7 166.14,78.81 166.24,78.92 166.24,80.09 v2(165.09,81.24) 165.06,81.24 v1(164.46,80.64) 162.32,78.5 162.32,77.38 161.57,76.63 160.1,76.63 159.92,76.81 158.4,76.81 158.27,76.68 156.83,76.68 156.07,77.44 153.96,77.44 153.85,77.33
MINI_CARD_RST#: length 57.5
  TOP w0.102: R131.2 190.77,39.95 192.49,39.95 193.05,40.51 U30.4 194.49,40.51 R26.1 195.22,39.78 196.33,39.78 196.66,40.11 196.66,41.39 197.04,41.77 198.16,41.77 v1(198.53,42.14) 199.4,43.01 203.39,43.01 v2(204.55,41.86) ; v2(206.55,47.05) 206.71,47.21 207.84,47.21 208.31,47.68 208.31,49.78 207.81,50.27 207.81,51.96 208.01,52.15 JMINI2.22
  IN1 w0.084: JMINI1.22 211.98,20.4 209.41,22.97 209.41,25.32 207.26,27.47 207.26,28.83 203.8,32.3 203.8,41.11 v2(204.55,41.86) 205.68,42.99 205.68,46.18 v2(206.55,47.05)
MMICLK_REQ#: length 228.7
  TOP w0.102: v2(254.11,20.58) 254.19,20.5 U27.17
  IN2 w0.089: v2(148.72,74.1) 149.14,74.51 152.42,74.51 152.73,74.2 152.73,73.76 153.09,73.41 153.09,72.34 152.82,72.07 152.82,71.21 153.7,70.33 v2(153.7,70.33)
  IN2 w0.122: v2(254.11,20.58) 254.11,20.68 254.87,21.43 254.87,25.67 256.13,26.93 259.06,26.93 261.05,28.92 262.7,28.92 263.83,27.79 264.88,27.79 266.86,29.77 267.4,29.77 268.64,31 269.37,31 271.6,33.24 271.6,45.42 268.67,48.36 268.67,74.83 267.93,75.56 v2(267.26,75.56)
  IN3 w0.089: 153.85,70.59 153.7,70.44 v2(153.7,70.33)
  IN3 w0.122: v2(267.26,75.56) 266.87,75.95 266.87,80.39 264.59,82.67 259.72,82.67 257.82,80.77 255.41,80.77 254.65,80.01 247.87,80.01 246.19,81.69 244.75,81.69 243.48,82.96 243.48,83.61 239.62,87.47 239.62,88.55 239.01,89.17 234.45,89.17 234.19,88.91 226.88,88.91 225.38,87.42 218.14,87.42 218.05,87.33 211.88,87.33 210.28,88.93 204.32,88.93 203.01,87.63 203.01,86.86 200.47,84.32 200.47,83.3 199.76,82.59 199.76,79.49 197.3,77.03 192.64,77.03 192.43,77.25 190.24,77.25 189.19,76.2 188.55,76.2 188.15,75.8 188.15,74.41 187.71,73.97 185.56,73.97 184.58,72.99 176.99,72.99 176.33,72.33 173.31,72.33 172.46,71.48 169.15,71.48 168.72,71.06 165.57,71.06 164.95,70.43 163.97,70.43 163.12,71.28 163.12,71.39 162.59,71.91 161.55,71.91 160.62,70.99 157.71,70.99 157.47,70.75 154.01,70.75 153.85,70.59
  BOTTOM w0.076: v2(148.72,74.1) 148.58,73.95 148.58,73.68 UC1.U5 ; 153.85,70.48 v2(153.7,70.33)
  BOTTOM w0.102: 153.85,70.48 154.21,70.84 154.99,70.84 155.93,71.78 160.88,71.78 RC55.2
MODC_EN: length 5.7
  TOP w0.102: v2(19.51,30.57) 19.18,30.24 U37.B7 ; T101.1 18.59,26.96 v2(18.59,26.64)
  BOTTOM w0.102: v2(18.59,26.64) 18.59,27.15 18.9,27.46 18.9,29.96 v2(19.51,30.57)
MODULE_BATT_PRES#: length 11.7
  TOP w0.102: T107.1 26.21,26.09 26.49,26.36 v2(26.49,26.56) ; v2(21.96,31.5) 22.31,31.5 23.01,30.79 23.01,30.35 23.18,30.18 U37.B15
  BOTTOM w0.102: v2(26.49,26.56) 26.49,26.67 26.85,27.03 26.85,28.92 26.37,29.4 24.18,29.4 23.84,29.74 23.55,29.74 23.01,30.28 23.01,30.79 22.31,31.5 v2(21.96,31.5)
MODULE_ON: length 6.5
  TOP w0.102: v2(24.12,37.44) 24.2,37.52 U37.B32
  BOTTOM w0.102: T106.1 28.75,39.64 27.43,39.64 26.11,38.32 25.98,38.32 25.8,38.14 25.3,38.14 24.73,37.57 24.24,37.57 v2(24.12,37.44)
MPCIE_RST#: length 84.2
  TOP w0.102: U30.2 192.23,41.16 192.42,41.35 192.42,42.09 192.2,42.3 186.87,42.3 179.93,49.24 179.93,57.61 179.63,57.91 179.63,64.71 175.58,68.76 175.58,76.14 175.17,76.54 175.17,77.63 173.71,79.1 172.24,79.1 v1(172.14,79.2) 170.29,81.04 167.51,81.04 166.89,81.66 166.18,81.66 v2(165.74,81.23)
  BOTTOM w0.076: 153.85,72.61 153.71,72.61 153.52,72.42 151.64,72.42 151.59,72.47 151.4,72.47 UC1.V1
  BOTTOM w0.102: v2(165.74,81.23) 167.83,79.14 167.83,76.82 167.56,76.56 166.27,76.56 166.17,76.66 166.17,77.72 166.08,77.81 RP4.5 165.32,77.81 163.96,76.46 163.96,76.37 162.8,75.21 160.64,75.21 160.11,74.68 159.59,74.68 159.26,74.35 159.26,74.21 159.09,74.04 155.64,74.04 154.21,72.61 153.85,72.61
MPHYP_PWR_EN: length 38
  TOP w0.102: R420.1 162.37,89.01 v2(162.37,88.16)
  IN2 w0.122: v2(162.37,88.16) 162.37,88.47 162.09,88.75 157.89,88.75 154.64,85.5 154.64,84.68 152.34,82.38 152.34,78.12 152.81,77.64 152.81,76.68 153.5,75.99 153.5,75.73 154.97,74.26 155,74.26 v2(156.2,73.06)
  BOTTOM w0.076: UC1.Y2 150.92,72.14 151.46,72.14 151.51,72.09 153.85,72.09
  BOTTOM w0.102: RC170.1 160.15,72.91 159.36,72.91 RC169.1 158.59,72.69 156.63,72.69 156.26,73.06 v2(156.2,73.06) 155.45,72.32 v1(154.77,72.32) 154.53,72.09 153.85,72.09
MPHYP_PWR_EN#: length 3.2
  TOP w0.102: Q124.5 159.39,89.8 159.09,89.51 v1(159.09,89.23) 159.25,89.08 R442.2 160.13,89.49 160.04,89.59 Q124.6
MSATA_DEVSLP: length 74.4
  TOP w0.102: JMINI2.44 207.76,60.95 206.98,60.17 206.11,60.17 205.35,60.93 205.35,63.55 204.89,64.01 204.89,68.08 v1(205.23,68.42) v2(205.69,68.87)
  IN4 w0.084: v2(197.24,70.49) 197.24,70.5 196.63,71.11 177.34,71.11 174.7,73.75 173.71,73.75 172.5,74.96 169.84,74.96 169.6,75.2 168.71,75.2 167.69,76.22 164.51,76.22 163.18,74.88 161.13,74.88 160.08,75.92 159.19,75.92 158.67,76.44 157.2,76.44 156.36,75.6 155.42,75.6 v2(155.04,75.98)
  BOTTOM w0.076: 153.91,77.09 153.84,77.09 152.98,76.23 152.98,76.16 152.12,75.3 151.08,75.3 151.07,75.29 151.07,75.29 UC1.P2
  BOTTOM w0.102: 153.91,77.09 154.51,77.09 R160.2 154.85,76.75 154.85,76.18 v2(155.04,75.98) ; v2(197.24,70.49) 198.11,69.62 205.27,69.62 205.69,69.21 v2(205.69,68.87)
MSCLK: length 277.2
  TOP w0.102: v2(4.81,7.14) v1(4.81,6.51) 4.81,6.05 6.72,4.14 7.75,4.14 7.98,4.37 RP1.6 ; v2(23.17,17.91) 24.33,17.91 24.69,18.26 U38.B43
  IN2 w0.122: v2(23.17,17.91) 24.49,17.91 25.92,19.34 29.1,19.34 29.26,19.51 33.1,19.51 33.45,19.85 34.27,19.85 35.13,20.71 37.68,20.71 37.88,20.51 38.13,20.26 39.11,20.26 40.57,21.73 44.12,21.73 45.44,23.04 46.25,23.04 47.96,24.75 57.02,24.75 57.36,25.09 84.39,25.09 84.6,25.3 122.59,25.3 123.4,24.5 128.26,24.5 129.22,23.53 132.18,23.53 134.37,25.72 173.76,25.72 176.75,22.73 195.33,22.73 197.28,20.78 197.52,20.78 199.66,18.65 201.01,18.65 v2(201.37,18.29)
  IN3 w0.122: v2(4.81,7.14) 7.1,7.14 9.18,9.22 9.18,9.79 9.91,10.52 10.67,10.52 11.75,9.44 14.97,9.44 15.8,10.26 15.8,12.44 17.3,13.94 19.03,13.94 20.34,15.25 21.24,15.25 22.38,16.39 22.38,17.12 v2(23.17,17.91)
  BOTTOM w0.102: JDEG1.5 10.67,41.97 10.44,41.74 10.44,39.72 10.69,39.47 10.69,37.14 9.82,36.27 4.97,36.27 3.18,34.48 3.18,32.73 4.17,31.74 4.17,23.66 7.76,20.07 7.76,9.83 6.38,8.44 4.83,8.44 4.64,8.25 4.64,7.77 4.81,7.59 v2(4.81,7.14) ; v2(201.37,18.29) 202.29,18.29 202.67,17.91 208.74,17.91 210.03,19.2 JMINI1.19
MSDATA: length 287.2
  TOP w0.102: v2(4.43,9.31) 5.91,9.31 6.79,10.2 8.39,10.2 v1(8.66,9.93) 8.93,9.66 R398.2 ; R366.2 24.94,22.12 v2(24.94,20.93) U38.A40 ; v2(208.12,12.51) 209.07,12.51 R222.2 210.56,14 JMINI1.14
  IN2 w0.122: v2(24.94,20.93) 24.94,20.93 25.92,21.91 29.39,21.91 29.93,21.37 32.33,21.37 33.68,22.72 43.45,22.72 44.77,24.04 45.24,24.04 47.09,25.89 56.75,25.89 56.95,26.09 83.98,26.09 84.19,26.3 129.06,26.3 129.47,26.71 182.29,26.71 184.96,24.04 190.55,24.04 192.01,25.5 192.17,25.5 193.15,26.49 196.42,26.49 197.86,25.05 197.86,24.04 198.78,23.11 201.22,23.11 202.67,21.66 202.67,19.62 202.93,19.36 202.93,13.73 204.15,12.51 v2(208.12,12.51)
  IN3 w0.122: v2(4.43,9.31) 4.78,9.65 5.66,9.65 5.99,9.98 6.84,9.98 7.66,10.8 7.66,17.01 8.98,18.33 10.55,19.9 13.19,19.9 13.85,19.24 15.64,19.24 16.75,20.36 24.37,20.36 v2(24.94,20.93)
  BOTTOM w0.102: v2(4.43,9.31) 5.03,9.31 5.19,9.47 6.99,9.47 7.53,10.01 7.53,19.97 3.94,23.56 3.94,31.38 2.95,32.37 2.95,34.57 4.87,36.5 9.73,36.5 10.44,37.21 10.44,39.22 9.58,40.08 9.58,41.43 10.17,42.02 JDEG1.4
NB_LAN_TX0+: length 11
  BOTTOM w0.089: JLOM1.1 249.42,100.74 249.42,99.67 249.29,99.55 249.29,98.21 250.56,96.94 253.73,96.94 253.96,96.71 253.96,95.15 253.48,94.67 T94.19
NB_LAN_TX0-: length 10.4
  BOTTOM w0.089: T94.20 254.75,94.55 254.27,95.03 254.27,96.84 253.86,97.26 250.69,97.26 249.61,98.34 249.61,99.42 249.87,99.68 250.4,99.68 JLOM1.2
NB_LAN_TX1+: length 13
  BOTTOM w0.089: T94.23 258.56,94.75 259.04,95.23 259.04,96.34 258.84,96.53 255.6,96.53 253.54,98.59 252.08,98.59 251.42,99.25 JLOM1.3
NB_LAN_TX1-: length 10.2
  BOTTOM w0.089: JLOM1.6 254.48,99.68 254.11,99.31 254.11,98.46 255.73,96.85 258.97,96.85 259.35,96.47 259.35,95.38 259.83,94.91 T94.24
NB_LAN_TX2+: length 13.4
  IN1 w0.084: v2(247.29,96.23) 247.4,96.13 248.32,96.13 249.71,97.51 253.83,97.51 254.05,97.73 254.05,98.3 253.5,98.85 253.26,98.85 252.87,99.25 252.87,99.25 JLOM1.4
  BOTTOM w0.089: T94.13 245.86,94.87 246.34,95.35 246.34,95.74 246.7,96.1 247.16,96.1 v2(247.29,96.23)
NB_LAN_TX2-: length 14.2
  IN1 w0.084: v2(247.29,95.65) 247.39,95.74 248.48,95.74 249.87,97.13 253.99,97.13 254.43,97.57 254.43,98.46 253.46,99.43 JLOM1.5
  BOTTOM w0.089: v2(247.29,95.65) 247.16,95.78 246.83,95.78 246.65,95.61 246.65,95.23 247.13,94.75 T94.14
NB_LAN_TX3+: length 10.5
  IN1 w0.084: v2(251.31,95.51) 251.38,95.58 251.38,96.08 251.72,96.42 254.26,96.42 255.31,97.46 255.31,99.67 255.58,99.95 255.58,100.69 JLOM1.7
  BOTTOM w0.089: T94.17 250.94,94.68 251.46,95.2 251.46,95.35 v2(251.31,95.51)
NB_LAN_TX3-: length 9.9
  IN1 w0.084: JLOM1.8 256.43,99.68 256.43,99.68 255.86,99.68 255.69,99.51 255.69,97.31 254.42,96.04 251.88,96.04 251.77,95.92 251.77,95.63 v2(251.89,95.51)
  BOTTOM w0.089: T94.18 252.21,94.73 251.78,95.16 251.78,95.39 v2(251.89,95.51)
NB_PSID: length 7.2
  TOP w0.254: PL3.2 89.07,86.76 v1(89.84,87.53) 90.11,87.8 90.11,91.96 89.7,92.37 v2(89.08,92.37)
NB_PSID_TS5A63157: length 8.8
  TOP w0.102: PR8.1 82.98,92.84 82.52,92.38 82.52,91.68 v1(83.1,91.11)
  TOP w0.254: PU111.3 80.9,92.99 80.67,92.76 80.67,92.37 80.85,92.19 81.27,92.19 PR9.2 PR8.1 82.98,94.3 PD5.1
NFC_DET#: length 176.8
  TOP w0.102: v2(178.18,16.06) 179.2,17.08 179.2,23.6 179.12,23.67 179.12,44.13 175.21,48.04 175.21,53.65 174.63,54.23 169.69,54.23 168.49,55.42 168.49,58.14 168.28,58.36 167.21,58.36 166.29,57.44 166.29,55.75 165.84,55.3 v1(164.58,55.3) 163.6,55.3 162.56,54.25 159.55,54.25 159.05,53.75 v2(158.8,53.75) ; R38.2 254.47,7.92 254.46,7.91 JNFC1.14 v2(254.46,2.26)
  IN2 w0.122: v2(254.46,2.26) 248.63,2.26 247.94,1.57 212.62,1.57 212.22,1.17 178.68,1.17 177.25,2.6 177.25,8.75 178.54,10.03 178.54,15.56 178.18,15.91 v2(178.18,16.06)
  IN4 w0.084: v2(148.83,61.95) 149.87,60.91 153.34,60.91 154.58,59.67 154.58,57.03 156.83,54.77 157.87,54.77 158.8,53.85 v2(158.8,53.75)
  BOTTOM w0.076: UC1.AT5 148.37,62.41 v2(148.83,61.95)
NFC_IRQ: length 247
  TOP w0.102: v2(166.14,61.49) 166.18,61.45 RC210.1 ; JNFC1.11 252.96,8.51 254.28,9.83 256.26,9.83 v1(256.85,9.25) v2(258.69,7.4)
  IN3 w0.122: v2(166.14,61.49) 166.42,61.49 167.64,62.71 167.97,62.71 169,63.74 169,64.49 169.24,64.73 169.24,65.22 171.25,67.23 174.04,67.23 176.59,69.78 180,69.78 181.09,70.87 184.94,70.87 185.41,71.35 188.67,71.35 190.27,72.95 191.46,72.95 192.62,74.1 199.31,74.1 200.03,74.82 200.03,75.86 201.13,76.97 201.49,76.97 202.29,77.77 202.83,77.77 207.51,82.45 208.09,82.45 209.6,83.96 211.85,83.96 212.05,84.15 220.02,84.15 220.5,84.63 228.09,84.63 229.87,86.41 233.22,86.41 233.46,86.17 239.87,86.17 242.61,83.43 242.61,82.64 244.43,80.82 245.8,80.82 247.45,79.17 254.84,79.17 255.09,78.92 257.18,78.92 260.18,81.92 264.11,81.92 266.12,79.92 266.12,76.24 265.52,75.64 265.52,74.76 265.89,74.4 266.37,74.4 268.48,72.29 268.48,54.57 269.95,53.1 270.9,53.1 275.13,48.88 275.13,47.87 276.04,46.96 276.04,41.68 276.45,41.26 276.45,38.42 276.25,38.22 276.25,34.29 281.06,29.49 281.06,28.06 281.52,27.6 281.52,25.07 282.65,23.94 282.65,16.95 280.15,14.45 276.53,14.45 271.4,9.32 270.51,9.32 269.93,8.74 260.02,8.74 v2(258.69,7.4)
  IN4 w0.084: v2(153.51,63.9) 154.77,63.9 155.97,65.1 159.56,65.1 163.21,61.45 166.1,61.45 v2(166.14,61.49)
  BOTTOM w0.076: v2(153.51,63.9) 153.5,63.91 153.08,63.91 152.6,64.39 151.65,64.39 151.4,64.65 151.15,64.65 151.04,64.53 150.98,64.48 150.98,64.3 150.75,64.06 150.23,64.06 UC1.AN3
NFC_RST: length 7.9
  TOP w0.102: U29.4 250.35,12.02 250.46,11.91 250.46,11.37 v1(249.92,10.83) 250.46,10.3 JNFC1.6
NFC_SMBCLK: length 208.8
  TOP w0.102: JNFC1.8 251.46,5.54 251.6,5.68 251.6,6.82 v2(251.38,7.04) ; v2(172.78,60.38) 172.58,60.18 172.58,60.01 172.29,59.71 171.89,59.71 170.95,60.65 v5(165.62,60.65) 164.03,60.65 162.34,62.35 162.34,62.38 162.34,63.46 161.3,64.5 161.3,64.5 161.11,64.69 161.11,66.17 RC33.1
  IN2 w0.122: v2(251.38,7.04) 251.54,7.21 251.54,7.43 249.87,9.1 249.87,12.22 249.5,12.59 249.5,19.69 250.25,20.45 250.25,24.41 250.85,25 250.85,29.05 252.88,31.08 264.18,31.08 266.86,33.75 266.86,34.44 267.44,35.03 267.44,38.79 268.29,39.64 268.29,42.75 267.67,43.37 267.67,46.28 266.79,47.15 266.79,70 264.8,72 259.72,72 258.88,72.83 256.67,72.83 253.87,75.63 245.47,75.63 244.23,76.86 241.78,76.86 240.92,77.72 240.2,77.72 238.32,79.6 238.32,79.82 236.73,81.41 222.97,81.41 221.52,79.96 218.8,79.96 217.41,78.57 213.45,78.57 212.78,77.9 210.16,77.9 208.99,76.73 208.99,76.27 209.29,75.97 v2(209.49,75.97)
  IN4 w0.084: v2(209.49,75.97) 209.49,75.65 209.86,75.28 209.86,73.76 208.61,72.51 204.46,72.51 203.15,71.2 200.8,71.2 198.63,69.03 194.46,69.03 194.33,69.16 189.3,69.16 188.51,68.37 182.44,68.37 177.47,63.4 175.88,63.4 173.3,60.82 172.8,60.82 172.66,60.68 172.66,60.51 v2(172.78,60.38)
NFC_SMBDATA: length 203.3
  TOP w0.102: JNFC1.9 251.96,5.57 251.82,5.7 251.82,6.91 v2(251.96,7.04) ; v2(172.2,60.38) 172.35,60.23 172.35,60.1 172.19,59.94 171.99,59.94 171.05,60.88 170.67,60.88 v5(170.23,61.33) 169.48,61.33 167.88,62.93 167.88,64.05 168.61,64.77 168.61,65.32 168.12,65.8 167.61,65.8 RC35.1
  IN2 w0.122: v2(251.96,7.04) 251.79,7.21 251.79,7.53 250.11,9.21 250.11,12.33 249.75,12.69 249.75,19.59 250.5,20.34 250.5,24.31 251.1,24.9 251.1,28.95 252.98,30.83 264.28,30.83 267.1,33.65 267.1,34.34 267.69,34.92 267.69,38.68 268.54,39.53 268.54,42.85 267.91,43.47 267.91,46.38 267.04,47.26 267.04,70.11 264.9,72.24 259.82,72.24 258.98,73.08 256.77,73.08 253.98,75.88 245.57,75.88 244.33,77.11 241.88,77.11 241.02,77.97 240.3,77.97 238.56,79.71 238.56,79.93 236.83,81.66 222.86,81.66 221.42,80.21 218.69,80.21 217.31,78.82 213.35,78.82 212.67,78.15 210.05,78.15 208.74,76.83 208.74,76.16 209.08,75.82 v2(209.08,75.55)
  IN4 w0.084: v2(172.2,60.38) 172.45,60.63 172.45,60.77 172.71,61.03 173.22,61.03 175.8,63.61 177.38,63.61 182.35,68.58 188.42,68.58 189.21,69.37 194.42,69.37 194.54,69.24 198.54,69.24 200.71,71.41 203.06,71.41 204.37,72.72 208.52,72.72 209.64,73.85 209.64,75.2 209.29,75.55 v2(209.08,75.55)
O-USR: length 5
  TOP w0.102: v1(86,68.66) 87,69.65 PR504.1
  TOP w0.203: PU500.9 88.45,71 88.32,70.87 87.94,70.87 87.78,70.71 v2(87.78,70.36)
  TOP w0.254: PR504.1 87,69.84 87.52,70.36 v2(87.78,70.36)
  BOTTOM w0.254: PR509.2 87.78,70.93 v2(87.78,70.36)
OCP-I: length 3.1
  TOP w0.203: v2(89.54,70.36) 89.65,70.47 PU500.12
  BOTTOM w0.254: PR506.2 90.23,71.11 89.54,70.41 v2(89.54,70.36) 89.54,69.98 PR501.1
P33ALW: length 2.4
  TOP w0.254: PU800.18 10.24,30.1 v1(10.85,30.71) 11.79,30.71 PR868.1
P33ALW2: length 2.2
  TOP w0.254: PU800.9 8.78,24.29 v1(9.07,24) PR862.2
PANEL_BKEN_EC: length 77.9
  TOP w0.102: D21.2 57.15,84.48 58.04,85.37 v1(59.65,85.37) 60.25,84.77 60.25,83.04 v2(61.61,81.69) ; U37.A35 22.93,41.17 v2(23.03,41.27)
  IN1 w0.084: v2(61.61,81.69) 60.12,80.2 60.12,78.98 59.28,78.15 59.28,73.28 58.49,72.48 58.49,70.42 55.57,67.5 55.57,61.42 54.88,60.72 54.88,57.09 51.92,54.14 51.92,52.2 51.41,51.69 51.41,51.08 47.17,46.84 45.69,46.84 44.86,47.68 v2(44.86,47.7)
  IN4 w0.084: v2(23.03,41.27) 23.17,41.41 23.58,41.41 23.69,41.52 26.88,41.52 29.31,43.95 30.89,43.95 32.2,45.26 33.66,45.26 35.7,47.3 44.46,47.3 v2(44.86,47.7)
PANEL_BKLEN: length 103
  TOP w0.102: D21.3 55.96,82.14 56.09,82.02 v1(56.57,82.02) 58.4,82.02 59.39,81.03 61.81,81.03 62.98,79.86 66.12,79.86 67.11,80.85 70.24,80.85 71.02,80.07 v2(74.22,80.07)
  IN3 w0.089: 143.8,85.57 143.84,85.53 143.84,84.78 144.26,84.37 145.72,84.37 v2(145.78,84.3)
  IN3 w0.122: v2(74.22,80.07) 74.7,80.55 78.8,80.55 79.37,81.12 82.6,81.12 83.76,82.28 87.07,82.28 90.81,86.03 93.76,86.03 95.35,87.61 97.76,87.61 100.37,90.22 100.79,90.22 101.38,89.63 102.37,89.63 102.84,90.1 105.58,90.1 105.97,89.71 107.62,89.71 108.46,90.55 112.31,90.55 113.16,89.7 116.17,89.7 116.46,89.99 129.17,89.99 132,87.16 133.79,87.16 135,85.95 140.09,85.95 140.7,86.56 142.81,86.56 143.8,85.57
  BOTTOM w0.076: UC1.A9 145.78,82.85 v2(145.78,84.3)
PANEL_HDD_LED#: length 99.4
  TOP w0.102: v2(193.47,95.68) 193.47,95.49 v1(193.18,95.2) ; v2(121.96,98.54) 121.65,98.54 121.27,98.92 121.27,100.72 121.79,101.24 JLED1.4
  IN3 w0.122: v2(121.96,98.54) 122.96,98.54 123.9,99.48 126.1,99.48 126.26,99.31 126.26,98.44 126.62,98.08 129.65,98.08 131.4,96.33 135.6,96.33 136.02,96.75 142.88,96.75 143.15,97.02 143.15,98.03 143.5,98.37 143.5,99.33 144.42,100.25 147.11,100.25 147.99,99.38 147.99,97.85 149.86,95.98 152.43,95.98 156.71,91.69 180.85,91.69 181.22,91.33 183.35,91.33 185.44,93.42 186.35,93.42 188.85,95.91 193.24,95.91 v2(193.47,95.68)
  BOTTOM w0.102: Q26.3 196.95,91.08 196.37,90.5 193.04,90.5 192.66,90.88 192.66,92.89 193.09,93.32 193.09,95.3 v2(193.47,95.68)
PBAT_PRES#: length 265.7
  TOP w0.102: v2(21.73,38.39) 21.68,38.44 U37.B40
  TOP w0.254: PR2.2 156.93,10.62 157.8,10.62 ; 158.36,13.46 158.36,13.88 157.63,14.6 154.01,14.6 151.63,16.99 147.96,16.99 146.4,15.43 136.86,15.43 135.75,16.55 134.54,16.55 132.79,14.79 v1(126.75,14.79) v2(124.21,14.79) 124.21,13.04 124.45,12.8 124.45,12.36 124.27,12.18 PU804.1 ; 158.36,13.46 158.97,13.46 159.16,13.27 PRP2.3 ; 158.36,13.46 158.36,13.3 157.8,12.74 157.8,10.62 ; PD4.1 157.66,9.93 157.8,10.07 157.8,10.62 ; PQ812.1 176.96,6.03 176.59,5.66 174.97,5.66 174.4,6.24 v2(174.4,9.26)
  IN1 w0.084: v2(124.21,14.79) 121.26,17.74 82.85,17.74 81.47,19.12 81.47,23.42 80.87,24.02 63.35,24.02 62.87,23.54 57.19,23.54 56.79,23.13 53.55,23.13 51.37,20.95 51.37,18.64 45.36,12.64 45.36,8.86 44.94,8.44 44.94,7.2 44.45,6.71 40.67,6.71 40.19,6.23 38.16,6.23 37.4,5.47 35.03,5.47 34.3,6.2 32.25,6.2 31.42,7.03 29.56,7.03 28.99,6.46 24.79,6.46 24.35,6.9 22.87,6.9 22.19,7.58 22.19,8.29 21.1,9.38 19.97,9.38 19.59,9.75 19.59,14.05 19.46,14.18 19.46,23.51 20.8,24.85 20.8,26.14 19.97,26.97 19.97,31.3 19.8,31.47 19.8,32.78 21.39,34.37 21.39,37.93 21.73,38.27 v2(21.73,38.39)
  IN3 w0.254: v2(174.4,9.26) 170.94,9.26 166.63,13.56 159.29,13.56 157.32,15.53 146.67,15.53 145.97,14.83 138.8,14.83 137.97,14.01 130.89,14.01 130.1,14.79 v2(124.21,14.79)
PBAT_SMBCLK: length 160.5
  TOP w0.102: R339.2 17.56,15.67 v2(18.02,15.21) 18.08,15.15 18.68,15.15 19.01,14.83 U38.A56 ; v2(134.9,20.72) 135.1,20.52 136.1,20.52 136.42,20.19 136.42,18.97 137.29,18.11 v3(145.07,18.11) 151.43,18.11 154.22,15.32 158.24,15.32 160.02,13.54 160.02,13.27 160.16,13.13 PRP2.1
  IN2 w0.122: v2(18.02,15.21) 18.07,15.16 21.15,15.16 21.91,15.93 27.34,15.93 28.41,16.99 29.05,16.99 29.24,17.19 31.19,17.19 31.59,17.59 39.1,17.59 39.85,16.84 39.85,15.77 41.05,14.57 45.33,14.57 47.72,16.96 47.72,22.45 48.36,23.08 50.24,23.08 50.8,23.65 56.86,23.65 57.01,23.5 84.09,23.5 84.21,23.38 92.21,23.38 92.62,23.8 121.83,23.8 122.48,23.15 127.71,23.15 128.22,22.64 131.66,22.64 133.75,20.55 134.73,20.55 v2(134.9,20.72)
PBAT_SMBDAT: length 164.4
  TOP w0.102: v2(21.83,15.23) 21.45,15.23 21.3,15.08 U38.B59 ; R345.2 14.89,17.12 15.17,17.4 v2(15.17,17.45) ; PRP2.2 159.66,13.13 159.79,13.27 159.79,13.44 158.15,15.09 154.13,15.09 151.33,17.88 137.19,17.88 136.2,18.88 136.2,20.1 136,20.29 135.05,20.29 v2(134.9,20.14)
  IN2 w0.122: v2(134.9,20.14) 134.73,20.3 133.64,20.3 131.55,22.39 128.12,22.39 127.61,22.9 122.38,22.9 121.73,23.55 92.73,23.55 92.31,23.13 84.11,23.13 83.99,23.25 56.91,23.25 56.76,23.4 50.9,23.4 50.34,22.83 48.46,22.83 47.97,22.35 47.97,16.86 45.44,14.33 40.95,14.33 39.6,15.67 39.6,16.74 39,17.35 31.7,17.35 31.29,16.94 29.35,16.94 29.15,16.74 28.51,16.74 27.45,15.68 22.28,15.68 21.83,15.23 v2(21.83,15.23)
  BOTTOM w0.102: v2(21.83,15.23) 20.37,15.23 18.53,17.07 17.53,17.07 16.69,17.91 15.67,17.91 15.22,17.45 v2(15.17,17.45)
PBATT+_C:
  vias: v5(168.71,4.55)
PCH_ALW_ON: length 236.3
  TOP w0.102: U38.A23 30.53,13.83 30.7,13.66 31.24,13.66 v2(31.38,13.8) 31.78,14.2 R368.2
  IN3 w0.122: v2(31.38,13.8) 31.98,13.8 32.83,14.66 33.75,14.66 34.78,15.68 34.78,16.41 35.85,17.47 37.65,17.47 39.7,19.53 39.7,22.16 42.25,24.72 42.25,25.54 45.11,28.4 46.06,28.4 47.74,30.09 50.41,30.09 52.05,31.72 55.08,31.72 56.98,33.62 61.95,33.62 62.74,34.41 117.15,34.41 121.74,29.82 121.74,26.92 122.44,26.22 126.72,26.22 128.87,28.37 129.99,28.37 131.27,29.65 131.96,29.65 133.28,30.96 133.28,32.3 137.3,36.32 177.5,36.32 185.63,36.32 186.44,35.51 187.73,35.51 187.99,35.77 189.68,35.77 190.67,36.76 194.32,36.76 197.93,40.38 200.4,40.38 204.6,44.57 204.6,46.33 204.07,46.85 204.07,50.77 203.61,51.24 203.61,52.87 203.13,53.35 203.13,64.34 203.97,65.18 203.97,67.6 203.58,67.99 203.58,68.7 202.73,69.54 202.73,70.45 v2(202.53,70.65)
  BOTTOM w0.102: v2(202.53,70.65) 203.96,72.08 203.96,72.96 v1(205.63,74.63) 206.65,75.65 206.65,76.23 R416.1
PCH_AUDIO_EN: length 4.3
  TOP w0.102: v2(154.2,76.05) 154.2,76.22 RC215.1
  BOTTOM w0.076: UC1.P1 152.32,74.84 152.83,75.36
  BOTTOM w0.102: v2(154.2,76.05) v1(153.51,76.05) 153.08,75.62 153.08,75.61 152.83,75.36
PCH_AZ_BITCLK: length 20.4
  TOP w0.102: RC26.2 155.26,50.42 154.34,50.42 151.64,53.12 145.31,53.12 144.83,53.6 144.83,56.16 v1(144.96,56.29) 146.43,57.76 v2(146.74,57.76)
  BOTTOM w0.076: UC1.AW8 146.11,60.54 146.11,59.61 146.46,59.25 146.46,58.55 146.74,58.28 v2(146.74,57.76)
PCH_AZ_CODEC_BITCLK: length 179.9
  TOP w0.102: v2(167.43,57.63) 167.43,57.63 166.9,57.1 v1(166.9,54.81) 166.9,54.01 164.94,52.04 158.85,52.04 157.59,50.78 157.59,50.52 157.53,50.46 CC5.1 RC26.1
  TOP w0.254: R149.1 273.33,28.59 v2(273.33,29.44) 273.33,29.56 273.08,29.82 U17.6
  IN4 w0.084: v2(273.33,29.44) 273.33,29.8 271.83,31.3 271.83,32.65 270.03,34.45 270.03,37.55 268.91,38.67 268.91,50.55 266.14,53.32 266.14,70.51 265.58,71.08 254.22,71.08 253.6,71.7 247.67,71.7 247.2,72.16 244.5,72.16 242.44,74.22 242.44,74.77 241.79,75.42 239.22,75.42 237.01,77.63 235.18,77.63 231.48,81.33 218.99,81.33 217.07,79.41 215.8,79.41 212.73,76.34 212.73,71.89 211.88,71.05 209.44,71.05 208.81,70.42 206.32,70.42 205.58,71.16 204.88,71.16 203.16,69.44 200.77,69.44 199.01,67.68 191.93,67.68 188.36,64.12 184.03,64.12 183.5,64.65 180.52,64.65 177.98,62.11 176.45,62.11 175.52,61.17 175.52,59.81 173.83,58.12 167.92,58.12 v2(167.43,57.63)
PCH_AZ_CODEC_RST#: length 201.4
  TOP w0.102: R213.2 268.83,22.77 v2(269.33,22.77) ; v2(275.41,26.77) 275.41,27.04 275.64,27.27 275.64,28.08 275.92,28.36 275.92,29.53 275.58,29.87 U17.11 ; v2(163.76,53.76) 162.51,52.5 158.54,52.5 157.35,51.31 154.34,51.31 v1(153.63,52.03) 153,52.65 152.93,52.65 151.56,54.01 RC25.1
  IN2 w0.122: v2(269.33,22.77) 270.48,23.93 273.91,23.93 275.41,25.42 v2(275.41,26.77)
  IN4 w0.084: v2(275.41,26.77) 275.41,27.04 275.83,27.46 275.83,29.54 270.82,34.55 270.82,39.25 269.54,40.53 269.54,50.81 266.77,53.58 266.77,70.77 265.79,71.75 259.52,71.75 258.85,72.43 256.39,72.43 254.52,74.3 243.81,74.3 242,76.11 239.61,76.11 236.84,78.88 234.83,78.88 231.75,81.96 218.73,81.96 216.82,80.05 215.54,80.05 212.1,76.6 212.1,72.15 211.62,71.68 209.18,71.68 208.62,71.12 206.6,71.12 205.89,71.83 204.66,71.83 202.95,70.13 200.56,70.13 198.87,68.44 194.14,68.44 194.02,68.31 191.66,68.31 189.64,66.29 181.27,66.29 177.72,62.74 176.19,62.74 174.88,61.44 174.88,60.07 173.6,58.79 168.34,58.79 168.15,58.98 166.9,58.98 166.21,58.28 166.21,56.93 163.76,54.49 v2(163.76,53.76)
PCH_AZ_CODEC_SDIN0: length 197.3
  TOP w0.254: v2(274.18,26.96) 274.18,27.56 R136.1
  IN4 w0.084: v2(274.18,26.96) 274.28,27.06 274.28,30.49 270.26,34.52 270.26,37.62 269.12,38.75 269.12,50.64 266.35,53.41 266.35,70.6 265.66,71.29 254.3,71.29 253.68,71.91 247.75,71.91 247.29,72.37 244.6,72.37 242.72,74.24 242.72,74.79 241.88,75.63 239.3,75.63 237.1,77.84 235.27,77.84 231.57,81.54 218.91,81.54 216.99,79.63 215.72,79.63 212.52,76.43 212.52,71.98 211.8,71.26 209.36,71.26 208.73,70.63 206.45,70.63 205.67,71.41 204.83,71.41 203.07,69.66 200.69,69.66 198.92,67.89 191.84,67.89 188.28,64.33 184.12,64.33 183.59,64.86 180.43,64.86 177.89,62.32 176.37,62.32 175.31,61.26 175.31,59.9 173.74,58.33 167.15,58.33 166.84,58.02 166.84,56.67 164.83,54.66 164.83,52.39 164.15,51.7 153.76,51.7 151.29,54.17 149.43,54.17 148.82,54.78 148.82,56.21 146.83,58.2 v2(146.3,58.2)
  BOTTOM w0.076: UC1.AY10 145.65,59.83 146.3,59.19 v2(146.3,58.2)
PCH_AZ_CODEC_SDOUT: length 178.9
  TOP w0.102: v2(167.44,57.05) v1(167.44,51.98) 164.71,49.25 RC23.1
  TOP w0.254: R148.1 272.3,28.55 272.83,29.08 v2(272.83,29.1) 272.83,29.53 272.58,29.78 U17.5
  IN4 w0.084: v2(272.83,29.1) 272.83,29.58 271.62,30.79 271.62,32.56 269.82,34.36 269.82,37.46 268.7,38.58 268.7,50.46 265.93,53.23 265.93,70.42 265.49,70.87 254.13,70.87 253.51,71.49 247.58,71.49 247.12,71.95 244.41,71.95 242.15,74.21 242.15,74.76 241.7,75.21 239.13,75.21 236.92,77.42 235.1,77.42 231.4,81.12 219.09,81.12 217.17,79.2 215.88,79.2 212.94,76.25 212.94,71.81 211.97,70.84 209.53,70.84 208.9,70.21 205.21,70.21 204.24,69.23 200.86,69.23 199.1,67.47 192.01,67.47 188.45,63.91 183.85,63.91 183.31,64.44 180.61,64.44 178.07,61.9 176.54,61.9 175.73,61.09 175.73,59.72 173.92,57.91 168.3,57.91 v2(167.44,57.05)
PCH_AZ_CODEC_SYNC: length 190.1
  TOP w0.102: v2(275.41,29.25) 275.41,29.32 275.08,29.66 U17.10 ; RC24.1 147.83,53.44 151.74,53.44 154.1,51.08 157.44,51.08 158.64,52.27 163.67,52.27 v1(164.1,52.71) 164.1,53.47 v2(164.36,53.73)
  IN4 w0.084: v2(164.36,53.73) 164.36,54.79 166.42,56.85 166.42,58.2 166.99,58.77 167.41,58.77 167.63,58.55 173.66,58.55 175.1,59.99 175.1,61.35 176.28,62.53 177.8,62.53 181.35,66.08 189.73,66.08 191.75,68.1 198.83,68.1 200.62,69.89 203.01,69.89 204.74,71.62 205.77,71.62 206.5,70.89 208.69,70.89 209.27,71.47 211.71,71.47 212.31,72.07 212.31,76.52 215.63,79.84 216.91,79.84 218.82,81.75 231.66,81.75 234.74,78.67 236.75,78.67 239.53,75.89 241.92,75.89 243.72,74.09 254.43,74.09 256.34,72.17 258.72,72.17 259.37,71.53 265.72,71.53 266.56,70.69 266.56,53.49 269.33,50.72 269.33,38.84 270.52,37.65 270.52,34.55 275.41,29.66 v2(275.41,29.25)
PCH_AZ_RST#: length 9.8
  TOP w0.102: RC25.2 148.7,54.01 v2(148.07,54.65)
  BOTTOM w0.076: UC1.AU8 146.8,61.78 146.8,61.41 146.69,61.3 146.69,58.68 147.12,58.26 147.12,57.11 v1(148.2,56.03) 148.2,54.77 v2(148.07,54.65)
PCH_AZ_SDIN0_R: length 1.9
  TOP w0.102: U17.8 274.08,29.84 274.28,29.64 274.28,28.68 R136.2
PCH_AZ_SDOUT: length 29.2
  TOP w0.102: RC3.2 158.79,49.76 157.59,49.76 157.14,49.3 RC23.2 RC9.2 v1(155.78,48.36) 154.11,48.36 152.82,49.66 152.82,51.5 151.51,52.81 145.21,52.81 144.58,53.44 144.58,57.27 v2(145.89,58.58)
  BOTTOM w0.076: UC1.AU11 145.23,61.84 145.23,61.19 145.36,61.06 145.36,59.89 145.89,59.35 v2(145.89,58.58)
PCH_AZ_SYNC: length 11.1
  TOP w0.102: RC24.2 145.72,54.01 145.47,53.76 v2(145.21,53.76) ; v1(143.87,61.43) 144.11,61.19 v2(144.53,61.19)
  BOTTOM w0.076: 144.96,58.9 144.96,59 144.61,59.35 144.61,60.77 144.53,60.86 v2(144.53,61.19) 144.83,61.49 UC1.AV11
  BOTTOM w0.102: v2(145.21,53.76) 145.4,53.76 146.16,54.52 146.16,57.7 144.96,58.9
PCH_BATLOW#: length 22.4
  TOP w0.102: RP9.6 162.76,67.24 162.66,67.14 162.66,66.45 162.45,66.24 162.45,65.46 162.87,65.03 162.87,64.28 163.41,63.74 v2(163.5,63.74)
  IN3 w0.089: 153.85,62.69 151.56,62.69 149.66,64.59 v2(149.66,64.73)
  IN3 w0.122: v2(163.5,63.74) 161.65,63.74 160.37,65.02 156.84,65.02 154.51,62.69 153.85,62.69
  BOTTOM w0.076: UC1.AN4 149.32,64.39 v2(149.66,64.73)
  BOTTOM w0.102: v2(163.5,63.74) 163.06,63.3 v1(163.06,63.18)
PCH_CL_CLK1: length 99.1
  IN2 w0.089: v2(151.82,69.51) 151.82,69.35 151.44,68.97 151.44,66.96 151.8,66.6 151.8,65.86 153.09,64.57 153.09,62.6 152.3,61.81 152.3,61.04 152.63,60.71 153.25,60.71 153.85,60.11
  IN2 w0.122: v2(155.03,52.95) 154.32,52.95 153.98,53.3 153.98,59.98 153.85,60.11
  BOTTOM w0.076: v2(151.82,69.51) 151.62,69.31 150.98,69.31 150.62,68.95 UC1.AF2
  BOTTOM w0.102: v2(155.03,52.95) 155.39,53.31 157.57,53.31 157.9,52.98 159.25,52.98 164.21,48.03 164.21,36.35 168.54,32.02 182.94,32.02 184.33,30.63 195.4,30.63 195.65,30.89 196.89,30.89 198.83,28.94 202.7,28.94 202.79,28.85 202.79,28.67 202.91,28.55 203.08,28.55 203.2,28.67 203.2,28.94 203.3,29.04 203.5,29.04 203.6,28.94 203.6,28.4 203.71,28.3 203.91,28.3 204.01,28.4 204.01,28.94 204.11,29.04 204.32,29.04 204.42,28.94 204.42,28.4 204.52,28.3 204.72,28.3 204.82,28.4 204.82,28.94 204.93,29.04 205.73,29.04 205.94,29.26 206.62,29.26 207.32,28.56 209.74,28.56 210.06,28.88 210.06,29.27 210.39,29.6 JMINI1.45
PCH_CL_DATA1: length 100
  IN1 w0.084: v2(152.35,70.33) 152.35,70.31 152.75,69.9 153.37,69.9 153.7,69.57 153.7,69.34 154.03,69.01 157.37,69.01 157.73,69.38 157.73,70.21 158.12,70.59 161.19,70.59 161.51,70.27 162.6,70.27 163.66,69.21 164.06,69.21 164.76,68.51 165.04,68.51 165.46,68.09 176.24,68.09 176.58,68.43 v2(179.25,68.43)
  IN2 w0.122: v2(179.25,68.43) 180.48,67.2 180.48,51.32 189.98,41.82 193.48,41.82 193.6,41.94 193.6,42.31 193.73,42.43 193.96,42.43 194.09,42.31 194.09,41.94 194.21,41.82 194.95,41.82 196.18,40.59 196.36,40.59 196.97,41.2 197.15,41.2 197.31,41.04 197.31,40.86 196.7,40.24 196.7,40.07 196.87,39.9 197.05,39.9 197.62,40.48 197.8,40.48 197.97,40.31 197.97,40.13 197.39,39.56 197.39,39.38 197.56,39.21 197.74,39.21 198.63,40.1 198.81,40.1 198.97,39.94 198.97,39.76 198.08,38.86 198.08,38.69 199.67,37.1 199.67,34.82 202.46,32.03 202.46,31.22 204.15,29.53 v2(204.99,29.53)
  BOTTOM w0.076: v2(152.35,70.33) 152.16,70.14 151.56,70.14 151.37,69.95 151.18,69.95 150.83,69.6 UC1.AD2
  BOTTOM w0.102: v2(204.99,29.53) 205.38,29.53 205.54,29.68 206.71,29.68 207.47,28.92 209.52,28.92 209.7,29.1 209.7,29.42 210.68,30.4 JMINI1.47
PCH_CL_RST1#: length 95.9
  TOP w0.102: v2(154.1,69.51) v1(153.59,69.51)
  IN2 w0.122: v2(159.91,52.91) 159.91,53.57 159.21,54.27 156.64,54.27 155,55.91 155,60.4 154.57,60.82 154.57,63.71 156.01,65.15 156.01,65.91 156.14,66.04 156.89,66.04 157.02,66.17 157.02,66.48 156.89,66.61 156,66.61 155.87,66.74 155.87,67.98 155.98,68.08 155.98,68.46 155.74,68.7 154.9,68.7 v2(154.1,69.51)
  BOTTOM w0.076: 153.85,69.51 153.78,69.51 153.21,68.94 152.81,68.94 152.59,68.71 151.59,68.71 151.44,68.56 150.98,68.56 150.81,68.39 150.16,68.39 150.06,68.49 149.59,68.49 149.32,68.76 UC1.AF4
  BOTTOM w0.102: 153.85,69.51 v2(154.1,69.51) ; R223.1 207.43,29.46 206.86,30.03 202.77,30.03 202.04,29.31 198.97,29.31 197.04,31.24 195.5,31.24 195.25,30.99 184.48,30.99 183.09,32.37 168.69,32.37 164.57,36.49 164.57,48.25 v2(159.91,52.91)
PCH_DPWROK: length 156.7
  TOP w0.102: R319.1 29.67,28.3 v1(30.66,29.29) 31.58,29.29 v2(31.93,29.63)
  IN2 w0.089: 149.64,51.41 149.64,51.45 149.48,51.61 149.48,53.82 150.03,54.37 150.03,56.54 149.78,56.79 v2(149.78,58.52)
  IN2 w0.122: 149.64,51.41 149.64,48.53 144.16,43.05 126.52,43.05 125.48,42 54.41,42 54.13,42.28 53.18,42.28 51.02,40.12 49.7,40.12 44,34.42 43.33,34.42 42.58,33.67 36.65,33.67 32.61,29.63 v2(31.93,29.63)
  BOTTOM w0.076: 153.85,55.12 152.86,55.12 151.42,56.55 150.42,56.55 149.78,57.19 v2(149.78,58.52) ; 149.02,58.65 148.36,59.31 148.36,61.16 148.61,61.41 UC1.AV5
  BOTTOM w0.102: 149.02,58.65 149.15,58.52 v2(149.78,58.52) ; 153.85,55.12 160.46,55.12 RC79.1
PCH_GPIO9: length 18.4
  TOP w0.102: RP9.8 163.32,66.24 163.21,66.13 163.21,65.96 163.39,65.79 v1(163.39,64.95) v2(163.39,64.37)
  IN3 w0.089: v2(150.27,64.73) 150.27,64.27 151.61,62.94 153.85,62.94
  IN3 w0.122: v2(163.39,64.37) 163.03,64.02 161.75,64.02 160.5,65.27 156.74,65.27 154.41,62.94 153.85,62.94
  BOTTOM w0.076: UC1.AM3 149.97,65.03 v2(150.27,64.73)
PCH_GPIO10: length 4.1
  BOTTOM w0.076: UC1.AM2 150.86,65.1 151.15,65.4 151.46,65.4 151.57,65.5 152.09,65.5 153.08,64.51 153.85,64.51
  BOTTOM w0.102: T137.1 153.94,64.43 153.85,64.51
PCH_GPIO14: length 7.1
  TOP w0.102: T138.1 154.23,67.98 153.53,67.28 148.95,67.28 v2(148.79,67.44)
  BOTTOM w0.076: UC1.AH4 148.92,67.31 v2(148.79,67.44)
PCH_GPIO15: length 13.2
  TOP w0.102: v2(148.17,70.29) 148.59,70.71 148.78,70.71 149.23,71.16 150.69,71.16 151.44,71.91 155.82,71.91 156.25,71.48 156.25,69.87 156.71,69.42 v1(156.86,69.42) RC190.2
  BOTTOM w0.076: UC1.AD6 147.99,70.11 v2(148.17,70.29)
PCH_GPIO17: length 5.8
  BOTTOM w0.076: 153.85,74.94 153.24,74.94 152.71,74.41 152.71,73.88 152.5,73.67 151.63,73.67 151.49,73.8 150.48,73.8 150.15,74.13 UC1.T3
  BOTTOM w0.102: 153.85,74.94 154.33,74.94 T139.1
PCH_GPIO36: length 11.8
  TOP w0.102: RP6.5 157.07,72.31 156.9,72.48 v2(156.9,73.13)
  IN3 w0.089: 153.85,73.01 153.14,73.01 152.76,72.63 151.71,72.63 151.23,73.12 149.37,73.12 148.97,73.52 148.54,73.52 v2(148.17,73.14)
  IN3 w0.122: v2(156.9,73.13) 156.52,73.5 154.75,73.5 154.27,73.01 153.85,73.01
  BOTTOM w0.076: v2(148.17,73.14) 147.99,72.97 UC1.V6
PCH_GPIO44: length 22.1
  TOP w0.102: RC200.1 149.8,57.89 149.21,58.47 149.21,59.27 v1(148.89,59.59) 148.45,60.03 148.45,62.55 148.77,62.87 148.77,62.87 149.89,63.98 150.39,63.98 150.9,64.49 150.9,66.22 151.53,66.85 153.87,66.85 154.03,66.68 154.58,66.68 154.93,67.03 v2(154.93,67.2)
  BOTTOM w0.076: 153.38,67.54 152.74,66.89 150.13,66.89 150.09,66.93 149.62,66.93 UC1.AK4
  BOTTOM w0.102: v2(154.93,67.2) 154.52,67.6 153.87,67.6 153.81,67.54 153.38,67.54
PCH_GPIO46: length 15.1
  TOP w0.102: RP7.7 161.93,70.31 v2(162.45,69.8)
  IN4 w0.084: v2(150.32,67.73) 150.78,67.73 151.4,67.1 152.47,67.1 152.98,67.61 153.84,67.61 154.91,68.68 155.93,68.68 156.08,68.83 160.15,68.83 160.77,69.44 162.09,69.44 v2(162.45,69.8)
  BOTTOM w0.076: UC1.AG3 149.97,68.07 v2(150.32,67.73)
PCH_GPIO48: length 4.5
  BOTTOM w0.076: UC1.U4 149.7,72.93 150.09,72.93 150.13,72.89 151.45,72.89 151.75,72.58 153.22,72.58 T140.1
PCH_GPIO49: length 6.4
  TOP w0.102: T141.1 154.25,72.49 152.08,72.49 151.84,72.73 151.47,72.73 150.55,71.81 150.04,71.81 v2(149.62,72.22)
  BOTTOM w0.076: UC1.Y3 149.97,71.87 v2(149.62,72.22)
PCH_GPIO66: length 16.3
  TOP w0.102: RC288.1 154.86,89.84 RC283.2 155.68,89.34 155.68,87.15 154.92,86.4 153.66,86.4 152.53,85.27 v1(152.53,83.58) 152.53,80.82 151.93,80.23 149.95,80.23 v2(149.5,80.67)
  BOTTOM w0.076: UC1.D3 149.61,80.78 v2(149.5,80.67)
PCH_GPIO73: length 7.4
  TOP w0.102: RC34.2 151.63,57.29 v1(152.11,57.78) 152.42,58.08 v2(152.42,58.39)
  BOTTOM w0.076: 150.34,59.98 150.34,60.32 150.28,60.38 150.28,60.98 150.05,61.21 149.83,61.21 149.66,61.39 149.66,61.61 149.3,61.97 UC1.AU4
  BOTTOM w0.102: 150.34,59.98 150.34,59.94 151.88,58.39 v2(152.42,58.39)
PCH_GPIO83: length 11.3
  TOP w0.102: RP2.7 157.07,74.29 156.5,73.72 155.27,73.72 RC292.1 153.87,74.27 153.33,74.82 v1(152.16,74.82) 151.37,75.6 148.65,75.6 148.49,75.44 v2(148.49,75.06)
  BOTTOM w0.076: UC1.R6 148.01,74.57 v2(148.49,75.06)
PCH_GPIO84: length 20.1
  TOP w0.102: v2(164.64,78.12) 164.84,78.32 RP8.7
  IN3 w0.089: v2(148.12,77.2) 148.31,77.2 148.59,77.48 150.46,77.48 151.09,78.11 152.79,78.11 153.2,78.52 153.85,78.52
  IN3 w0.122: 153.85,78.52 154.11,78.78 155.34,78.78 156.24,79.68 160.67,79.68 161.74,78.61 164.15,78.61 v2(164.64,78.12)
  BOTTOM w0.076: v2(148.12,77.2) 148.12,76.91 147.99,76.78 UC1.L6
PCH_GPIO85: length 20.5
  TOP w0.102: RP8.6 164.55,78.82 164.24,78.5 164.24,77.9 v1(163.91,77.58) 163.78,77.44 v2(163.06,77.44)
  IN3 w0.089: 153.85,75.53 152.3,75.53 151.97,75.86 149.28,75.86 149.02,75.6 148.56,75.6 v2(148.17,76)
  IN3 w0.122: 153.85,75.53 156.12,75.53 158.38,77.79 161.24,77.79 161.42,77.61 162.89,77.61 v2(163.06,77.44)
  BOTTOM w0.076: v2(148.17,76) 147.99,75.82 UC1.N6
PCH_GPIO87: length 6.7
  TOP w0.102: RC216.1 146.53,73.58 148.96,73.58 149.16,73.79 149.16,74.27 148.95,74.48 148.06,74.48 147.69,74.85 v2(147.69,75.03)
  BOTTOM w0.076: UC1.R7 147.34,74.68 v2(147.69,75.03)
PCH_INTVRMEN: length 26.6
  TOP w0.102: v2(150.74,54.71) 151.33,54.71 v1(152.49,53.55) 152.78,53.55 154.52,51.82 157.18,51.82 158.52,53.16 159.15,53.16 159.75,53.77 v2(163.09,53.77)
  BOTTOM w0.076: UC1.AV7 146.86,61.23 146.86,58.75 147.29,58.32 147.29,57.42 149.54,55.17 150.28,55.17 v2(150.74,54.71)
  BOTTOM w0.102: v2(163.09,53.77) 163.09,53.96 164.64,55.51 RC2.1 RC1.2
