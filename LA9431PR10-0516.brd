# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 100.4
  TOP w0.127: C142.1 269.42,65.29 v5(269.1,64.97) ; v2(270.31,47.66) 269.51,47.66 v5(269.46,47.61) ; v5(267.11,43.74) 267.26,43.59 v2(267.26,42.9)
  TOP w0.254: v2(270.41,38.65) 270.58,38.47 U17.36 ; U17.26 275.58,37.77 275.91,38.1 276.83,38.1 277.18,37.76 v2(278.05,37.76)
  TOP w0.381: C137.2 276.76,23.74 v2(276.76,24.15) 277.21,24.61 Q20.4
  TOP w0.432: Q21.1 281.47,24.27 280.71,25.03 v2(280.71,25.16) 280.3,25.57 Q21.4 ; v2(268.59,26.9) 268.86,26.63 Q123.4
  TOP w0.508: v2(268.63,38.07) 268.39,38.32 C150.2 ; C385.2 269.44,42.2 269.77,42.53 v2(270.12,42.53) ; v2(267.26,42.9) 267.14,42.79 C144.1 ; D30.1 277.27,52.02 v2(277.51,52.26) ; v2(270.84,65.59) 270.36,66.08 C141.1 270.35,66.38 C142.1 ; v2(274.85,51.21) 274.54,51.21 274.03,51.71 C441.2 ; R39.2 v2(281.43,33.25) ; C116.2 269.14,40.74 C138.2 270.12,40.74 v2(270.14,40.72) ; v2(273.29,44.87) 273.8,44.36 C117.2 273.82,43.98 274.8,43 C115.2 ; v2(267.02,23.43) 267.02,23.7 267.56,24.24 Q123.1 ; C440.2 273.62,49.55 274.43,48.74 v2(274.43,48.17)
  GND1 w0.203: JHP1.7 277.54,65.65 ; JHP1.7 276.41,65.65 ; JHP1.7 275.28,64.98 ; JHP1.7 275.28,65.65 ; JHP1.7 277.54,64.98
  IN1 w0.508: v2(268.63,38.07) 269.84,38.07 v2(270.41,38.65)
  IN2 w0.508: v2(278.05,37.76) 278.75,37.06 278.75,33.27 280.19,31.84 280.19,26.38 280.71,25.86 v2(280.71,25.16) 279.71,24.15 v2(276.76,24.15) 275.06,24.15 274.27,23.37 272.33,23.37 272.06,23.1 272.06,21.53 271.55,21.02 269.43,21.02 v2(267.02,23.43)
  IN4 w0.508: v2(267.02,23.43) 267.77,24.18 267.77,26.07 v2(268.59,26.9)
  GND3 w0.203: JHP1.7 277.54,65.65 ; JHP1.7 276.41,65.65 ; JHP1.7 275.28,65.65 ; JHP1.7 275.28,64.98 ; JHP1.7 277.54,64.98
  BOTTOM w0.254: v2(273.29,44.87) 272.86,44.87 272.69,45.03 PJP4.1
  BOTTOM w0.381: C169.2 272.43,43.64 v2(272.53,43.54)
  BOTTOM w0.457: v2(272.53,43.54) 272.53,42.62 272.76,42.39 C131.2
  BOTTOM w0.508: v2(280.85,53.06) 279.91,52.12 C442.2 ; v2(281.43,33.25) 279.97,33.25 279.08,34.14 279.08,36.6 278.05,37.63 v2(278.05,37.76) ; v2(275.26,44.87) 275.72,44.41 C140.2 ; v2(274.43,48.17) 274.63,48.36 R481.2 ; C443.2 277.48,49.5 D32.1 277.48,52.23 v2(277.51,52.26) ; C167.1 274.17,43.99 v2(273.29,44.87) ; v2(270.31,47.66) 270.37,47.73 C408.2 ; v2(273.26,48.86) 273.26,49.34 273.1,49.5 D31.1
GNDA_CHG: length 2.8
  TOP w0.254: PC708.2 51.4,3.92 PR714.2 52.24,3.9 PC719.1 52.31,3.45 52.13,3.28 v2(51.74,3.28)
  vias: v1(53.8,3.75) v2(52.2,8.58) v2(52.57,7.91) v2(52.91,8.58) v2(53.01,7.28) v2(56.99,7.17)
VCCSENSE: length 38.1
  TOP w0.254: v2(110.29,88.3) 110.38,88.3 111.04,87.64 RC250.2 111.04,84.94 110.62,84.52 v1(110.62,82.78) 110.62,81.07 v2(110.8,80.89) ; v2(98.67,86.19) 98.67,86.02 98.29,85.64 98.29,81.83 97.38,80.92 95.11,80.92 93.95,79.77 93.95,76.96 93.37,76.38 PR531.2
  IN4 w0.254: v2(110.29,88.3) 110.13,88.45 107.79,88.45 107.1,89.14 106.03,89.14 105.38,88.49 103.45,88.49 102.76,89.19 100.44,89.19 98.69,87.44 98.69,86.22 v2(98.67,86.19)
  BOTTOM w0.203: UC1.E63 112.06,80.17 111.81,80.42 111.27,80.42 v2(110.8,80.89)
VCCST_PWRGD: length 14.5
  TOP w0.102: v2(114.15,85.04) 114.15,89.62 v1(113.82,89.95) 112.9,90.87 112.9,91.63 112.8,91.73 112.14,91.73 112.04,91.83 112.04,92.04 112.14,92.14 112.8,92.14 112.9,92.24 112.9,92.72 112.76,92.86 RC245.2
  BOTTOM w0.076: v2(114.15,85.04) 114.15,84.73 115.71,83.16 115.71,82.37 115.51,82.16 UC1.B59
VDD_1.35V: length 5
  TOP w0.102: v2(115.76,14.85) 115.28,14.85 v1(115.06,15.06)
  TOP w0.203: PU11.11 116.61,12.27 v2(116.97,12.62)
  TOP w0.508: v2(115.76,14.85) PR201.1 116.9,15.05 PR202.2 118.63,15.05 118.96,15.38 PC211.1
VSSSENSE: length 37.9
  TOP w0.254: v2(99.26,86.22) 99.26,85.86 98.79,85.39 98.79,81.51 97.7,80.42 95.36,80.42 94.46,79.51 94.46,76.47 PR532.2 ; v2(110.2,80.87) 110.11,80.96 v1(110.11,84.94) 110.11,85.81 109.79,86.13 RC260.1 109.79,87.17 v2(110.29,87.67)
  IN4 w0.254: v2(110.29,87.67) 110.07,87.67 109.8,87.93 107.57,87.93 106.88,88.62 106.25,88.62 105.6,87.97 103.24,87.97 102.54,88.67 100.66,88.67 99.21,87.22 99.21,86.27 v2(99.26,86.22)
  BOTTOM w0.203: v2(110.2,80.87) 111.02,80.05 111.74,80.05 112.02,79.77 112.94,79.77 UC1.E62
3301_ACAV_IN_NB: length 2.7
  TOP w0.254: PR855.1 5.19,32.93 v1(5.89,32.23) 6.28,31.84 PU800.24
3301_DSCHRG_FET_GC: length 198
  TOP w0.102: v2(1.63,29.9) 1.4,29.9 v1(1.07,30.23)
  TOP w0.254: PR841.1 1.44,29.7 v2(1.63,29.9)
  IN3 w0.254: v2(1.63,29.9) 2.59,29.9 3.38,29.11 3.38,23.47 3.76,23.09 9.35,23.09 9.91,22.53 11.81,22.53 13.16,23.88 v2(13.16,24.05)
  BOTTOM w0.254: v2(13.16,24.05) 13.39,23.82 13.92,23.82 14.35,24.26 20.49,24.26 20.75,24.52 21.51,24.52 21.73,24.3 21.73,23.71 21.95,23.49 23.87,23.49 24.41,22.96 29.47,22.96 31.7,25.19 31.7,25.9 32.7,26.9 32.7,31.37 34.27,32.93 35.42,32.93 36.37,33.88 42.11,33.88 45.25,37.02 46.68,37.02 49.07,39.41 51.86,39.41 52.29,38.98 53.68,38.98 54.71,37.95 57.99,37.95 58.26,37.68 60.18,37.68 60.75,37.11 121.18,37.11 121.31,37.24 126.16,37.24 126.57,36.83 126.57,31.47 126.95,31.09 126.95,30.17 127.55,29.57 127.55,29.21 127.95,28.81 127.95,27.83 127.7,27.58 127.7,25.81 128.84,24.66 128.84,22.73 128.32,22.21 128.32,20.7 128,20.38 128,17.69 131.65,14.05 134.59,14.05 134.79,13.86 143.57,13.86 144.62,14.9 146.14,14.9 146.96,15.72 155.82,15.72 PR821.2
3301_PWRSRC: length 2.4
  TOP w0.254: PU800.15 10.75,28.6 10.84,28.51 11.29,28.51 11.82,27.98 PR877.1
+ALC290_LDO_CAP: length 12.7
  TOP w0.102: v2(277.97,35.19) 278.09,35.06 v1(278.49,35.06)
  TOP w0.254: U17.21 277.84,35.07 v2(277.97,35.19)
  IN1 w0.508: v2(277.97,35.19) 277.13,36.03 277.13,36.83 277.41,37.11 277.41,37.74 276.8,38.35 275.01,38.35 274.21,39.15 274.21,40.7 275.25,41.74 v2(275.25,42.04)
  BOTTOM w0.508: C140.1 275.72,42.51 v2(275.25,42.04)
+ALC3226_CPVEE: length 3.7
  TOP w0.254: C138.1 271.58,40.01 U17.34
+ALC3226_VREF: length 11.1
  TOP w0.102: v2(273.88,41.91) 273.88,42.51 v1(273.82,42.56)
  TOP w0.254: U17.25 276.08,37.66 276.14,37.72 276.53,37.72 276.67,37.58 v2(276.67,37.55)
  IN1 w0.508: v2(276.67,37.55) 274.85,37.55 273.37,39.04 273.37,41.4 v2(273.88,41.91)
  BOTTOM w0.508: v2(273.88,41.91) 273.88,42.27 274.17,42.56 C167.2 274,42.98 273.34,43.64 C169.1
+AUX_LDO:
  vias: v1(254.81,24.29)
+BATT_SUM:
  vias: v1(86.86,7.23) v3(86.3,5.85) v3(86.3,5.12) v3(86.93,5.85) v3(86.93,5.12) v3(87.62,5.12) v3(175.92,15.05) v3(175.9,14.38) v3(175.9,13.74) v3(175.9,13.11) v3(175.9,12.47) v3(176.53,14.38) v3(176.53,13.74) v3(176.53,13.11) v3(176.53,12.47) v3(176.56,15.04)
+BL_PWR_SRC:
  vias: v1(65.37,73.52)
+CAP_LDO: length 3.8
  TOP w0.305: U37.B46 18.68,38.47 v2(18.72,38.43)
  BOTTOM w0.127: v1(17.82,39.74) 18.3,40.22 C336.1
  BOTTOM w0.508: C336.1 18.86,38.57 v2(18.72,38.43)
+CHGR_DC_IN: length 68.2
  TOP w0.508: PR833.1 1.44,24.94 1.64,24.74 v2(2.46,24.74) ; v2(46.6,12.86) 46.79,13.06 v5(46.79,13.69) 46.79,14.13 46.95,14.3 PR708.1
  IN4 w0.508: v2(2.46,24.74) 4.46,22.74 5.69,22.74 7.85,20.58 7.85,10.57 8.94,9.49 8.94,7 10.86,5.08 13.41,5.08 14.24,5.9 15.49,5.9 17.07,7.49 18.57,7.49 19.1,6.96 24.44,6.96 24.71,6.68 27.52,6.68 28.6,7.76 31.55,7.76 32.27,8.48 37.63,8.48 40.81,11.66 45.39,11.66 v2(46.6,12.86)
+COINCELL: length 69.6
  TOP w0.305: JSH1.1 262.53,6.86 261.84,7.56 260.23,7.56 257.95,9.84 v2(257.95,10.76)
  TOP w0.508: v2(269.41,52.27) 269.41,53.7 v1(269.09,54.01) 268.02,55.08 PR1.1
  BOTTOM w0.508: 270.04,37.13 270.07,37.11 274.33,37.11 274.69,37.47 275.41,37.47 275.88,37 JRTC1.1 ; 270.04,37.13 270.04,38.15 269.79,38.41 269.79,40.21 269.3,40.69 269.3,50.29 268.67,50.93 268.67,51.85 269.09,52.27 v2(269.41,52.27) ; 270.04,37.13 270.04,21.56 268.69,20.22 268.69,16.89 262.56,10.76 v2(257.95,10.76)
+DC1_PWR_SRC:
  vias: v1(190.47,54.27) v2(185.59,57.38) v2(185.59,56.74) v2(185.59,56.11) v2(186.3,57.38) v2(186.3,56.74) v2(186.3,56.11) v2(187.22,55.87) v2(187.22,55.29) v2(187.86,55.87) v2(187.86,55.29) v2(188.49,55.87) v2(188.49,55.29)
+DC_IN: length 112.7
  TOP w0.508: v2(91.45,79.67) 91.45,80.96 v5(92.06,81.57) 92.41,81.92 93.24,81.92 93.6,81.56 95.57,81.56 PR737.1 ; v2(1.5,21.22) 1.73,21.45 PR835.1
  IN1 w0.508: v2(49.91,37.9) 50.03,37.78 50.03,34.65 48.5,33.12 48.5,27.63 46.12,25.25 46.12,23.82 44.58,22.28 44.58,18.34 42.06,15.82 42.06,14.79 37.15,9.88 34.72,9.88 33.68,10.92 32.46,10.92 v2(32.18,10.64)
  IN2 w0.508: v2(1.5,21.22) 2.82,21.22 3.29,21.69 6.46,21.69 7.47,20.69 7.47,10.48 7.12,10.13 7.12,6.83 9.35,4.61 11.62,4.61 12.7,3.53 13.45,3.53 14.38,4.46 v2(15.16,4.46)
  BOTTOM w0.508: v2(91.45,79.67) 91.75,79.37 91.75,78.84 91.33,78.42 91,78.42 90.58,78.84 83.72,78.84 PL4.2 ; v2(15.16,4.46) 16.44,4.46 16.8,4.83 19.71,4.83 20.31,4.23 26.78,4.23 27.6,3.42 31.5,3.42 31.86,3.78 31.86,10.32 v2(32.18,10.64)
  vias: v2(48.46,37.39) v2(48.83,36.93) v2(48.93,37.86) v2(49.27,37.33) v2(49.39,38.26) v2(82.19,76.28) v2(82.21,75.67) v2(82.21,75.03) v2(82.78,76.28) v2(82.79,75.67) v2(82.79,75.03) v5(48.37,38.52) v5(49.9,40.61)
+DC_IN_SS: length 263.5
  TOP w0.508: v2(198.3,19.28) 198.3,16.93 198.97,16.26 199.48,16.26 199.89,15.85 200.46,15.85 200.93,15.38 203.59,15.38 203.76,15.21 ; PD701.3 52.85,18.61 PR15.1 52.78,19.41 v2(52.55,19.41) ; v2(2.27,26.26) 1.83,26.26 1.44,26.66 PR831.1
  IN3 w0.508: v2(198.3,19.28) 198.3,20.07 195.79,22.58 190.47,22.58 190.12,22.94 185.32,22.94 184.79,22.41 176.72,22.41 173.13,18.83 139.26,18.83 139.05,18.62 134.25,18.62 133.35,19.52 130.7,19.52 130.37,19.85 128.32,19.85 127.31,18.84 124.01,18.84 122.6,17.43 119.12,17.43 118.44,18.11 116.59,18.11 115.96,18.73 115.96,21.74 114.83,22.87 102.54,22.87 99.77,25.64 66.57,25.64 66.27,25.34 57.68,25.34 57.16,24.81 54.4,24.81 v2(52.53,22.94)
  IN4 w0.508: v2(2.27,26.26) 2.35,26.26 5.23,23.38 5.95,23.38 9.19,20.14 9.19,16.25 8.63,15.69 8.63,10.92 9.61,9.93 9.61,7.3 10.72,6.2 11.66,6.2 12,6.54 15.22,6.54 16.81,8.13 18.47,8.13 19.65,9.31 22.48,9.31 22.84,9.66 28.41,9.66 29.58,10.83 29.58,12.04 30.51,12.97 33.1,12.97 34.33,11.73 35.05,11.73 36.02,12.7 37.92,12.7 39.88,14.66 39.88,16.31 40.59,17.02 43.46,17.02 45.19,15.29 46.74,15.29 47.42,15.98 47.42,17.28 48.11,17.97 48.11,18.62 49.61,20.12 51.38,20.12 52.1,19.41 v2(52.55,19.41) 52.55,22.91 v2(52.53,22.94) 53.88,22.94 57.85,26.91 57.85,28.33 57.24,28.94 v2(57,28.94)
  BOTTOM w0.508: v2(57,28.94) 57,29.07 55.87,30.2 55.87,30.96 55.36,31.47
  vias: v2(53.77,33.55) v2(53.78,32.2) v5(52.57,31.03)
+DCIN: length 2.9
  TOP w0.127: v1(50.47,15.11) 50.7,14.88 50.7,14.29
  TOP w0.254: PC706.1 51.13,10.52 51.57,10.08 PU700.20
+DCIN_JACK: length 4
  TOP w0.102: v2(83.95,81.84) v5(83.95,83.48)
  TOP w0.508: PC9.1 82.87,81.88 PD6.1 83.87,81.76 v2(83.95,81.84)
  vias: v5(84.06,80.11) v5(93.46,90.59)
+DCPRRTC: length 5.6
  TOP w0.508: CC36.1 154.42,68.99 154.24,68.81 151.31,68.81 150.95,68.45 149.83,68.45
  BOTTOM w0.229: v2(147.52,69.33) 147.34,69.16 UC1.AE7
  vias: v1(149.59,68.9)
+DIMM1_VREF_DQ: length 7.3
  TOP w0.508: v2(58.23,24.43) 58.23,24.74 v1(58.6,25.11) RD1.2 CD1.1 58.61,28.28 CD2.1
  BOTTOM w0.356: v2(58.23,24.43) 58.7,24.89 59.26,24.89 59.5,25.13 JDIMM1.1
+DIMM2_VREF_DQ: length 7.6
  TOP w0.508: CD32.1 133.09,26.66 RD7.2 CD33.1 135.19,25.73 v1(135.84,25.08) 135.84,24.18 v2(135.84,24.18)
  BOTTOM w0.356: v2(135.84,24.18) 136,24.34 JDIMM2.1
+DOCK_PWR_BAR: length 135.5
  TOP w0.457: PR832.1 1.44,28.26 1.79,28.61 v2(1.89,28.61) ; PD701.2 52.48,17.31 v2(52.9,16.89)
  TOP w0.508: PR814.2 198.63,13.79 198.76,13.66 v3(198.76,13.35)
  IN4 w0.508: v2(52.13,14.53) 50.28,12.67 49.71,12.67 47.35,10.32 45.11,10.32 40.71,5.92 40.71,4.95 40.74,4.92 ; 40.74,4.92 41.06,4.92 41.53,4.44 44.76,4.44 45.14,4.83 50.14,4.83 51.69,6.37 54.65,6.37 55.28,7.01 56.25,7.01 58.28,4.98 59.37,4.98 60.29,4.06 68.77,4.06 71.03,6.32 74.89,6.32 76.95,8.38 85.98,8.38 v2(89.76,4.6) ; 40.74,4.92 32.2,4.92 30.68,3.4 28.18,3.4 27.23,4.36 19.29,4.36 18.15,3.21 10.98,3.21 7.04,7.15 7.04,9.85 7.22,10.04 7.22,20.32 5.43,22.11 4.01,22.11 1.38,24.74 1.38,28.1 v2(1.89,28.61)
  vias: v1(112.4,97.8) v2(51.07,15.21) v2(51.5,15.62) v2(51.5,14.79) v2(51.93,15.19) v2(51.97,16.05) v2(52.39,16.47) v2(52.41,15.62) v2(52.57,15.03) v2(52.84,16.08) v2(53.01,15.43) v2(53.3,16.46) v2(53.43,15.85) v3(103.66,6.48) v3(103.67,5.74) v3(104.39,6.48) v3(104.41,5.74) v3(105.11,5.75) v3(121.81,7.57) v3(122.43,8.23) v3(122.44,7.57) v3(123.09,8.23) v3(123.1,7.57) v3(196.8,13.31) v3(196.8,12.65) v3(196.77,12.01) v3(197.43,13.33) v3(197.43,12.67) v3(197.43,12.03) v3(198.12,13.35) v3(198.12,12.69) v3(198.12,12.01) v3(198.12,11.35) v3(198.76,12.69) v3(198.76,12.01)
+LCDVDD: length 7.6
  BOTTOM w1.524: 55.6,63.05 54.92,63.74 52.5,63.74 50.91,65.33 50.91,67.27
  vias: v2(50.97,69.02) v2(51.55,69) v2(51.55,68.39) v5(52.02,67.96)
+LOM_VCT: length 0.8
  TOP w0.127: 143.83,109 v1(143.07,109)
  vias: v2(144.35,109.88)
+NBDOCK_DC_IN_SS: length 481.3
  TOP w0.127: v2(124.5,98.12) 125.3,98.12 v1(125.36,98.06)
  TOP w0.508: PQ823.1 7.42,39.65 v2(7.07,39.99)
  IN1 w0.508: v2(152.64,12.19) 152.64,15.43 151.1,16.97 134.56,16.97 v2(134.32,17.2)
  IN2 w0.508: v2(10.29,9.93) 9.12,9.93 8.1,10.95 8.1,20.95 6.73,22.33 4.5,22.33 3.8,23.02 3.8,29.5 2.65,30.64 2.65,33.76 4.13,35.23 4.13,37.71 4.85,38.43 5.69,38.43 7.07,39.81 v2(7.07,39.99) ; v2(122.94,94) 122.94,95.33 124.5,96.89 v2(124.5,98.12)
  IN3 w0.508: v2(10.29,9.93) 10.1,9.93 9.64,9.47 9.64,7.43 10.65,6.42 15.51,6.42 16.62,7.53 18.72,7.53 19.55,6.71 21.58,6.71 22.06,6.22 22.06,5.42 23.24,4.24 26.77,4.24 27.8,3.21 42.85,3.21 43.46,3.82 44.49,3.82 45.1,3.21 47.99,3.21 49.12,4.34 52.07,4.34 52.66,3.76 55.04,3.76 55.49,4.2 59.45,4.2 60,3.66 76.66,3.66 76.9,3.89 76.9,6.48 78.78,8.36 82.09,8.36 86.77,3.68 92.96,3.68 97.46,8.18 105.89,8.18 107.49,9.78 116.06,9.78 119.57,13.28 122.38,13.28 123.55,12.12 124.99,12.12 125.55,12.67 129.1,12.67 129.96,11.81 132.4,11.81 133.59,10.62 145.19,10.62 146.76,12.19 v2(152.64,12.19) 152.92,11.91 165.87,11.91 170.78,7 177.8,7 180.75,4.05 188.37,4.05 188.71,3.71 191.87,3.71 192.84,4.67 195.43,4.67 196.95,3.15 v2(197.32,3.15) ; v2(62.34,46.51) 65.98,50.14 65.98,74.45 68.17,76.65 69.56,76.65 74.19,81.28 78.03,81.28 79.31,82.56 82.83,82.56 84.34,84.07 84.34,84.75 85.86,86.27 89.57,86.27 90.27,86.97 93.29,86.97 94.89,88.56 97.35,88.56 100.66,91.87 106.25,91.87 106.63,92.25 107.4,92.25 107.97,92.82 113.02,92.82 113.53,93.32 116.8,93.32 117.29,93.81 119.66,93.81 119.89,93.59 122.52,93.59 v2(122.94,94)
  BOTTOM w0.254: v2(124.5,98.12) 124.5,98.16 123.45,99.21 JDOCK1.41
  BOTTOM w0.508: PQ801.1 152.98,12.53 v2(152.64,12.19) ; PR827.2 198.95,3.87 198.48,4.34 PQ814.3 198.11,3.94 v2(197.32,3.15) ; v2(62.34,46.51) 67.06,46.51 67.82,45.74 131.13,45.74 133.91,42.96 133.91,39.29 132.72,38.1 132.72,31.38 133.52,30.58 133.52,24.95 132.9,24.34 132.9,20.73 134.32,19.31 v2(134.32,17.2)
+PBATT: length 243.1
  TOP w0.508: PQ830.3 209.13,10.98 PR836.2 209.04,11.26 v2(209.64,11.86) ; PR838.1 3.39,31.28 v2(3.45,31.22)
  IN1 w0.508: v3(160.4,14.68) 160.24,14.52 154.45,14.52 151.34,17.63 134.82,17.63 134.58,17.86 132.83,17.86 131.09,19.61 125.08,19.61 v2(124.97,19.49)
  IN3 w0.508: v2(124.97,19.49) 123.76,19.49 122.33,18.07 119.38,18.07 118.69,18.76 117.97,18.76 117.36,19.37 117.36,21.53 115.29,23.6 106.74,23.6 104,26.34 65.9,26.34 65.53,25.97 57.42,25.97 56.9,25.45 52.82,25.45 51.41,24.05 v2(49.83,24.05)
  IN4 w0.508: v2(200.6,2.26) 201.5,1.36 208.33,1.36 211.33,4.36 211.33,9.98 209.64,11.67 v2(209.64,11.86) ; v2(3.45,31.22) 3.73,30.94 8.98,30.94 9.54,30.38 11.78,30.38 12.82,29.34 12.82,26.64 15.04,24.42 16.5,24.42 16.59,24.33 20.35,24.33 21.01,24.99 23.66,24.99 25.07,26.41 25.07,26.9 25.58,27.41 29.32,27.41 30.17,26.56 31.21,26.56 31.61,26.16 32.27,26.16 33.32,27.22 34.4,27.22 35.09,27.91 36.3,27.91 36.78,28.38 41.23,28.38 42.4,27.22 44.69,27.22 45.06,27.58 45.06,27.58 v2(45.06,27.58)
  BOTTOM w0.508: v2(200.6,2.26) 200.4,2.07 191.2,2.07 189.34,3.92 181.04,3.92 178.84,6.12 166.19,6.12 162.05,10.26 162.05,11.63 ; v2(45.06,27.58) 45.06,27.58 45.06,26.85 46.34,25.56 48.31,25.56 v2(49.83,24.05)
  vias: v3(161.04,15.34) v3(161.04,14.07) v3(161.06,14.71) v3(161.71,15.37) v3(161.71,14.73) v3(161.71,14.1) v3(162.34,15.37) v3(162.34,14.73) v3(162.34,14.1) v5(165.21,13.06)
+PBATT_IN_SS: length 9.8
  TOP w0.127: v2(157.63,13.44) 157.54,13.44 v1(157.02,13.96)
  BOTTOM w0.508: v2(157.63,13.44) 157.63,10.01 157,9.37 155.45,9.37 154.98,9.84 154.98,11 155.31,11.33 PD807.2
  vias: v2(167.95,15.11) v2(167.95,14.53) v2(167.95,13.94) v2(167.96,13.35)
+PCH_ASATA3PLL: length 20.6
  IN3 w0.508: v2(136.47,89.52) 137.62,88.38 141.85,88.38 143.15,89.69 v2(143.46,89.69) 143.46,88.56 143.36,88.46 143.36,86.64 144.28,85.71 144.28,85.05 144.53,84.81 v2(144.78,84.81)
  BOTTOM w0.229: UC1.B11 144.53,82.22 144.53,84.55 v2(144.78,84.81)
  BOTTOM w0.508: v2(136.47,89.52) 136.63,89.67 136.63,90.68 CC77.1 ; v2(143.46,89.69) 143.57,89.57 RC14.1 RC19.2
  vias: v1(145.47,90.53)
+PCH_AUSB3PLL: length 26.6
  TOP w0.508: v2(140.7,92.08) 140.7,92.04 v5(141.14,91.6) LC1.2
  IN2 w0.508: v2(139.95,86.51) 140.78,87.34 140.78,91.96 140.7,92.04 v2(140.7,92.08)
  IN3 w0.508: v2(139.95,86.51) 135.16,86.51 134.26,87.4 134.26,87.6 133.11,88.76 v2(133.11,89.13)
  BOTTOM w0.254: UC1.B18 140.4,82.54 140.13,82.81 140.13,82.97 140.13,84.42
  BOTTOM w0.508: CC42.1 140.77,87.32 v2(139.95,86.51) 139.6,86.16 139.6,84.95 140.13,84.42 ; CC76.1 133.67,89.68 v2(133.11,89.13) 133.11,88.61 RC163.1 133.67,88.38 134.35,87.69 RC161.1
+PCH_DCPSUS: length 27.7
  TOP w0.508: 137.91,91.29 CC62.1 139.5,91.29 139.83,90.96 140.63,90.96 141.38,90.21 v1(141.38,89.64) 141.38,88.52 141.92,87.97 CC61.1 142.61,87.69 143.72,86.58 143.72,84.97 144.29,84.4 144.29,82.48 145.01,81.76 v2(145.01,80.76) ; v2(144.28,77.94) 144.28,77.85 CC66.1
  IN2 w0.508: v2(144.39,67.67) 144.39,67.86 144.96,68.43 145.4,68.43 146.09,69.11 146.09,76.99 146.1,77
  BOTTOM w0.229: v2(144.28,77.94) 144.24,77.94 143.91,77.6 UC1.J13 ; v2(144.39,67.67) 144.06,67.34 UC1.AH13
+PCH_DCPSUS1: length 1.7
  BOTTOM w0.254: v2(145.09,70.14) 145.21,70.01 145.59,70.01 UC1.AD10 UC1.AD8
+PCH_DCPSUS4: length 31.9
  TOP w0.508: CC53.1 144.78,71.93 v2(144.39,71.54)
  IN1 w0.508: v2(146.86,71.24) 146.4,71.24 145.53,72.11 144.96,72.11 v2(144.39,71.54)
  IN3 w0.508: v2(161.75,88.3) 161.75,87.83 161.16,87.25 156.79,87.25 155.02,85.47 155.02,83.37 154.42,82.78 153.47,82.78 152.58,81.89 152.58,81.18 v2(153.09,80.67)
  IN4 w0.508: v2(153.09,80.67) 152.5,80.09 152.5,78.28 152.22,78 151.08,78 150.44,77.37 150.42,77.37
  BOTTOM w0.254: v2(146.86,71.24) 146.69,71.06 UC1.AB8
  BOTTOM w0.508: v2(161.75,88.3) 161.75,88.8 161.18,89.37 161.18,93.27 161.4,93.5 CC75.1 LC4.2
+PCH_RTC_VCCSUS3_3: length 33.3
  IN3 w0.508: 145.24,65.58 145.24,61.14 145.84,60.53 154.35,60.53 156.9,57.98 159.33,57.98 159.92,58.57 160.43,58.57 161.7,59.83 161.7,60.35 162.59,61.24 164,61.24 v2(165.03,62.27)
  BOTTOM w0.229: 144.8,67.34 144.69,67.34 v2(144.39,67.03)
  BOTTOM w0.254: UC1.AH11 144.8,67.34
  BOTTOM w0.508: CC30.1 v2(165.03,62.27) 164.9,62.4 v1(164.9,63.83) 164.9,64.67 165.24,65.01 165.47,65.01 RC264.2 RC261.2
+PCH_VCC1P05: length 16.6
  TOP w0.508: 141.47,81.44 141.47,81.58 139.67,83.37 139.67,84.8 138.35,86.12 138.35,87.54 v1(138.93,88.12) 139.17,88.12 140.14,89.08 v2(140.14,89.65)
  BOTTOM w0.229: v2(141.48,77.92) 141.28,77.92 141.05,77.7 UC1.J18 141.05,77.48 140.69,77.11 UC1.K19
  BOTTOM w0.508: v2(140.14,89.65) 140.47,89.65 141.05,90.23 141.05,90.66 141.58,91.2 CC79.1 141.92,91.53 142.6,91.53 143.34,92.28 LC3.2
+PCH_VCCACLKPLL: length 31.3
  IN3 w0.508: v2(132.19,89.44) 130.57,89.44 129.64,90.37 129.64,91.09 127.91,92.82 v2(127.91,93.45) 128.63,93.45 131.29,90.78 132.77,90.78 v2(134.34,89.2) 135,89.2 137.06,87.15 v2(139.08,87.15)
  BOTTOM w0.254: v2(139.08,87.15) 138.93,86.99 v1(138.93,86.25) 138.93,84.31 139.75,83.49 UC1.A20
  BOTTOM w0.508: LC6.2 v2(132.19,89.44) ; RC45.2 135.24,87.74 134.34,88.65 v2(134.34,89.2) ; v2(127.91,93.45) 127.91,93.27 128.76,92.43 CC78.1 ; v2(139.08,87.15) 139.13,87.15 139.66,87.68 CC58.1
+PCH_VCCDSW: length 12.7
  TOP w0.254: v2(140.34,67.65) 140.34,67.24 139.62,66.52 139.62,62.52 138.96,61.85 v1(138.96,60.65) 138.96,58.81 139.37,58.39 RC275.2
  BOTTOM w0.254: UC1.AG20 139.97,68.02 v2(140.34,67.65) 140.71,68.02 UC1.AG19
+PCH_VCCDSW3_3: length 193.8
  TOP w0.305: JAPS1.7 37.39,45.63 37.39,46.52 v2(37.77,46.9) 38.21,47.35 38.66,47.35 38.72,47.33 39.04,46.77 JAPS1.3
  TOP w0.508: RC265.2 145.78,68.44 CC32.1 145.8,67.21 v2(145.99,67.02) ; v2(168.05,65.24) 168.05,64.91 167.75,64.62 RC206.2 167.39,63.66 RC197.2 RC267.2
  IN3 w0.508: v2(168.05,65.24) 166.41,65.24 165.31,66.34 v2(165.31,67.01) 164.98,67.33 163.75,67.33 162.2,65.79 161.37,65.79 160.93,66.22 155.85,66.22 154.53,64.9 152.98,64.9 150.93,66.95 150.93,67.13 ; v2(166.27,39.37) 166.27,40.06 162.85,43.47 123.61,43.47 123.15,43.01 v2(123.15,42.7)
  BOTTOM w0.229: v2(145.99,67.02) 145.99,67.08 145.73,67.34 145.63,67.34
  BOTTOM w0.254: UC1.AH10 145.63,67.34
  BOTTOM w0.508: v2(168.05,65.24) 168,65.24 167.41,64.66 167.41,60.98 166.98,60.55 166.98,59 v1(168.33,57.66) 168.33,41.43 v2(166.27,39.37) ; v2(123.15,42.7) 123.04,42.58 64.43,42.58 63.58,43.43 56.39,43.43 55.25,44.58 52.28,44.58 52.01,44.84 49.79,47.07 48.79,47.07 47.22,48.63 46.68,48.63 46.09,49.22 43.21,49.22 42.16,48.17 39.79,48.17 39.39,47.78 38.41,47.78 37.77,47.14 v2(37.77,46.9)
+PCH_VCCDSW_R: length 0.9
  TOP w0.508: RC275.1 CC65.1
+PECI_VREF: length 5.6
  TOP w0.102: v1(19.37,24.21) R374.1
  TOP w0.305: U38.B51 20.69,19.37 20.19,19.86
  TOP w0.508: R374.1 C360.1 19.37,20.69 20.19,19.86
+PWR_SRC: length 24.4
  TOP w0.508: v2(71.22,67.86) R97.1 C66.1
  IN3 w1.016: 207.29,58.54 207.37,58.62 207.37,65.3 207.53,65.47 207.53,66.81 207.9,67.18
  IN3 w3.048: 72.26,11.38 66.75,11.38 64.74,13.39
  BOTTOM w1.016: 72,66.14 72.7,66.14 74.28,64.55 74.28,61.89
  vias: v2(54.62,20.52) v2(54.62,19.89) v2(55.23,20.54) v2(55.23,19.9) v2(55.82,20.54) v2(55.82,19.9) v2(188.77,52.29) v2(189.41,52.29) v2(189.41,51.7) v2(189.43,51.1) v2(190.04,52.29) v2(190.04,51.7) v2(190.04,51.1) v2(190.04,50.47) v2(206.38,58.32) v2(206.38,57.73) v2(221.49,72.9) v2(222.1,72.9) v3(71.17,7.04) v3(71.55,8.05) v3(71.81,7.02) v3(72.21,8.08) v3(72.62,14.3) v3(72.89,8.04) v3(73.05,13.66) v3(73.33,14.35) v3(73.52,8.04) v3(73.76,13.72) v3(73.97,14.35) v3(74.16,8.04) v3(74.4,13.72) v3(74.83,61.01) v3(74.83,60.38) v3(74.83,8.03) v3(74.85,59.73) v3(75.49,61.7) v3(75.46,61.01) v3(75.46,60.38) v3(75.46,8.03) v3(106.4,5.13) v3(107.05,5.1) v3(107.68,5.1) v3(108.37,5.1) v3(109,5.1) v3(109.64,5.1) v3(110.3,5.13) v5(221.73,71.35)
+PWR_SRC_AC: length 121.4
  TOP w0.127: v2(60.53,35.71) 60.53,34.98 v5(60.4,34.85)
  TOP w0.508: v2(13.64,27.89) 13.55,27.98 PR877.2
  IN3 w0.508: v2(13.64,27.89) 13.21,27.46 13.21,26.87 13.71,26.36 17.41,26.36 18.02,25.75 21.17,25.75 21.72,26.3 23.65,26.3 24.03,25.92 27.93,25.92 28.27,26.26 28.27,27.11 28.76,27.61 31.21,27.61 31.87,28.27 33.27,28.27 33.55,28.55 34.77,28.55 35.23,28.09 36.27,28.09 36.83,28.65 39.19,28.65 41.08,30.54 45.25,30.54 50.65,35.94 60.3,35.94 v2(60.53,35.71)
  IN4 w0.508: 63.3,12.9 63.3,17.65 62.51,18.44 59.83,18.44 59.12,19.15 59.12,22.41 58.22,23.32 57.48,23.32 57.15,23.65 57.15,25.31 58.49,26.65 58.49,29.76 59.08,30.36 59.08,34.27 v2(60.53,35.71)
  IN4 w3.048: 67.87,10.52 87,10.52 92.68,4.83 101.88,4.83
  vias: v2(54.52,10.11) v2(54.84,10.72) v2(55.11,10.13) v2(55.75,10.21) v2(56.38,10.18) v3(200.75,11.09) v3(200.75,10.45) v3(200.79,11.73) v3(201.45,11.73) v3(201.41,11.09) v3(201.41,10.45)
+RSVD_VCC3P3_1: length 4.2
  TOP w0.254: 257.78,73.65 257.78,74.76 257.18,75.37 U21.1
  TOP w0.508: 257.78,73.65 257.92,73.51 R178.2
+RTC_CELL: length 437.4
  TOP w0.254: v2(149.66,54.71) 148.88,54.71 148.49,55.1 147.85,55.1 147.7,54.95 RC7.1
  TOP w0.508: v2(12.87,15.21) R332.1 ; v2(267.94,28.22) 267.94,28.17 268.39,27.72 R202.1 ; PD3.1 266.42,65.01 266.12,65.32 PC1.1 267.3,67.22 267.53,67.45 267.53,68.92 266.55,69.9 266.55,73.34 v2(266.33,73.55) ; R327.1 13,5.31 v2(12.57,5.74) 12.14,5.31 R328.1 ; R346.1 R347.1 15.21,9.18 14.67,9.18 14.44,8.95 v2(14.44,8.94)
  IN1 w0.508: v2(267.25,45.69) 266.85,46.09 266.85,73.04 v2(266.33,73.55) ; v2(12.87,15.21) 12.82,15.21 12.34,14.74 12.34,8.96 12.57,8.74 ; 12.57,8.74 v2(12.57,5.74) ; 12.57,8.74 14.23,8.74 v2(14.44,8.94) ; v2(57.05,49.4) 52.31,44.66 52.31,41.1 51.36,40.14 51.36,33.69 50.07,32.4 v2(49.46,32.4)
  IN3 w0.508: v2(266.33,73.55) 265.83,73.55 265.05,74.34 265.05,80.31 263.88,81.48 260.47,81.48 259.21,80.22 259.21,78.43 258.5,77.72 255.75,77.72 254.49,76.46 249.32,76.46 245.4,80.38 244.11,80.38 242.15,82.33 242.15,83.26 239.81,85.6 235.84,85.6 234.92,84.68 232.78,84.68 232.29,84.19 223.56,84.19 222.72,83.35 221.01,83.35 220.9,83.46 212.67,83.46 211.67,82.46 209.55,82.46 206.43,79.34 205.38,79.34 203.12,77.08 202.57,77.08 201.77,76.28 201.42,76.28 201.4,76.26 200.75,75.61 200.75,74.56 199.53,73.34 192.83,73.34 190.11,70.62 185.89,70.62 185.14,69.87 183.77,69.87 182.38,68.49 180.56,68.49 179.88,67.82 179,67.82 178.23,68.58 176.7,68.58 176.23,68.1 176.23,66.94 177.29,65.87 177.29,63.51 175.18,61.4 175.18,60.39 174.13,59.33 171.77,59.33 170.19,60.91 167.36,60.91 166.44,60 166.44,59.05 166.07,58.67 166.07,57.35 v2(165.81,57.1) 165.67,56.96 164.05,56.96 164.02,56.93 163.01,56.93 v2(162.8,57.14) 162.8,56.5 161.04,54.74 156.18,54.74 154.38,56.54 150.6,56.54 149.68,55.63 149.68,54.74 v2(149.66,54.71) 148.97,54.71 148.56,55.12 148.56,56.77 145.06,60.27 144.2,60.27 143.76,60.71 143.76,62.53 143.36,62.94 143.36,66.83 v2(143.56,67.03)
  IN4 w0.508: v2(49.46,32.4) 49.3,32.4 48.92,32.01 48.92,30.79 47.57,29.44 47.57,27.23 45.79,25.46 41.76,25.46 41.19,26.03 35.51,26.03 33.72,24.24 30.82,24.24 29.81,25.25 26.21,25.25 25.26,24.3 25.26,23.41 25.01,23.15 23.28,23.15 22.3,22.17 12.79,22.17 11.87,21.26 11.87,18.34 12.22,17.99 12.22,15.86 v2(12.87,15.21) ; v2(57.05,49.4) 57.53,49.88 57.53,54.79 56.86,55.46 v2(55.91,55.46) ; v2(267.25,45.69) 267.25,43.87 267.87,43.24 267.87,39.41 266.22,37.76 266.22,33.43 267.79,31.85 267.79,29.57 268.16,29.2 268.16,28.68 267.94,28.46 v2(267.94,28.22)
  BOTTOM w0.254: v2(145.2,67.68) 145.19,67.68 145.21,67.66 145.21,67.64 145.59,68.02 UC1.AG10
  BOTTOM w0.508: v2(57.05,49.4) 57.1,49.45 66.53,49.45 67.11,50.03 67.11,50.96 69.53,53.38 76.05,53.38 78.27,51.16 146.1,51.16 v2(149.66,54.71) ; RC1.1 165.53,56.62 165.79,56.87 165.79,57.07 v2(165.81,57.1) ; RC6.1 56.81,56.45 RC8.1 56.58,56.44 55.91,55.77 v2(55.91,55.46) ; RC73.2 v2(162.8,57.14)
+RTC_CELL_VBAT: length 11.3
  TOP w0.305: v2(21.32,12.68) 21.31,12.67 20.56,12.67 20.47,12.58 U38.B64
  TOP w0.508: v2(14.28,13.63) 14.54,13.89 C345.1 R332.2
  IN4 w0.508: v2(21.32,12.68) 21.23,12.77 20.27,12.77 19.36,13.69 18.69,13.69 18.16,14.22 17.3,14.22 16.21,13.13 15.55,13.13 15.05,13.63 v2(14.28,13.63)
+SD_IO_LDO:
  vias: v1(252.64,15.84)
+SDC_IN: length 94.5
  TOP w0.508: PR713.2 49.57,3.92 49.1,3.46 v2(49.1,3.46) ; PR854.1 7.29,21.78 8.1,20.97 v5(8.69,20.97) 9.27,20.97 v2(9.4,21.09)
  IN1 w0.508: v2(49.71,5.49) 49.1,4.88 v2(49.1,3.46)
  IN2 w0.508: v2(9.4,21.09) 9.18,20.87 9.18,18.48 9.9,17.75 10.72,17.75 11.24,17.23 11.24,9.14 11.87,8.52 11.87,5.26 12.3,4.83 13.54,4.83 14.47,5.75 15.86,5.75 16.69,4.93 16.69,3.9 17.13,3.46 21.14,3.46 21.87,4.19 27.14,4.19 27.87,3.46 40.88,3.46 41.52,4.1 45.39,4.1 v2(45.39,4.1) 45.89,4.6 48.29,4.6 49.1,3.78 v2(49.1,3.46)
  IN4 w0.508: v2(49.71,5.49) 50.88,6.65 50.88,8.91 51.74,9.78 53.11,9.78 53.67,10.34 53.67,11.76 55.83,13.92 55.83,15.67 58.04,17.88 v2(58.04,19.61)
  BOTTOM w0.508: v2(58.04,19.61) 56.44,21.21 56.44,22.52 57.26,23.34 57.26,26.64 56.06,27.85 54.22,27.85
+SIM_PWR: length 205.2
  TOP w0.127: v1(267.16,7.43) 266.53,6.81 JSH1.9
  TOP w0.305: JSH1.9 266.53,4.37 v2(266.51,4.39)
  IN2 w0.508: JMINI2.8 207,43.35 206.25,44.1 206.25,46.11 205.75,46.61 205.75,47.57 206.21,48.03 206.21,50.4 205.13,51.49 205.13,62.11 204.26,62.97 204.26,64.64 204.46,64.84 204.46,69.06 204.01,69.51 204.01,71.27 205.53,72.8 206.62,72.8 207.43,73.61 207.43,76.22 209.8,78.59 212.47,78.59 213.24,79.36 217.08,79.36 218.37,80.65 221.23,80.65 222.75,82.17 237.12,82.17 238.79,80.49 240.02,80.49 240.7,79.81 240.7,78.92 242.06,77.56 244.52,77.56 245.75,76.32 254.16,76.32 256.56,73.91 262.59,73.91 263.06,74.38 264.67,74.38 265.65,73.41 265.65,72.43 267.48,70.59 267.48,47.86 269.23,46.12 269.23,38.81 269.86,38.18 269.86,33.5 268.87,32.51 266.59,32.51 264.47,30.39 253.16,30.39 252.45,29.68 252.45,28.37 252.92,27.9 252.92,25.39 252.15,24.61 252.15,19.93 251.77,19.54 251.77,15.94 252.73,14.97 252.73,11.82 256.15,8.41 265.15,8.41 266.51,7.05 v2(266.51,4.39)
+SM_VREF_CA: length 54.8
  TOP w0.127: v1(128.75,32.23) 128.51,31.99 v2(128.15,31.99)
  TOP w0.254: v2(114.05,15.84) CC67.1 RC68.2
  IN3 w0.508: v2(128.15,31.99) 127.77,31.99 125.79,33.98 123.53,33.98 121.59,35.92 121.59,55.98 121.26,56.31
  IN4 w0.508: v2(128.15,31.99) 127.7,31.99 126.57,30.86 126.57,29.95 126.54,29.92 126.37,29.92 124.99,28.55 124.08,28.55 117.2,21.67 117.2,18.47 114.57,15.84 v2(114.05,15.84)
  BOTTOM w0.279: UC1.AP49 121.39,63.95 v2(121.07,63.63)
+SM_VREF_CA_DIMM:
  vias: v1(110.62,17.59)
+SM_VREF_CA_DIMM1: length 23.1
  TOP w0.102: v2(99.4,16.22) 100.6,17.42 v1(107.52,17.42) 110.11,17.42 110.8,16.74 110.8,15.54 111.34,15 114.2,15 114.91,15.71 CD13.1 CD12.1 RD12.1
  BOTTOM w0.254: JDIMM1.126 v2(99.4,16.22)
+SM_VREF_CA_DIMM2: length 77.7
  TOP w0.102: v2(112.89,20.04) 112.72,20.21 RD13.1 ; CD44.1 CD43.1 172.29,17.74 173.08,17.74 174.55,19.22 v1(174.8,19.22) v2(175.9,19.22)
  IN1 w0.084: v2(175.9,19.22) 175.39,18.71 135.34,18.71 130.87,23.18 123.55,23.18 122.36,21.99 122.36,20.93 119.81,18.37 112.87,18.37 112.54,18.7 112.54,19.69 v2(112.89,20.04)
  BOTTOM w0.102: JDIMM2.126 v2(175.9,19.22)
+SM_VREF_DQ0: length 100.3
  TOP w0.508: RC173.2 54.74,28.3 54.27,28.76 v1(53.87,28.76) 53.87,28.19 54.29,27.77 CC70.1 54.29,27.23 53.65,26.58 53.65,26.14 54.1,25.68 55.11,25.68 55.63,26.2 v2(55.63,26.64)
  IN1 w0.508: v2(55.63,26.64) 55.63,28.56 56.73,29.67 58.5,29.67 60.04,31.21 60.04,32.85 61.99,34.8 61.99,38.47 61.43,39.02 61.43,43.87 64.9,47.34 v2(64.9,50.06)
  IN2 w0.508: v2(64.9,50.06) 67.69,50.06 68.33,50.7 73.76,50.7 74.24,51.18 113.64,51.18 119.53,57.07 119.53,59.56 120.12,60.15 v2(120.12,62.97)
  BOTTOM w0.254: v2(120.12,62.97) 120.19,62.97 UC1.AR51
+SM_VREF_DQ0_DIMM1: length 4.8
  TOP w0.102: RC217.2 56.07,29.3 v1(57,30.23)
  TOP w0.508: RC217.2 RC173.1 RC221.1 56.1,27.38 RD1.1
+SM_VREF_DQ1: length 48.1
  TOP w0.508: RC126.2 CC69.1 136.32,29.85 136.32,31.03 135.45,31.9 134.23,31.9 133.28,30.95 v1(131.05,30.95) 129.29,30.95 128.88,31.36 v2(128.14,31.36)
  IN3 w0.508: 119.74,61.59 119.74,60.15 119.38,59.79 119.38,37.24 123.27,33.35 125.52,33.35 127.51,31.36 v2(128.14,31.36)
  BOTTOM w0.254: UC1.AP51 120.45,63.95 v2(120.12,63.62)
+SM_VREF_DQ1_DIMM2: length 4.2
  TOP w0.102: v1(132.65,28.85) 133.07,28.44 RC130.2
  TOP w0.508: RC132.1 RC126.1 RC130.2 RD7.1
+USB_PWR:
  vias: v2(227.05,91.35) v2(227.05,90.72) v2(227.69,91.35) v2(227.69,90.72) v5(227.19,93.89)
+USB_SIDE_PWR: length 7.8
  IN2 w1.524: 262.28,83.21 264.36,83.21 266.73,80.85 269.1,80.85
  vias: v2(236.02,83.92) v2(236.6,83.92) v2(237.19,83.92) v2(271.45,80.54) v2(272.11,81.18) v2(272.11,80.54) v5(235.83,82.91)
+V_DDR_REF: length 5.7
  TOP w0.127: PC212.1 117.78,6.62 118.62,5.78 118.62,4.86 v1(118.29,4.53)
  TOP w0.203: PU11.4 116.21,8.22 116.71,7.72
  TOP w0.508: 116.71,7.72 117.12,7.72 117.78,7.06 PC212.1
+VCHGR:
  vias: v3(83.62,14.93) v3(83.62,14.3) v3(83.62,13.66) v5(83.55,11.72)
+VDISPLAY_VCC:
  vias: v1(267.4,87.08) v2(268.29,87.06) v2(268.87,87.06) v2(272.02,87.05) v2(272.63,87.05)
+VHDMI_VCC: length 0.7
  TOP w0.102: v5(199.76,101.24) 199.76,100.82 v2(199.59,100.66)
  vias: v2(186.17,103.02) v2(186.17,102.29) v2(199.01,100.57)
+VR_CAP: length 13.3
  TOP w0.305: v2(27.48,11.8) 27.39,11.71 26.95,11.71 26.19,10.95 U38.B12
  TOP w0.381: C366.1 26.91,4.93 v2(26.28,5.56)
  TOP w0.508: C366.1 27.23,3.94 v1(27.61,3.56)
  BOTTOM w0.508: v2(26.28,5.56) 26.28,5.88 25.71,6.45 25.71,11.2 26.3,11.8 v2(27.48,11.8)
+VREFOUT: length 16.4
  TOP w0.254: U17.23 277.8,36.07 v2(277.97,36.23) 278.4,36.23 v1(278.63,36.46)
  IN1 w0.508: v2(277.68,39.88) 278.64,39.88 278.92,39.6 278.92,37.19 v2(277.97,36.23)
  BOTTOM w0.457: C131.1 271.77,42.09 272.58,41.27 274.49,41.27 274.74,41.02 274.74,39.28 275.04,38.98 275.95,38.98 276.28,39.31 276.28,39.73 276.75,40.19 277.37,40.19 v2(277.68,39.88)
-DCIN_JACK: length 2.7
  BOTTOM w0.102: v1(91.21,79.11) 90.44,79.88 90.44,81.53
A_ON: length 284.2
  TOP w0.102: v2(187.82,33.26) 187.76,33.32 v1(186.77,33.32) 186.61,33.48 186.61,34.92 187.8,36.11 187.8,36.35 188.37,36.92 188.37,37.41 188.79,37.83 192,37.83 194.17,35.66 195.42,35.66 R424.1 196.95,34.98 198.36,33.57 200.76,33.57 201.26,33.07 v2(202.91,33.07) ; v2(35.79,13.93) 35.52,14.2 R372.2 ; v2(28.55,13.26) 28.68,13.4 28.82,13.4 29,13.58 U38.B24
  TOP w0.254: PR304.1 241.47,73.44 v2(241.48,73.46)
  IN3 w0.122: v2(35.79,13.93) 35.92,13.93 36.85,14.86 39.38,14.86 40.64,16.11 40.64,21.89 43,24.26 43,25.24 44.3,26.53 46.89,26.53 49.68,29.32 50.74,29.32 52.36,30.94 55.35,30.94 57.29,32.87 62.28,32.87 63.06,33.66 116.84,33.66 121,29.51 121,26.55 122.73,24.81 126.37,24.81 127.56,26 129.33,26 130.58,27.25 130.87,27.25 132.03,28.41 132.13,28.41 134.27,30.55 134.27,31.89 137.63,35.25 185.28,35.25 186.34,34.18 186.9,34.18 v2(187.82,33.26)
  IN4 w0.084: v2(241.48,73.46) 241.48,73.25 242.47,72.26 242.47,71.37 241.35,70.26 215.93,70.26 213.98,68.31 209.35,68.31 205.6,64.56 205.6,63.14 205.35,62.89 205.35,51.92 204.55,51.12 204.55,43.47 205.27,42.74 205.27,40.81 205.29,40.76 205.29,40.74 202.21,37.66 202.21,33.32 202.46,33.07 v2(202.91,33.07)
  BOTTOM w0.102: v2(35.79,13.93) 35.66,13.8 34.71,13.8 34.02,13.12 28.7,13.12 v2(28.55,13.26)
AC_DIS: length 75.9
  TOP w0.102: U37.B12 21.68,30.26 v2(21.39,30.56)
  TOP w0.254: v2(53.5,43.72) 54.19,43.03 v1(54.19,42.57) 54.19,41.69 54.55,41.34 54.55,40.56 54.19,40.21 PQ6.5
  IN3 w0.254: v2(21.39,30.56) 21.62,30.33 22.72,30.33 22.94,30.54 22.94,30.78 23.24,31.09 23.61,31.09 23.8,30.9 27.78,30.9 28.47,31.59 28.47,31.95 30.19,33.67 31.36,33.67 31.8,33.23 35.61,33.23 38.95,36.57 44.45,36.57 48.74,40.86 48.74,42.16 50.3,43.72 v2(53.5,43.72)
  IN4 w0.084: v2(9.41,32.8) 8.66,32.8 5.22,36.25 4.74,36.25 3.87,37.11 2.38,37.11 v2(2.02,37.46)
  BOTTOM w0.254: v2(21.39,30.56) 21.29,30.56 20.82,31.03 20.82,31.98 20.66,32.13 19.91,32.13 18.01,34.04 13.21,34.04 12.67,33.5 11.4,33.5 10.71,32.8 v2(9.41,32.8) ; PR828.1 2.03,42.8 1.17,41.93 1.17,38.32 v2(2.02,37.46)
AC_PRESENT: length 202.3
  TOP w0.102: v2(18.01,16.05) 18.02,16.04 18.7,16.04 18.9,15.83 U38.A54 ; RP9.5 162.69,67.74 162.43,67.49 162.43,66.55 161.99,66.1 161.99,65.3 v2(162.43,64.86)
  IN1 w0.084: v2(15.72,28.63) 15.72,26.57 15.54,26.38 15.54,26.36 15.16,25.99 15.16,24.54 16.04,23.67 16.04,22.75 17.06,21.73 17.06,17.57 17.76,16.87 17.76,16.3 v2(18.01,16.05) ; v2(146.4,67.49) 146.4,67.43 146.8,67.03 147.32,67.03 147.36,67.06 148.27,67.06 148.51,66.82 148.51,66.22 148.45,66.15 148.45,64.26 148.62,64.1 150.6,64.1 150.93,64.43 153.29,64.43 155.55,66.69 155.55,67.2 155.84,67.49 157.68,67.49 158.08,67.08 159.07,67.08 159.44,66.71 160.58,66.71 v2(162.43,64.86)
  IN2 w0.089: v2(146.4,67.49) 146.4,67.24 146.85,66.79 146.85,66.22 147.06,66.01 147.06,62.56 146.62,62.12 146.62,58.41 147.11,57.91 147.11,56.94 146.87,56.7 146.87,53.59 145.25,51.97 145.25,51.41
  IN2 w0.122: 145.25,51.41 145.25,50.25 141.89,46.89 117.09,46.89 116.09,45.89 67.62,45.89 67.2,46.32 63.22,46.32 61.88,47.65 59.41,47.65 57.65,45.89 55.75,45.89 54.83,44.98 51.02,44.98 45.01,38.96 44.25,38.96 42.55,37.26 35.93,37.26 34.56,35.89 29.85,35.89 27.71,33.76 26.09,33.76 25.41,33.08 25.41,31.11 23.73,29.43 18.89,29.43 18.14,28.68 15.77,28.68 v2(15.72,28.63)
  BOTTOM w0.076: UC1.AJ8 146.4,67.24 v2(146.4,67.49)
  BOTTOM w0.102: v2(162.43,64.86) 162.94,64.86 v1(162.99,64.91)
ACAV_DOCK_SRC#: length 200.6
  TOP w0.254: v2(10.67,23.96) 10.72,23.91 10.72,22.5 PR846.2 9.92,21.7 9.92,20.64 9.58,20.29 7.48,20.29 v1(6.85,20.93) 6.4,21.37 PR847.1
  IN3 w0.122: v2(10.67,23.96) 10.03,23.96 9.41,24.57 9.41,29.24 6.96,31.69 5.78,31.69 3.71,33.76 3.71,34.96 4.64,35.89 4.64,41.2 5.75,42.31 7.63,42.31 7.82,42.12 9.08,42.12 9.27,42.31 10.89,42.31 11.62,43.04 15.72,43.04 16.34,42.41 20.66,42.41 21.43,43.18 22.4,43.18 23,43.77 25.17,43.77 25.61,44.22 28.09,44.22 29.46,45.59 30.3,45.59 31.61,46.9 33.48,46.9 38.83,52.26 41.47,52.26 41.57,52.36 43.38,52.36 43.73,52.01 46.09,52.01 47.14,50.96 48.76,50.96 49.3,51.5 49.96,51.5 50.36,51.1 50.79,51.1 51.3,51.61 51.3,53.49 54.2,56.39 54.2,61.65 52.89,62.96 52.89,77.17 53.9,78.18 53.9,79.71 59.96,85.76 62.2,85.76 65.14,88.7 68.45,88.7 75.69,95.95 94.11,95.95 95.86,97.7 95.86,98.46 102.51,105.11 102.51,105.63 104.72,107.84 104.72,109.1 105.7,110.08 108.06,110.08 109.53,111.55 110.79,111.55 112.07,110.27 113.02,110.27 113.4,110.65 115.88,110.65 116.19,110.97 v2(122.8,110.97)
  BOTTOM w0.102: JDOCK1.42 123.45,109.62 123.3,109.77 123.3,110.46 v2(122.8,110.97)
ACAV_IN: length 352.6
  TOP w0.102: v5(60.34,37.55) 59.98,37.19 v2(59.64,37.19)
  TOP w0.254: U38.A64 18.85,10.83 v2(18.04,10.01) ; PR872.1 134.36,4.15 v2(134.6,3.91) ; v2(9,21.58) 8.42,21.58 8.18,21.82 PR859.1 ; v2(46.85,3.89) 47.27,3.47 PR717.1 47.54,3.7 47.78,3.94 47.99,3.94 48.5,4.44 PR747.2 ; v2(92.8,88.11) 93.07,88.38 PQ712.5
  IN1 w0.254: v2(59.64,37.19) 59.64,38.14 57.94,39.84 57.94,47.42 60.12,49.6 60.12,55.83 61.19,56.9 61.19,64.11 63.16,66.08 63.16,72.82 62.03,73.95 61.27,73.95 60.43,74.79 60.43,76.23 60.92,76.72 62.72,76.72 67.57,81.57 67.57,82.23 69.81,84.47 70.86,84.47 71.44,85.05 71.44,86.56 72,87.12 85.17,87.12 85.98,87.93 88.32,87.93 88.99,87.26 92.34,87.26 92.8,87.72 v2(92.8,88.11)
  IN3 w0.254: v2(18.04,10.01) 18.74,10.01 19.79,8.97 21.01,8.97 21.9,8.08 21.9,7.52 22.78,6.63 23.37,6.63 23.72,6.27 23.72,5.99 23.51,5.78 23.51,5.4 23.9,5 27.84,5 27.97,5.13 30.88,5.13 31.36,4.65 40.76,4.65 41.07,4.34 44.93,4.34 45.21,4.62 46.11,4.62 v2(46.85,3.89)
  IN4 w0.254: v2(84.9,6.72) 83.74,7.87 77.16,7.87 75.1,5.82 71.24,5.82 68.98,3.56 60.08,3.56 59.31,4.32 55.44,4.32 54.73,3.61 52.96,3.61 52.25,4.32 47.29,4.32 v2(46.85,3.89) ; v2(9,21.58) 9.69,21.58 10.52,20.75 10.52,19.71 9.91,19.1 9.91,15.67 11.88,13.69 11.88,9.97 12.6,9.26 13.43,9.26 14.71,7.98 15.11,7.98 16.31,9.17 16.31,9.66 16.98,10.34 17.71,10.34 v2(18.04,10.01)
  BOTTOM w0.254: PR746.1 50.32,4.65 49.64,3.97 46.94,3.97 v2(46.85,3.89) ; v2(84.9,6.72) 84.9,4.43 86.12,3.21 113.35,3.21 113.72,3.58 134.27,3.58 v2(134.6,3.91) 134.6,3.92 135.12,4.43 135.12,6.58 136.49,7.95 136.49,11.61 134.44,13.66 131.49,13.66 127.62,17.53 127.62,20.54 127.94,20.86 127.94,22.41 128.46,22.92 128.46,24.51 127.32,25.65 127.32,27.74 127.57,27.99 127.57,28.65 127.17,29.05 127.17,29.41 126.57,30.01 126.57,30.93 126.19,31.31 126.19,36.35 125.67,36.86 121.47,36.86 121.34,36.73 60.59,36.73 60.12,37.19 v2(59.64,37.19)
ACAV_IN#: length 11.1
  TOP w0.102: PQ825.1 137.01,4.16 v1(137.64,3.53)
  TOP w0.254: PR820.2 v2(139.43,13.37)
  BOTTOM w0.254: v2(138.23,4.93) 138.23,6.93 138.63,7.34 138.63,12.57 v2(139.43,13.37)
ACAV_IN_NB: length 192.4
  TOP w0.102: v2(60.88,67.88) 62.57,69.57 62.57,71.96 v5(62.98,72.36) 64.63,72.36 70.55,78.28 75.2,78.28 77.04,80.12 78.33,80.12 78.8,79.65 80.32,79.65 80.73,79.23 81.44,79.23 83.43,77.25 v2(83.68,77.25) ; U38.B20 28.72,11.58 v2(28.63,11.48)
  TOP w0.254: v2(4.22,34.14) 4.23,34.15 PR855.2
  IN4 w0.084: v2(60.88,67.88) 60.49,67.49 60.49,65.75 60.05,65.31 60.05,48.55 59.99,48.49 59.99,46.42 59.71,46.14 56.26,46.14 54.09,43.97 54.09,41.12 53.82,40.84 53.75,40.84 47.2,34.29 47.2,31.16 44.31,28.27 42.24,28.27 41.7,28.81 36.6,28.81 36.13,28.34 33.89,28.34 33.19,27.64 29.69,27.64 29.5,27.83 25.4,27.83 23.81,26.24 13.82,26.24 13.24,26.81 13.24,29.51 11.95,30.8 9.71,30.8 9.15,31.36 8.24,31.36 6.5,33.1 5.26,33.1 v2(4.22,34.14) 3.19,34.14 1.52,32.46 1.52,31.65 4.02,29.16 8.74,29.16 9.52,28.38 9.52,22.16 10.82,20.87 10.82,17.9 11.16,17.55 11.16,15.28 12.18,14.26 12.18,10.09 12.72,9.55 15.06,9.55 16.22,10.72 18.66,10.72 19.67,11.73 22.07,11.73 22.46,12.12 26.62,12.12 27.31,12.8 28.68,12.8 28.83,12.64 28.83,11.69 v2(28.63,11.48)
  BOTTOM w0.254: PR741.2 94.23,80.24 94.04,80.05 93.11,80.05 92.25,79.19 92.25,78.63 91.54,77.91 90.79,77.91 90.37,78.33 86.6,78.33 85.84,77.57 84,77.57 v2(83.68,77.25)
ACAVDK_SRC: length 2.2
  TOP w0.254: PU800.4 6.28,23.22 PR847.2
ACAVIN: length 2.1
  TOP w0.254: PR859.2 8.28,23.2 PU800.8
ALS_INT#: length 1.9
  TOP w0.102: R281.2 17.45,41.38 17.26,41.19 17.26,40.5 17.43,40.33 U37.A46
ALW_PWRGD_3V_5V: length 267
  TOP w0.102: v2(20.04,7.99) 20.04,8.02 20.45,8.43 20.59,8.43 20.94,8.78 U38.A1
  TOP w0.254: v2(202.39,45.87) v1(202.39,46.71) 202.13,46.96 PR108.1
  IN1 w0.084: v2(207.32,4.74) 208.8,6.22 208.8,9.98 209.2,10.38 209.2,25.23 207.04,27.4 207.04,28.76 203.56,32.24 203.56,35.03 202.35,36.23 202.35,45.84 v2(202.39,45.87)
  IN2 w0.122: v2(20.04,7.99) 20.04,8.34 21.14,9.44 28.42,9.44 30.39,7.47 32.07,7.47 32.45,7.09 34.6,7.09 34.85,7.34 34.85,7.78 35.29,8.23 36.66,8.23 40.28,11.84 46.16,11.84 47.01,12.69 47.01,13.7 49.84,16.53 49.84,17.12 51.44,18.72 54.28,18.72 56.14,16.86 58.34,16.86 59.18,17.7 69.28,17.7 69.75,18.17 122.61,18.17 123.49,19.05 125.61,19.05 125.92,19.35 130.2,19.35 130.98,18.58 130.98,17.68 131.48,17.17 133.77,17.17 134.15,16.79 134.5,16.79 135.1,17.39 179.73,17.39 180.63,16.49 180.63,12.19 179.03,10.6 179.03,9.83 177.75,8.54 177.75,2.81 178.76,1.8 201.67,1.8 203.1,3.23 205.8,3.23 v2(207.32,4.74)
ALWON: length 211.5
  TOP w0.102: v2(18.13,12.33) 18.62,12.83 U38.A60
  TOP w0.254: PR113.2 190.83,47.08 v1(190.39,46.64) 190.11,46.35 v2(190.11,45.76)
  IN3 w0.122: v2(188.03,34.58) 186.3,34.58 185.38,35.5 137.53,35.5 134.02,31.99 134.02,30.65 132.05,28.68 131.95,28.68 130.77,27.5 130.48,27.5 129.23,26.25 127.45,26.25 126.27,25.06 122.83,25.06 121.24,26.65 121.24,29.61 116.94,33.91 62.96,33.91 62.17,33.12 57.18,33.12 55.28,31.22 52.29,31.22 50.64,29.57 49.57,29.57 46.8,26.79 44.21,26.79 42.76,25.34 42.76,24.39 40.36,21.99 40.36,16.19 39.28,15.11 36.75,15.11 35.99,14.35 34.95,14.35 33.44,12.84 27.53,12.84 26.87,13.5 23.79,13.5 23.73,13.44 22.61,13.44 22.35,13.18 22.35,12.06 22.03,11.74 20.04,11.74 19.45,12.33 v2(18.13,12.33)
  IN4 w0.084: v2(188.03,34.58) 188.03,34.77 190.11,36.85 v2(190.11,45.76)
AUD_HP_NB_SENSE: length 376
  TOP w0.254: v2(280.66,23.41) C137.1 277.86,23.55 Q20.5 ; v2(20.03,41.08) 19.93,40.98 U37.A41
  IN3 w0.254: v2(131.18,33.91) 136.06,38.79 167.85,38.79 175.74,46.69 175.74,61.24 177.8,63.3 177.8,67.4 177.26,67.94 v2(177.09,67.94)
  IN4 w0.254: v2(280.66,23.41) 280.66,23.72 281.41,24.47 281.41,27.89 280.49,28.8 280.49,31.22 279.02,32.69 279.02,39.98 279.43,40.39 279.43,41.5 276.24,44.69 276.24,45.64 273.78,48.1 v2(273.78,48.19) 273.78,49.94 268.17,55.55 268.17,71.03 265.85,73.35 265.85,73.93 265.18,74.6 262.89,74.6 262.49,74.2 256.98,74.2 255.2,75.98 246.75,75.98 246.3,76.43 244.8,76.43 243.97,77.26 241.19,77.26 240.48,77.96 240.06,77.96 236.3,81.73 233.99,81.73 232.54,83.17 226.23,83.17 224.81,84.6 218.35,84.6 217.91,84.16 215.68,84.16 213.58,82.06 213.58,79.65 210.88,76.95 208.78,76.95 206.71,74.88 206.05,74.88 205.35,74.18 204.81,74.18 203.05,72.41 198.16,72.41 197.42,71.67 197.42,71.01 197.72,70.71 197.72,70.29 197.39,69.96 194.84,69.96 194.71,70.09 190.61,70.09 189.89,70.8 180.6,70.8 179.54,69.74 178.7,69.74 177.26,68.29 177.26,68.1 v2(177.09,67.94)
  BOTTOM w0.102: v2(20.03,41.08) 20.27,40.84 20.66,40.84 21.6,39.9 25.19,39.9 28.63,43.34 29.49,43.34 31.62,45.48 33.27,45.48 37.84,50.05 38.95,50.05 40.64,51.73 46.21,51.73 47.36,50.59 48.57,50.59 49.68,49.48 51.52,49.48 51.94,49.06 51.94,47.7 53.22,46.42 57.47,46.42 58.56,45.33 65.84,45.33 66.54,44.63 124.62,44.63 131.18,38.07 v2(131.18,33.91)
  BOTTOM w0.254: JHP1.6 274.34,55.47 273.89,55.02 273.89,53.97 274.07,53.8 D31.3 274.07,50.82 274.63,50.27 R481.1 274.57,49.77 273.78,48.98 v2(273.78,48.19) 273.44,48.19 C408.1
AUD_HP_OUT_L: length 10.1
  TOP w0.381: v2(270.28,45.22) v1(271.39,44.12) 271.96,43.55 271.96,41.11 R162.2
  BOTTOM w0.381: L51.2 273.42,45.73 272.91,46.24 271.3,46.24 v2(270.28,45.22)
AUD_HP_OUT_L1: length 29.8
  IN1 w0.381: JHP1.1 270.59,64.98 270.22,64.6 270.22,55.78 271.43,54.57 277.41,54.57 v2(277.95,54.03)
  BOTTOM w0.381: L51.1 275.57,46.06 276.31,46.81 276.31,47.35 278.73,49.76 C442.1 278.99,51.03 278.45,51.57 D32.3 278.45,53.53 v2(277.95,54.03)
AUD_HP_OUT_R: length 13.7
  TOP w0.381: R166.2 273.08,40.88 273.08,43.92 271.12,45.87 v1(271.12,46.29) 271.12,47.78 269.79,49.11 269.79,50.41 269.93,50.55 269.93,51.31 270.78,52.16 L52.2
AUD_HP_OUT_R1: length 4.4
  TOP w0.102: v1(272.17,53.47) 272.17,53.19 272.57,52.79
  TOP w1.016: JHP1.2 276.66,54.33 276.66,53.06 276.16,52.56
AUD_NB_MUTE#: length 365.1
  TOP w0.102: v2(269.34,22.12) 269.23,22.01 R220.2 ; v2(203.64,45.72) 205.64,47.71 206.91,47.71 207.38,48.18 v2(207.65,48.18) ; U37.A39 20.93,40.31 21.34,40.72 v2(21.34,40.86)
  TOP w0.254: U17.47 268.6,31.57 C410.1 267.81,29.7 R150.2 267.83,29.7 v2(268.66,29.7)
  IN2 w0.122: v2(268.66,29.7) 269.27,29.1 269.27,27.77 268.88,27.39 268.25,27.39 267.61,26.76 267.61,23.79 269.28,22.12 v2(269.34,22.12)
  IN3 w0.122: v2(207.65,48.18) 207.65,48.26 207.24,48.67 207.24,51.14 207.63,51.54 207.63,55.66 206.87,56.43 206.04,56.43 205.68,56.79 205.68,59.4 206.65,60.38 206.65,64.39 206.21,64.83 206.21,68.06 209.59,71.44 212.23,71.44 213.04,72.25 213.04,76.46 214.8,78.21 218.65,78.21 219.24,77.63 222.87,77.63 224.55,79.31 225.75,79.31 226.33,79.9 235.7,79.9 237.48,78.12 242.62,78.12 245.49,75.25 246.75,75.25 247.75,74.25 255.28,74.25 256.65,72.88 258.54,72.88 259.97,71.44 266.14,71.44 266.56,71.02 266.56,47.47 267.91,46.13 267.91,43.71 269.63,41.98 269.63,30.45 268.88,29.7 v2(268.66,29.7) ; v2(203.64,45.72) 203.64,44.69 200.75,41.8 192.37,41.8 189.58,39.01 188.04,39.01 186.98,37.96 136.64,37.96 131.41,32.73 v2(131.41,31.81)
  BOTTOM w0.102: v2(21.34,40.86) 21.9,40.3 v1(25.08,40.3) 25.26,40.3 28.54,43.57 29.39,43.57 31.53,45.71 33.18,45.71 39.43,51.96 46.31,51.96 47.46,50.81 48.66,50.81 49.77,49.71 51.62,49.71 52.16,49.16 52.16,47.79 53.31,46.65 57.56,46.65 58.66,45.55 66.76,45.55 67.46,44.86 124.74,44.86 130.45,39.14 130.45,39.12 131.6,37.98 131.6,32.01 v2(131.41,31.81)
AUD_OUT_L: length 2.5
  TOP w0.254: R162.1 272.44,39.41 272.08,39.05 v1(272.08,38.58) U17.33
AUD_OUT_R: length 2.7
  TOP w0.254: U17.32 272.58,38.86 273.33,39.61 R166.1
AUD_PC_BEEP: length 6.7
  TOP w0.254: U17.12 276.08,29.93 276.49,29.51 276.49,27.66 v1(276.35,27.52) 276.74,27.13 276.74,25.73 C146.2 C145.2
AUD_SENSE_A: length 4.1
  TOP w0.102: v1(276.87,28.82) 277.06,28.63 R152.1 277.8,29.01 277.5,29.31 277.5,30.89 277.31,31.07 U17.13
AUD_SENSE_B: length 5.3
  TOP w0.102: U17.14 277.49,31.57 277.7,31.35 277.7,30.45 v1(278.31,29.84) 278.69,29.46 R156.1 278.8,28.74 R157.1
AUX_EN_WOWL: length 238.7
  TOP w0.102: v2(16.99,31.46) 16.88,31.46 16.45,31.02 U37.B67 ; R51.2 14.38,27.1 14.68,27.41 15,27.41 15.28,27.69 15.28,28.27 v2(14.93,28.63) ; U3.5 203.55,24.57 203.75,24.37 203.75,23.79 204.33,23.2 204.33,21.89 203.78,21.35 v1(202.53,21.35) 201.88,21.35 201.32,20.79 v2(200.83,20.79)
  IN1 w0.084: v2(195.05,16.15) 195.05,15.63 194.84,15.43 191.44,15.43 189.64,17.23 170.27,17.23 169.42,18.08 134.98,18.08 132.66,20.4 130.43,20.4 v2(129.69,21.13)
  IN4 w0.084: v2(200.83,20.79) 200.83,20.38 197.08,16.64 195.53,16.64 v2(195.05,16.15)
  BOTTOM w0.102: v2(129.69,21.13) 130.39,21.83 130.39,23.08 129.39,24.09 129.39,24.94 128.92,25.41 128.92,27.32 128.52,27.71 128.52,28.99 128.09,29.43 128.09,29.79 127.48,30.39 127.48,32.48 127.83,32.83 127.83,36.65 126.45,38.02 120.79,38.02 120.64,37.87 61.06,37.87 60.48,38.46 59.09,38.46 58.76,38.79 55.06,38.79 54.11,39.74 52.61,39.74 52.16,40.18 48.75,40.18 46.35,37.79 43.74,37.79 41.93,35.98 35.14,35.98 34.58,35.42 32.71,35.42 29.68,32.39 29.68,27.69 30.3,27.07 30.3,25.79 29.13,24.61 28.81,24.61 28.52,24.32 25.28,24.32 24.73,24.87 22.25,24.87 21.83,25.28 21.43,25.28 20.93,25.78 18.04,25.78 17.26,26.55 14.61,26.55 14.36,26.79 14.36,28.13 14.86,28.63 v2(14.93,28.63) 15.08,28.77 15.08,29.86 16.24,31.03 16.54,31.03 16.97,31.46 v2(16.99,31.46)
B-RAMP: length 2.8
  TOP w0.203: v2(88.95,70.36) 88.95,70.46 89.25,70.76 PU500.11
  TOP w0.254: v2(88.95,70.36) 88.95,69.89 PR502.1
  BOTTOM w0.254: PR507.2 88.95,70.75 v2(88.95,70.36)
BAT1_LED#: length 156.7
  TOP w0.102: v2(106.02,102.44) 106.02,104.52 104.97,105.57 v1(104.97,105.85) 104.97,107.17 105.25,107.45 105.25,108.75 106.13,109.64 v2(110.35,109.64) 110.86,109.64 110.97,109.53 Q23.1 ; R433.1 113.32,111.42 v2(113.13,111.23) ; v2(16.31,32.52) U37.B64
  IN1 w0.084: v2(110.35,109.64) 111.94,111.23 v2(113.13,111.23)
  IN3 w0.122: v2(16.31,32.52) 15.58,33.25 15.58,38.48 16.29,39.19 16.91,39.19 17.17,39.45 17.91,39.45 18.09,39.62 19.95,39.62 20.4,40.06 24.28,40.06 25.36,41.14 27.14,41.14 30,44 30.51,44 32.05,45.54 34.07,45.54 37.6,49.07 52.71,49.07 55.08,51.45 55.08,64.61 56.85,66.37 56.85,70.92 57.25,71.32 57.25,75.55 57.84,76.14 57.84,80.34 64.87,87.37 69.54,87.37 74.98,92.81 77.57,92.81 79.33,94.57 94.78,94.57 97.22,97 99.99,97 105.43,102.44 v2(106.02,102.44)
BAT1_LED#_Q: length 1.6
  TOP w0.102: R431.1 110.86,110.46 110.97,110.58 Q23.6
BAT2_LED#: length 147.9
  TOP w0.102: v2(20.57,28.32) 20.43,28.47 U37.A9 ; Q23.4 112.27,111.47 112.03,111.7 110.27,111.7 R429.1 109.49,110.92 108.17,110.92 v2(107.94,110.69)
  IN3 w0.122: v2(20.57,28.32) 20.78,28.53 23.8,28.53 24.36,27.97 26.08,27.97 27.17,29.06 27.65,29.06 28.86,30.27 28.86,31.14 29.89,32.17 31.83,32.17 32.33,32.67 35.84,32.67 39.18,36.01 44.76,36.01 45.04,35.72 45.28,35.72 46.03,36.47 46.03,37.35 49.3,40.62 49.3,41.93 49.84,42.46 56.29,42.46 57.79,43.95 57.79,46 61.52,49.74 61.52,61.77 62.88,63.13 63.76,63.13 65.04,64.4 65.04,74.84 68.62,78.42 69.94,78.42 75.26,83.74 75.26,84.63 76.03,85.41 81.98,85.41 v2(82.49,84.9)
  BOTTOM w0.102: v2(82.49,84.9) 82.49,87.36 85.4,90.27 86.42,90.27 88.7,92.55 88.7,93.19 92.06,96.56 92.06,96.94 95.12,100 97.71,100 v1(101.01,103.29) 105.23,107.52 105.23,108.61 106.39,109.77 107.01,109.77 v2(107.94,110.69)
BAT2_LED#_Q: length 3.9
  TOP w0.102: v1(113.26,108.57) 113.26,108.58 112.58,109.26 Q23.3 112.27,110.23 112.57,110.53 R427.1
