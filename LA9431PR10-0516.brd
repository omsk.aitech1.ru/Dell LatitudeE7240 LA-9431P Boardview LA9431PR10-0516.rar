# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDI2_LANE_N0: length 71.8
  TOP w0.102: v2(119.44,88.36) 119.56,88.48 119.56,88.84 119.75,89.03 123.46,89.03 126.63,92.2 128.36,92.2 132.19,96.04 135.48,96.04 135.73,96.28 144.28,96.28 145.3,97.29 151.5,97.29 151.9,97.7 162.62,97.7 167.79,92.53 171.97,92.53 174.93,89.57 174.93,89.13 175.14,88.92 U19.3
  BOTTOM w0.076: UC1.C51 120.07,81.79 119.97,81.94 119.93,82.09 119.93,82.28 119.94,82.31 119.99,82.43 119.99,82.54 119.93,82.7 119.93,83.15 120.35,83.57 120.35,84.91 120.41,84.98 120.41,85.45 120.4,85.46 120.4,85.55 120.38,85.56 120.38,85.57
  BOTTOM w0.102: v2(119.44,88.36) 119.44,87.48 120.14,86.78 120.14,85.88 120.38,85.63 120.38,85.57
DDI2_LANE_N1: length 70.3
  TOP w0.102: U19.6 173.64,89.73 171.53,91.83 167.37,91.83 162.76,96.44 159.55,96.44 159.41,96.58 157.91,96.58 157.56,96.94 153.14,96.94 152.18,95.99 150.99,95.99 150.55,96.43 145.92,96.43 145.07,95.58 136.07,95.58 135.81,95.33 133.58,95.33 126.11,87.86 v3(124.74,87.86) 121.14,87.86 119.84,86.55 119.09,86.55 118.54,86 118.54,85.57 118.98,85.13 v2(119.54,85.13)
  BOTTOM w0.076: UC1.C53 118.74,81.78 118.74,82.02 118.72,82.04 118.72,84.54 118.86,84.68 118.86,84.85 118.87,84.86 118.87,85 119.01,85.13 v2(119.54,85.13)
DDI2_LANE_N2: length 65.1
  TOP w0.102: U19.8 172.64,89.74 171.24,91.13 167.06,91.13 162.48,95.71 159.27,95.71 159.09,95.88 157.27,95.88 156.95,96.2 153.4,96.2 152.49,95.29 150.7,95.29 150.37,95.62 146.28,95.62 145.54,94.88 v3(138.66,94.88) 136.55,94.88 136.23,94.56 134.9,94.56 126.94,86.6 122.45,86.6 122.31,86.75 v2(122.31,87.1)
  BOTTOM w0.076: 122.31,85.57 122.31,85.51 121.79,85 121.79,83.51 121.22,82.94 121.22,81.98 121.52,81.69 UC1.C49
  BOTTOM w0.102: 122.31,85.57 v2(122.31,87.1)
DDI2_LANE_N3: length 62.9
  TOP w0.102: v2(119.94,84.68) 120.84,84.68 122.05,85.89 127.23,85.89 135.18,93.84 136.65,93.84 136.83,94.02 140.39,94.02 140.55,94.18 146.32,94.18 147,94.87 150.13,94.87 150.41,94.59 152.83,94.59 153.36,95.12 158.6,95.12 159,94.72 v3(160.45,94.72) 162.08,94.72 166.36,90.44 170.94,90.44 171.64,89.74 U19.10
  BOTTOM w0.076: v2(119.94,84.68) 119.75,84.49 119.3,84.49 119.08,84.26 119.08,83.44 119.36,83.16 119.36,82.8 119.22,82.65 119.07,82.65 119.01,82.71 UC1.A53
DDI2_LANE_P0: length 71.8
  TOP w0.102: v2(120.02,88.36) 119.77,88.61 119.77,88.75 119.84,88.81 123.55,88.81 126.72,91.99 128.45,91.99 132.28,95.82 135.57,95.82 135.81,96.06 144.37,96.06 145.39,97.08 151.59,97.08 151.99,97.48 162.53,97.48 167.7,92.32 171.88,92.32 174.71,89.48 174.71,89 174.64,88.92 U19.4
  BOTTOM w0.076: UC1.C50 120.68,81.63 120.51,81.81 120.33,81.81 120.13,82.01 120.1,82.12 120.1,82.25 120.12,82.31 120.13,82.32 120.16,82.4 120.16,82.62 120.1,82.74 120.1,83.08 120.51,83.5 120.51,84.81 120.6,84.9 120.6,85.57
  BOTTOM w0.102: v2(120.02,88.36) 119.65,87.99 119.65,87.57 120.36,86.87 120.36,85.97 120.6,85.72 120.6,85.57
DDI2_LANE_P1: length 70.1
  TOP w0.102: v2(119.54,85.72) 119.54,85.71 119.18,85.35 119.07,85.35 118.76,85.66 118.76,85.91 119.18,86.33 119.93,86.33 121.23,87.64 124.46,87.64 124.47,87.63 125.01,87.63 125.02,87.64 126.2,87.64 133.66,95.11 135.9,95.11 136.16,95.36 145.16,95.36 146.01,96.21 150.46,96.21 150.9,95.77 152.27,95.77 153.23,96.72 157.47,96.72 157.82,96.37 159.32,96.37 159.46,96.23 162.67,96.23 167.28,91.62 171.45,91.62 173.42,89.64 173.42,89.27 173.34,89.19 173.22,89.19 173.14,89.11 U19.7
  BOTTOM w0.076: UC1.B54 118.27,81.84 118.16,81.95 118.16,82.08 118.22,82.14 118.48,82.14 118.53,82.19 118.53,84.62 118.67,84.76 118.67,84.85 118.66,84.86 118.66,85.09 118.92,85.35 119.17,85.35 119.39,85.57
  BOTTOM w0.102: 119.39,85.57 v2(119.54,85.72)
DDI2_LANE_P2: length 65.1
  TOP w0.102: v2(121.72,87.1) 122.09,86.73 122.09,86.66 122.36,86.39 127.03,86.39 134.99,94.35 136.32,94.35 136.64,94.67 138.38,94.67 138.39,94.65 138.92,94.65 138.94,94.67 145.63,94.67 146.37,95.4 150.28,95.4 150.61,95.07 152.58,95.07 153.49,95.99 156.86,95.99 157.18,95.67 159,95.67 159.18,95.49 162.4,95.49 166.97,90.92 171.16,90.92 172.42,89.65 172.42,89.29 172.14,89 U19.9
  BOTTOM w0.076: 122.09,85.57 122.09,85.56 121.6,85.07 121.6,83.58 121.03,83.01 121.03,81.92 UC1.B50
  BOTTOM w0.102: 122.09,85.57 122.09,86.73 v2(121.72,87.1)
DDI2_LANE_P3: length 62.9
  TOP w0.102: v2(119.94,84.1) 120.31,84.47 120.93,84.47 122.14,85.67 127.32,85.67 135.27,93.62 136.74,93.62 136.92,93.8 140.47,93.8 140.64,93.97 146.41,93.97 147.09,94.65 150.04,94.65 150.32,94.37 152.92,94.37 153.45,94.91 158.51,94.91 158.91,94.5 160.13,94.5 160.16,94.47 160.86,94.47 160.88,94.5 161.99,94.5 166.27,90.22 170.85,90.22 171.42,89.65 171.42,89.24 171.14,88.95 U19.11
  BOTTOM w0.076: v2(119.94,84.1) 119.71,84.33 119.37,84.33 119.24,84.2 119.24,83.51 119.53,83.23 119.53,82.73 119.01,82.21 UC1.B53
DDR3_DRAMRST#: length 94.2
  TOP w0.102: v2(74.92,22.33) 73.9,21.31 73.9,18.01 74.17,17.74 CD34.1 CD3.1 RC279.1 v1(76.38,16.67) v2(76.38,16.17)
  IN1 w0.084: v2(76.38,16.17) 76.63,15.91 76.82,15.91 77.71,15.02 81.5,15.02 81.94,15.47 85.04,15.47 86.06,14.45 113.91,14.45 114.7,15.24 118.77,15.24 120.43,13.58 137.91,13.58 138.89,14.55 v2(138.89,16)
  BOTTOM w0.102: JDIMM1.30 68.2,21.9 68.63,22.33 v2(74.92,22.33) ; JDIMM2.30 144.7,16.29 143.93,15.52 139.37,15.52 v2(138.89,16)
DDR3_DRAMRST#_CPU: length 116.9
  TOP w0.102: v2(79.96,48.03) v1(79.96,44.49) 79.96,41.75 79.67,41.46 RD3.2 78.16,18.07 77.57,18.66 RC279.2
  IN2 w0.089: 142.71,51.41 143.04,51.74 143.04,51.78 144.64,53.38 145.37,53.38 145.72,53.74 145.72,56.23 143.97,57.97 143.97,59.67 143.89,59.75 142.61,59.75 142.52,59.84 142.52,60.02 142.61,60.11 143.89,60.11 143.97,60.2 143.97,60.38 143.89,60.47 142.76,60.47 142.67,60.55 142.67,60.71 142.79,60.82 143.89,60.82 143.97,60.91 143.97,61.38 143.57,61.79 v2(143.04,61.79)
  IN2 w0.122: v2(79.96,48.03) 115.07,48.03 116.07,49.03 140.33,49.03 142.71,51.41
  BOTTOM w0.076: v2(143.04,61.79) 143.03,61.79 142.73,61.49 UC1.AV15
DDR_A_BS0: length 80.6
  IN4 w0.084: v2(130.86,58.33) 130.59,58.06 130.59,55.8 129.49,54.69 129.49,51.41
  IN4 w0.132: 129.49,51.41 129.49,51.24 129.33,51.08 129.33,39.6 121.12,31.4 118.7,31.4 117.21,29.9 117.21,27.31 116.46,26.56 103.88,26.56 103.75,26.69 103.75,30.25 103.65,30.35 103.32,30.35 103.22,30.25 103.22,26.69 103.09,26.56 102.63,26.56 101.61,27.57 101.61,30.15 100.31,31.45 96.8,31.45 96.26,30.91 96.26,29.44 v2(95.12,28.29)
  BOTTOM w0.076: v2(130.86,58.33) 129.97,59.22 129.97,61.63 130.38,62.04 UC1.AU35
  BOTTOM w0.17: JDIMM1.109 94.3,27.47 v2(95.12,28.29)
DDR_A_BS1: length 81.3
  IN4 w0.084: v2(130.86,58.89) 131.24,58.51 131.24,58.2 131.23,58.19 131.23,58.18 131.02,57.96 131,57.96 130.76,57.72 130.76,55.71 130.08,55.03 130.08,51.41
  IN4 w0.132: 130.08,51.41 130.08,51.17 129.71,50.81 129.71,39.44 121.28,31.01 119.14,31.01 118.38,30.25 118.38,27.32 117.23,26.17 102.47,26.17 101.22,27.41 101.22,29.99 100.15,31.07 96.96,31.07 96.65,30.75 96.65,23.74 95.6,22.69 95.6,21.92 v2(95.1,21.42)
  BOTTOM w0.076: v2(130.86,58.89) 130.13,59.62 130.13,61.19 UC1.AV35
  BOTTOM w0.17: JDIMM1.108 94,20.32 v2(95.1,21.42)
DDR_A_BS2: length 79.1
  IN4 w0.084: v2(126.1,59.92) 126.03,59.92 124.78,58.66 124.78,56.67 122.73,54.62 122.73,53.94 120.42,51.62 120.42,51.41
  IN4 w0.132: v2(82.9,29.82) 83.39,30.3 83.39,32.47 90.59,39.68 111.81,39.68 112.08,39.95 112.26,39.95 112.53,39.68 112.67,39.68 112.9,39.91 112.9,40.06 112.64,40.32 112.64,40.51 112.83,40.69 113.01,40.69 113.93,39.78 114.07,39.78 114.3,40.01 114.3,40.15 113.39,41.07 113.39,41.25 113.57,41.44 113.76,41.44 114.68,40.52 114.82,40.52 115.05,40.75 115.05,40.9 114.13,41.82 114.13,42 114.32,42.19 114.51,42.19 115.43,41.27 115.57,41.27 115.8,41.5 115.8,41.64 114.88,42.56 114.88,42.75 115.07,42.94 115.25,42.94 116.17,42.02 116.32,42.02 116.55,42.25 116.55,42.39 115.95,42.99 115.95,43.13 116.18,43.36 116.33,43.36 116.92,42.77 117.06,42.77 120.42,46.12 120.42,51.41
  BOTTOM w0.076: v2(126.1,59.92) 126.37,60.19 UC1.AY41
  BOTTOM w0.17: JDIMM1.79 85.3,27.44 82.93,29.82 v2(82.9,29.82)
DDR_A_CAS#: length 79.6
  IN4 w0.084: v2(130.85,61.84) 131.22,61.47 131.22,60.64 131.93,59.93 131.93,57.92 131.92,57.91 131.92,57.89 131.83,57.79 131.83,51.41
  IN4 w0.132: 131.83,51.41 131.83,50.03 131.26,49.46 131.26,42.48 131.39,42.34 131.85,42.34 131.98,42.21 131.98,39.52 123.38,30.92 123.38,30.68 123.56,30.5 123.56,30.31 119.12,25.87 116.24,23 98.07,23 97.93,23.14 97.93,23.53 98.06,23.67 99.25,23.67 99.35,23.77 99.35,24.09 99.25,24.19 98.06,24.19 97.93,24.33 97.93,24.59 98.06,24.72 98.96,24.72 99.06,24.82 99.06,25.15 98.96,25.25 98.06,25.25 97.93,25.38 97.93,25.65 98.06,25.78 98.5,25.78 98.63,25.91 98.63,26.18 98.5,26.31 98.06,26.31 97.93,26.44 97.93,26.97 97.63,27.27 97.63,27.73 v2(97.07,28.29)
  BOTTOM w0.076: v2(130.85,61.84) 131.15,62.14 UC1.AU34
  BOTTOM w0.17: JDIMM1.115 96.1,27.32 96.6,27.82 96.6,27.83 v2(97.07,28.29)
DDR_A_D0: length 62.5
  IN1 w0.084: v2(110.24,67.98) 109.71,67.45 109.44,67.45 107.67,65.68 100.74,65.68 99.08,64.01 99.08,55.24 100.53,53.78 100.53,40.06 100.41,39.94 100.1,39.94 100,39.84 100,39.7 100.1,39.6 100.5,39.6 100.6,39.5 100.6,39.35 100.5,39.25 99.95,39.25 99.85,39.15 99.85,39.01 99.95,38.91 100.5,38.91 100.6,38.81 100.6,38.67 100.5,38.57 99.95,38.57 99.85,38.48 99.85,38.34 99.95,38.24 100.5,38.24 100.6,38.14 100.6,38 100.5,37.9 99.95,37.9 99.85,37.81 99.85,37.67 99.95,37.57 100.5,37.57 100.6,37.47 100.6,37.33 100.5,37.23 100,37.23 99.9,37.14 99.9,37 100,36.9 100.5,36.9 100.6,36.8 100.6,36.66 100.5,36.56 100.06,36.56 99.97,36.48 99.97,36.31 100.06,36.23 100.47,36.23 100.6,36.1 100.6,35.92 100.47,35.79 100.03,35.79 99.95,35.71 99.95,27.79 100.21,27.53 v2(100.8,27.53)
  BOTTOM w0.076: v2(110.24,67.98) 110.81,67.41 112.26,67.41 112.39,67.54 UC1.AH63
  BOTTOM w0.102: JDIMM1.129 100.3,27.03 v2(100.8,27.53)
DDR_A_D1: length 63.4
  IN1 w0.084: v2(110.8,67.98) 110.8,67.55 110.4,67.15 109.68,67.15 107.91,65.38 100.87,65.38 99.38,63.89 99.38,55.36 100.9,53.84 100.9,35.55 100.82,35.46 100.35,35.46 100.25,35.36 100.25,35.22 100.35,35.13 100.82,35.13 100.9,35.04 100.9,34.87 100.82,34.79 100.35,34.79 100.25,34.69 100.25,34.55 100.35,34.46 100.82,34.46 100.9,34.37 100.9,34.2 100.82,34.12 100.35,34.12 100.25,34.02 100.25,33.88 100.35,33.78 100.82,33.78 100.9,33.7 100.9,33.53 100.82,33.45 100.39,33.45 100.3,33.37 100.3,33.2 100.39,33.11 100.82,33.11 100.9,33.03 100.9,32.86 100.82,32.78 100.39,32.78 100.3,32.7 100.3,32.53 100.39,32.44 100.82,32.44 100.9,32.36 100.9,32.19 100.82,32.11 100.39,32.11 100.3,32.02 100.3,31.86 100.39,31.77 100.82,31.77 100.9,31.69 100.9,31.52 100.82,31.44 100.39,31.44 100.3,31.35 100.3,31.19 100.39,31.1 100.76,31.1 100.88,30.99 100.88,30.82 100.76,30.71 100.42,30.71 100.29,30.58 100.29,29.08 100.42,28.96 100.7,28.96 v2(100.8,29.05)
  BOTTOM w0.076: UC1.AH62 113.09,67.54 112.89,67.74 112.72,67.83 112.45,67.83 112.19,67.57 111.21,67.57 v2(110.8,67.98)
  BOTTOM w0.102: v2(100.8,29.05) 101.23,28.62 101.23,27.35 100.9,27.02 JDIMM1.131
DDR_A_D2: length 61.5
  IN1 w0.084: v2(104.61,29.05) 105.01,29.45 105.01,30.33 104.31,31.03 104.31,41.87 104.4,41.96 104.54,41.96 104.62,42.04 104.62,42.21 104.54,42.29 104.4,42.29 104.31,42.38 104.31,42.54 104.4,42.63 104.89,42.63 104.99,42.73 104.99,42.87 104.89,42.96 104.41,42.96 104.31,43.06 104.31,43.2 104.41,43.3 104.91,43.3 105.01,43.4 105.01,43.54 104.91,43.63 104.41,43.63 104.31,43.73 104.31,43.87 104.41,43.97 104.91,43.97 105.01,44.07 105.01,44.21 104.91,44.3 104.41,44.3 104.31,44.4 104.31,44.54 104.41,44.64 104.91,44.64 105.01,44.74 105.01,44.88 104.91,44.98 104.41,44.98 104.31,45.07 104.31,45.21 104.41,45.31 104.91,45.31 105.01,45.41 105.01,45.55 104.91,45.65 104.4,45.65 104.31,45.73 104.31,45.9 104.4,45.98 104.91,45.98 105.01,46.08 105.01,46.22 104.91,46.32 104.4,46.32 104.31,46.4 104.31,46.57 104.4,46.65 104.91,46.65 105.01,46.75 105.01,46.89 104.91,46.99 104.4,46.99 104.31,47.07 104.31,47.24 104.4,47.32 104.91,47.32 105.01,47.42 105.01,47.56 104.91,47.66 104.4,47.66 104.31,47.74 104.31,47.91 104.4,47.99 104.91,47.99 105.01,48.09 105.01,48.23 104.91,48.33 104.4,48.33 104.31,48.41 104.31,48.58 104.4,48.66 104.91,48.66 105.01,48.76 105.01,48.9 104.91,49 104.4,49 104.31,49.08 104.31,49.25 104.4,49.33 104.91,49.33 105.01,49.43 105.01,49.57 104.91,49.67 104.4,49.67 104.31,49.75 104.31,49.92 104.4,50 104.91,50 105.01,50.1 105.01,50.24 104.91,50.34 104.4,50.34 104.31,50.42 104.31,50.59 104.4,50.68 104.91,50.68 105.01,50.77 105.01,50.91 104.91,51.01 104.4,51.01 104.31,51.09 104.31,54.67 105.06,55.42 105.06,56.74 107.8,59.47 107.8,59.92 107.54,60.17 107.54,60.56 107.76,60.78 107.76,61.64 110.24,64.11 v2(110.24,65.8)
  BOTTOM w0.076: UC1.AK63 112.52,66.06 112.25,66.06 112.01,65.81 110.25,65.81 v2(110.24,65.8)
  BOTTOM w0.102: v2(104.61,29.05) 103.9,28.34 JDIMM1.141
DDR_A_D3: length 62.2
  IN1 w0.084: v2(103.03,19.13) 103.72,19.83 103.72,27.89 104.19,28.35 104.19,30.73 104.01,30.91 104.01,31.6 103.93,31.68 103.37,31.68 103.29,31.77 103.29,31.93 103.37,32.02 103.93,32.02 104.01,32.1 104.01,32.27 103.93,32.35 103.37,32.35 103.29,32.44 103.29,32.6 103.37,32.69 103.93,32.69 104.01,32.77 104.01,32.94 103.93,33.02 103.37,33.02 103.29,33.11 103.29,33.27 103.37,33.36 103.93,33.36 104.01,33.44 104.01,33.61 103.93,33.69 103.37,33.69 103.29,33.78 103.29,33.94 103.37,34.03 103.93,34.03 104.01,34.11 104.01,34.28 103.93,34.36 103.37,34.36 103.29,34.45 103.29,34.62 103.37,34.7 103.93,34.7 104.01,34.78 104.01,34.95 103.93,35.03 103.58,35.03 103.48,35.13 103.48,35.27 103.58,35.37 103.93,35.37 104.01,35.45 104.01,56.92 107.03,59.93 107.03,60.51 107.46,60.95 107.46,61.76 109.25,63.55 v2(109.25,65.15)
  BOTTOM w0.076: 109.91,65.12 110.23,65.12 110.76,65.65 112.07,65.65 112.32,65.89 112.77,65.89 113.06,66.18 UC1.AK62
  BOTTOM w0.102: 109.91,65.12 109.28,65.12 v2(109.25,65.15) ; v2(103.03,19.13) 103.45,19.13 103.6,18.98 JDIMM1.140
DDR_A_D4: length 63.5
  IN1 w0.084: v2(101.14,19.13) 100.74,19.53 100.74,21.62 101.2,22.08 101.2,54.09 99.68,55.62 99.68,63.76 100.99,65.08 108.03,65.08 109.8,66.85 110.35,66.85 111.37,67.88 v2(111.37,67.98)
  BOTTOM w0.076: UC1.AH61 113.56,67.92 112.9,67.92 112.8,67.97 112.76,67.99 112.38,67.99 112.13,67.75 111.61,67.75 v2(111.37,67.98)
  BOTTOM w0.102: JDIMM1.132 101.2,19.08 v2(101.14,19.13)
DDR_A_D5: length 64.3
  IN1 w0.084: v2(111.13,66.54) 111.11,66.55 109.93,66.55 108.16,64.78 101.12,64.78 99.98,63.64 99.98,55.74 101.61,54.1 101.61,20.8 101.47,20.66 v2(101.14,20.66)
  BOTTOM w0.076: UC1.AH60 114.6,66.77 114.39,66.57 114.15,66.57 114.14,66.58 113.76,66.58 113.74,66.57 113.55,66.57 113.54,66.58 113.4,66.64 113.19,66.64 113.04,66.57 112.91,66.57 112.8,66.62 112.75,66.64 112.46,66.64 112.2,66.39 112.11,66.39 111.87,66.14 111.52,66.14 v2(111.13,66.54)
  BOTTOM w0.102: v2(101.14,20.66) 100.6,20.12 JDIMM1.130
DDR_A_D6: length 62.6
  IN1 w0.084: v2(110.65,66.18) 112.26,64.57 112.26,63.98 111.43,63.16 111.06,63.16 108.82,60.91 108.82,60.07 105.36,56.62 105.36,55.3 104.61,54.55 104.61,51.73 105.31,51.04 105.31,40.22 105.23,40.14 104.96,40.14 104.86,40.04 104.86,39.9 104.96,39.8 105.23,39.8 105.31,39.72 105.31,39.55 105.23,39.46 104.78,39.46 104.7,39.38 104.7,39.21 104.78,39.13 105.23,39.13 105.31,39.05 105.31,38.88 105.23,38.79 104.78,38.79 104.7,38.71 104.7,38.54 104.78,38.46 105.23,38.46 105.31,38.37 105.31,38.21 105.23,38.12 104.78,38.12 104.7,38.04 104.7,37.87 104.78,37.79 105.23,37.79 105.31,37.7 105.31,37.54 105.23,37.45 104.78,37.45 104.7,37.37 104.7,37.2 104.78,37.12 105.23,37.12 105.31,37.03 105.31,36.87 105.23,36.78 104.78,36.78 104.7,36.7 104.7,36.53 104.78,36.45 105.23,36.45 105.31,36.36 105.31,36.2 105.23,36.11 104.78,36.11 104.7,36.03 104.7,35.86 104.78,35.78 105.23,35.78 105.31,35.69 105.31,35.52 105.23,35.44 104.78,35.44 104.7,35.36 104.7,35.19 104.78,35.11 105.23,35.11 105.31,35.02 105.31,34.85 105.23,34.77 104.78,34.77 104.7,34.69 104.7,34.52 104.78,34.44 105.23,34.44 105.31,34.35 105.31,34.18 105.23,34.1 104.78,34.1 104.7,34.02 104.7,33.85 104.78,33.76 105.23,33.76 105.31,33.68 105.31,33.51 105.23,33.43 104.78,33.43 104.7,33.35 104.7,33.18 104.78,33.09 105.23,33.09 105.31,33.01 105.31,32.84 105.23,32.76 104.78,32.76 104.7,32.68 104.7,32.51 104.78,32.42 105.23,32.42 105.31,32.34 105.31,32.17 105.23,32.09 104.78,32.09 104.7,32 104.7,31.84 104.78,31.75 105.23,31.75 105.31,31.67 105.31,31.5 105.23,31.42 104.78,31.42 104.7,31.33 104.7,31.17 104.78,31.08 105.23,31.08 105.31,31 105.31,28.23 v2(104.61,27.53)
  BOTTOM w0.076: v2(110.65,66.18) 110.85,65.98 111.94,65.98 112.18,66.22 112.27,66.22 112.52,66.48 112.71,66.48 112.82,66.43 112.87,66.4 113.07,66.4 113.13,66.43 113.22,66.47 113.23,66.48 113.36,66.48 113.41,66.45 113.47,66.43 113.6,66.29 UC1.AK61
  BOTTOM w0.102: JDIMM1.143 104.5,27.42 v2(104.61,27.53)
DDR_A_D7: length 63.4
  IN1 w0.084: v2(103.03,20.66) 102.63,21.06 102.63,27.29 103.79,28.44 103.79,30.71 102.99,31.51 102.99,35.76 103.07,35.85 103.61,35.85 103.7,35.93 103.7,36.1 103.61,36.18 103.07,36.18 102.99,36.27 102.99,36.44 103.07,36.52 103.61,36.52 103.7,36.6 103.7,36.77 103.61,36.85 103.07,36.85 102.99,36.94 102.99,37.11 103.07,37.19 103.61,37.19 103.7,37.27 103.7,37.44 103.61,37.53 103.07,37.53 102.99,37.61 102.99,37.78 103.07,37.86 103.61,37.86 103.7,37.94 103.7,38.11 103.61,38.2 103.07,38.2 102.99,38.28 102.99,38.45 103.07,38.53 103.61,38.53 103.7,38.61 103.7,38.78 103.61,38.87 103.39,38.87 103.29,38.96 103.29,39.1 103.39,39.2 103.57,39.2 103.64,39.28 103.64,57.54 103.84,57.74 104.41,57.74 106.73,60.06 106.73,60.64 107.16,61.07 107.16,61.88 108.79,63.51 v2(108.79,64.74)
  BOTTOM w0.076: 109.91,64.74 110.09,64.74 110.83,65.48 112.14,65.48 112.39,65.73 112.84,65.73 113,65.89 113.42,65.89 113.54,66.02 113.81,66.02 113.83,66 114.07,66 114.36,66.29 UC1.AK60
  BOTTOM w0.102: JDIMM1.142 104.2,19.49 v2(103.03,20.66) ; 109.91,64.74 v2(108.79,64.74)
DDR_A_D8: length 84.1
  IN4 w0.084: v2(59.62,28.93) 59.87,28.93 60.02,29.08 60.02,33.88 62.94,36.81 63.06,36.81 63.2,36.66 63.34,36.66 63.44,36.76 63.44,36.9 63.29,37.04 63.29,37.16 63.41,37.28 63.53,37.28 63.75,37.06 63.87,37.06 63.99,37.18 63.99,37.3 63.77,37.52 63.77,37.64 63.89,37.75 64.01,37.75 64.23,37.53 64.34,37.53 64.46,37.65 64.46,37.77 64.24,37.99 64.24,38.11 64.36,38.23 64.48,38.23 64.7,38.01 64.82,38.01 64.94,38.13 64.94,38.25 64.72,38.47 64.72,38.58 64.84,38.7 64.95,38.7 65.18,38.48 65.29,38.48 67.11,40.3 67.11,40.42 66.63,40.89 66.63,41.03 66.73,41.13 66.87,41.13 67.35,40.65 67.46,40.65 67.58,40.77 67.58,40.89 67.12,41.35 67.12,41.49 67.22,41.59 67.36,41.59 67.82,41.13 67.94,41.13 68.06,41.25 68.06,41.36 67.61,41.81 67.61,41.95 67.71,42.05 67.84,42.05 68.29,41.6 68.41,41.6 68.53,41.72 68.53,41.84 68.08,42.29 68.08,42.43 68.18,42.53 68.32,42.53 68.77,42.08 68.89,42.08 82.15,55.34 98.16,55.34 101.17,58.34 104.13,58.34 108.43,62.63 109.13,62.63 109.27,62.78 109.94,62.78 v2(110,62.72)
  BOTTOM w0.076: UC1.AM63 112.52,64.98 112.37,64.98 112.37,64.98 111.03,64.98 110.41,64.36 110.41,63.64 110,63.22 v2(110,62.72)
  BOTTOM w0.102: JDIMM1.7 61.3,27.25 v2(59.62,28.93)
DDR_A_D9: length 85
  IN4 w0.084: v2(59.75,19.48) 60.89,19.48 61.01,19.6 61.01,19.77 60.89,19.9 60.23,19.9 60.13,20 60.13,20.13 60.23,20.23 60.83,20.23 60.92,20.32 60.92,32.83 82.53,54.44 98.54,54.44 101.54,57.44 104.51,57.44 107.87,60.8 108.33,60.8 108.59,61.06 108.59,61.52 v2(108.64,61.57)
  BOTTOM w0.076: UC1.AM62 113.06,65.11 112.77,65.4 112.52,65.4 112.27,65.14 110.96,65.14 110.25,64.43 110.25,63.91 109.91,63.56
  BOTTOM w0.102: 109.91,63.56 108.64,62.29 v2(108.64,61.57) ; v2(59.75,19.48) 60.4,18.82 JDIMM1.4
DDR_A_D10: length 83.6
  IN4 w0.084: v2(63.21,29.05) 63.61,29.05 63.74,28.93 63.74,27.38 63.84,27.28 63.99,27.28 64.09,27.38 64.09,33.07 67.57,36.54 67.57,36.66 67.35,36.88 67.35,37 67.46,37.12 67.58,37.12 67.8,36.9 67.92,36.9 68.04,37.02 68.04,37.14 67.82,37.36 67.82,37.48 67.94,37.6 68.06,37.6 68.28,37.37 68.4,37.37 68.51,37.49 68.51,37.61 68.29,37.83 68.29,37.95 68.41,38.07 68.53,38.07 68.75,37.85 68.87,37.85 68.99,37.97 68.99,38.09 68.77,38.31 68.77,38.43 68.89,38.54 69.01,38.54 69.23,38.32 69.35,38.32 69.46,38.44 69.46,38.56 69.24,38.78 69.24,38.9 69.36,39.02 69.48,39.02 69.7,38.8 69.82,38.8 69.94,38.92 69.94,39.04 69.72,39.26 69.72,39.37 69.84,39.49 69.95,39.49 70.18,39.27 70.29,39.27 70.41,39.39 70.41,39.51 70.19,39.73 70.19,39.85 70.31,39.97 70.43,39.97 70.65,39.75 70.77,39.75 70.89,39.87 70.89,39.98 70.67,40.21 70.67,40.32 70.79,40.44 70.9,40.44 71.12,40.22 71.24,40.22 71.36,40.34 71.36,40.46 71.14,40.68 71.14,40.8 71.26,40.92 71.38,40.92 71.6,40.7 71.72,40.7 71.84,40.81 71.84,40.93 71.62,41.15 71.62,41.27 71.73,41.39 71.85,41.39 72.07,41.17 72.19,41.17 72.31,41.29 72.31,41.41 72.09,41.63 72.09,41.75 72.21,41.87 72.33,41.87 72.55,41.64 72.67,41.64 72.79,41.76 72.79,41.88 72.56,42.1 72.56,42.22 72.68,42.34 72.8,42.34 73.02,42.12 73.14,42.12 73.26,42.24 73.26,42.36 73.04,42.58 73.04,42.7 83.19,52.84 99.2,52.84 101.61,55.26 105.1,55.26 110.34,60.5 v2(110.34,60.88)
  BOTTOM w0.076: UC1.AP63 112.23,63.75 110.34,61.86 v2(110.34,60.88)
  BOTTOM w0.102: JDIMM1.17 64.3,27.97 v2(63.21,29.05)
DDR_A_D11: length 84.3
  IN4 w0.084: v2(111.17,61.71) 111.17,60.88 105.25,54.96 101.74,54.96 99.32,52.55 83.31,52.55 76.37,45.6 76.37,45.48 76.59,45.26 76.59,45.14 76.47,45.03 76.35,45.03 76.13,45.25 76.01,45.25 75.89,45.13 75.89,45.01 76.12,44.79 76.12,44.67 76,44.55 75.88,44.55 75.66,44.77 75.54,44.77 75.42,44.65 75.42,44.54 75.64,44.31 75.64,44.2 75.52,44.08 75.4,44.08 75.18,44.3 75.06,44.3 74.95,44.18 74.95,44.06 75.17,43.84 75.17,43.72 75.05,43.6 74.93,43.6 74.71,43.82 74.59,43.82 74.47,43.7 74.47,43.59 74.69,43.36 74.69,43.25 74.57,43.13 74.46,43.13 74.23,43.35 74.12,43.35 74,43.23 74,43.11 74.22,42.89 74.22,42.77 74.1,42.65 73.98,42.65 73.76,42.87 73.64,42.87 73.52,42.76 73.52,42.64 73.74,42.42 73.74,42.3 64.39,32.94 64.39,25.14 64.5,25.02 64.66,25.02 64.76,24.92 64.76,24.79 64.66,24.69 64.22,24.69 64.14,24.6 64.14,24.32 64.22,24.24 64.37,24.24 64.47,24.14 64.47,24 64.37,23.9 64.22,23.9 64.14,23.82 64.14,19.81 v2(64.6,19.35)
  BOTTOM w0.076: v2(111.17,61.71) 111.17,62.46 112.17,63.46 112.77,63.46 113.06,63.75 UC1.AP62
  BOTTOM w0.102: v2(64.6,19.35) 64.6,19.35 JDIMM1.18
DDR_A_D12: length 85.6
  IN4 w0.084: v2(108.16,61.2) 107.84,61.2 104.38,57.74 101.41,57.74 98.41,54.74 82.4,54.74 60.62,32.96 60.62,23.02 60.53,22.93 60.35,22.93 60.25,22.83 60.25,22.69 60.35,22.6 60.53,22.6 60.62,22.51 60.62,22.34 60.53,22.26 60.22,22.26 60.13,22.18 60.13,22.01 60.22,21.93 60.53,21.93 60.62,21.84 60.62,21.23 60.38,21 v2(59.75,21)
  BOTTOM w0.076: UC1.AM61 113.82,65 113.42,65.4 113,65.4 112.84,65.56 112.46,65.56 112.2,65.31 110.89,65.31 110.08,64.5 110.08,64.19 109.91,64.01
  BOTTOM w0.102: v2(108.16,61.2) 108.16,62.27 109.91,64.01 ; v2(59.75,21) 61,19.74 JDIMM1.6
DDR_A_D13: length 86.3
  IN4 w0.084: v2(109.55,62.33) 108.55,62.33 104.26,58.04 101.29,58.04 98.29,55.04 82.28,55.04 63.41,36.18 63.3,36.18 63.15,36.33 63.01,36.33 62.91,36.23 62.91,36.09 63.06,35.94 63.06,35.82 62.94,35.71 62.82,35.71 62.6,35.93 62.48,35.93 62.36,35.81 62.36,35.69 62.58,35.47 62.58,35.35 62.43,35.2 62.32,35.2 62.1,35.42 61.98,35.42 61.86,35.3 61.86,35.18 62.08,34.96 62.08,34.84 61.96,34.73 61.84,34.73 61.62,34.95 61.5,34.95 61.38,34.83 61.38,34.71 61.6,34.49 61.6,34.37 61.49,34.25 61.37,34.25 61.15,34.47 61.03,34.47 60.91,34.35 60.91,34.23 61.13,34.01 61.13,33.9 61.01,33.78 60.89,33.78 60.67,34 60.55,34 60.43,33.88 60.43,33.76 60.66,33.54 60.66,33.42 60.32,33.08 60.32,24.74 60.19,24.61 59.75,24.61 59.62,24.74 v2(59.62,27.4)
  BOTTOM w0.076: UC1.AM60 114.6,64.34 114.39,64.14 113.55,64.14 113.54,64.15 113.45,64.19 113.4,64.21 113.19,64.21 113.04,64.14 112.91,64.14 112.75,64.21 112.18,64.21 110.68,62.71 110.51,62.71 110.13,62.33 109.91,62.33
  BOTTOM w0.102: v2(59.62,27.4) 60,27.4 60.7,26.71 JDIMM1.5 ; 109.91,62.33 v2(109.55,62.33)
DDR_A_D14: length 84.3
  IN4 w0.084: v2(63.21,27.53) 63.21,24.38 63.09,24.26 62.79,24.26 62.66,24.38 62.66,30.17 62.79,30.3 63.69,30.3 63.68,30.31 63.79,30.42 63.79,33.19 64.22,33.63 64.22,33.77 64.01,33.98 64.01,34.1 64.13,34.21 64.25,34.21 64.46,34 64.6,34 64.7,34.1 64.7,34.24 64.49,34.45 64.49,34.57 64.61,34.69 64.73,34.69 64.94,34.48 65.08,34.48 65.17,34.58 65.17,34.72 64.96,34.93 64.96,35.04 65.08,35.16 65.2,35.16 65.41,34.95 65.55,34.95 65.65,35.05 65.65,35.19 65.44,35.4 65.44,35.52 65.56,35.64 65.68,35.64 65.89,35.43 66.02,35.43 66.12,35.53 66.12,35.66 65.91,35.87 65.91,35.99 66.03,36.11 66.15,36.11 66.36,35.9 66.5,35.9 66.6,36 66.6,36.14 66.39,36.35 66.39,36.47 66.51,36.59 66.62,36.59 66.83,36.38 66.97,36.38 67.07,36.47 67.07,36.61 66.86,36.82 66.86,36.94 83.06,53.14 99.07,53.14 101.49,55.56 104.97,55.56 109.84,60.43 v2(109.84,60.53)
  BOTTOM w0.076: 109.91,61.66 112.29,64.05 112.71,64.05 112.82,64 112.87,63.97 113.07,63.97 113.13,64 113.13,64 113.22,64.04 113.23,64.05 113.36,64.05 113.47,64 113.71,63.75 UC1.AP61
  BOTTOM w0.102: v2(109.84,60.53) 109.84,61.6 109.91,61.66 ; JDIMM1.15 63.7,27.24 63.41,27.53 v2(63.21,27.53)
DDR_A_D15: length 85.1
  IN4 w0.084: v2(111.56,62.11) 111.56,60.85 105.38,54.66 101.86,54.66 99.45,52.25 83.44,52.25 79.23,48.03 79.23,47.92 79.45,47.69 79.45,47.55 79.35,47.45 79.21,47.45 78.99,47.68 78.87,47.68 78.75,47.56 78.75,47.44 78.98,47.22 78.98,47.08 78.88,46.98 78.74,46.98 78.51,47.2 78.4,47.2 78.28,47.09 78.28,46.97 78.5,46.74 78.5,46.6 78.4,46.51 78.26,46.51 78.04,46.73 77.92,46.73 77.8,46.61 77.8,46.49 78.03,46.27 78.03,46.13 77.93,46.03 77.79,46.03 77.56,46.26 77.45,46.26 77.33,46.14 77.33,46.02 77.55,45.79 77.55,45.65 77.45,45.56 77.32,45.56 77.09,45.78 76.97,45.78 76.85,45.66 76.85,45.54 77.08,45.32 77.08,45.18 64.69,32.79 64.69,26.94 64.77,26.86 65.08,26.86 65.18,26.76 65.18,26.62 65.08,26.52 64.8,26.52 64.69,26.42 64.69,26.27 64.8,26.16 65.17,26.16 65.29,26.03 65.29,21.57 v2(64.6,20.87)
  BOTTOM w0.076: v2(111.56,62.11) 111.56,62.62 112.24,63.3 112.84,63.3 113,63.46 113.42,63.46 113.43,63.47 113.82,63.47 113.83,63.46 114.07,63.46 114.14,63.53 114.37,63.53 UC1.AP60
  BOTTOM w0.102: JDIMM1.16 64,20.28 v2(64.6,20.87)
DDR_A_D16: length 53.6
  IN1 w0.084: v2(115.42,63.62) 115.79,63.25 115.79,61.93 114.62,60.76 113.89,60.76 108.64,55.51 108.64,39 110.39,37.25 110.39,34.58 110.3,34.5 109.35,34.5 109.27,34.41 109.27,34.24 109.35,34.16 110.3,34.16 110.39,34.08 110.39,33.91 110.3,33.83 109.35,33.83 109.27,33.74 109.27,33.57 109.35,33.49 110.3,33.49 110.39,33.41 110.39,33.24 110.3,33.15 109.35,33.15 109.27,33.07 109.27,30.6 109.64,30.24 109.64,28.81 109.58,28.75 109.37,28.75 109.27,28.65 109.27,28.51 109.37,28.42 109.58,28.42 109.64,28.36 109.64,25.39 109.51,25.26 109.07,25.26 108.94,25.39 v2(108.94,27.53)
  BOTTOM w0.076: v2(115.42,63.62) 115.74,63.95 UC1.AP58
  BOTTOM w0.102: JDIMM1.159 109.3,27.17 v2(108.94,27.53)
DDR_A_D17: length 53.4
  IN1 w0.084: v2(108.94,29.05) 109.25,29.05 109.34,29.15 109.34,30.1 109.24,30.2 109.04,30.2 108.94,30.3 108.94,34.72 109.04,34.81 109.73,34.81 109.83,34.91 109.83,35.05 109.73,35.15 109.04,35.15 108.94,35.25 108.94,35.39 109.04,35.49 109.98,35.49 110.09,35.59 110.09,35.72 109.98,35.82 109.04,35.82 108.94,35.92 108.94,36.06 109.04,36.16 109.99,36.16 110.09,36.25 110.09,36.39 109.99,36.49 108.8,36.49 108.7,36.59 108.7,36.73 108.8,36.83 109.99,36.83 110.09,36.92 110.09,37.06 109.99,37.16 108.44,37.16 108.34,37.26 108.34,37.4 108.44,37.5 109.37,37.5 109.47,37.6 109.47,37.74 109.37,37.85 108.44,37.85 108.34,37.95 108.34,38.15 108.42,38.23 108.64,38.23 108.72,38.31 108.72,38.48 108.64,38.57 108.42,38.57 108.34,38.65 108.34,55.64 113.64,60.93 114.55,60.93 115.42,61.8 v2(115.42,62.97)
  BOTTOM w0.076: UC1.AR58 115.74,63.3 v2(115.42,62.97)
  BOTTOM w0.102: JDIMM1.157 108.7,27.12 108.51,27.31 108.51,28.62 v2(108.94,29.05)
DDR_A_D18: length 56.1
  IN1 w0.084: v2(105.57,19.13) 106.26,19.82 106.26,56.25 110.18,60.17 110.67,60.17 112.4,61.9 112.4,63.11 114.73,65.44 114.73,66.07 115.26,66.59 115.57,66.59 115.8,66.37 115.8,65.49 v2(116.37,64.92)
  BOTTOM w0.076: v2(116.37,64.92) 116.69,65.25 UC1.AM57
  BOTTOM w0.102: v2(105.57,19.13) 105.4,18.97 JDIMM1.146
DDR_A_D19: length 57.1
  IN1 w0.084: v2(116.32,66.22) 115.77,66.77 115.1,66.77 114.48,66.14 114.48,65.51 112.46,63.49 112.24,63.49 109.41,60.66 109.41,59.82 105.96,56.37 105.96,54.64 105.87,54.56 105.62,54.56 105.52,54.46 105.52,54.32 105.62,54.22 105.87,54.22 105.96,54.14 105.96,53.97 105.87,53.89 105.56,53.89 105.46,53.79 105.46,53.65 105.56,53.55 105.87,53.55 105.96,53.47 105.96,22.71 105.17,21.92 105.17,21.06 v2(105.57,20.66)
  BOTTOM w0.076: v2(116.32,66.22) 116.64,66.55 UC1.AK57
  BOTTOM w0.102: v2(105.57,20.66) 106,20.23 JDIMM1.148
DDR_A_D20: length 56.1
  IN1 w0.084: v2(115.43,65.57) 113.02,63.16 113.02,61.76 110.8,59.54 110.39,59.54 106.85,56 106.85,36.03 106.96,35.93 107.5,35.93 107.6,35.83 107.6,24.98 107.5,24.88 107.31,24.88 107.23,24.96 107.23,26.96 107.13,27.06 106.99,27.06 106.89,26.96 106.89,24.96 106.81,24.88 106.66,24.88 106.56,24.98 106.56,27.41 106.68,27.53 v2(107.15,27.53)
  BOTTOM w0.076: UC1.AL58 115.75,65.9 v2(115.43,65.57)
  BOTTOM w0.102: JDIMM1.149 106.3,27.01 106.82,27.53 v2(107.15,27.53)
DDR_A_D21: length 56.6
  IN1 w0.084: v2(107.15,29.05) 107.15,28.79 107.05,28.69 106.66,28.69 106.56,28.79 106.56,29.18 106.64,29.26 106.76,29.26 106.85,29.35 106.85,29.51 106.76,29.6 106.64,29.6 106.56,29.68 106.56,29.99 106.63,30.06 106.83,30.06 107.06,30.29 107.06,30.75 106.93,30.87 106.69,30.87 106.56,31.01 106.56,31.17 106.64,31.25 107.21,31.25 107.29,31.33 107.29,31.5 107.21,31.58 106.64,31.58 106.56,31.67 106.56,31.84 106.64,31.92 107.21,31.92 107.29,32 107.29,32.17 107.21,32.26 106.64,32.26 106.56,32.34 106.56,32.51 106.64,32.59 107.21,32.59 107.29,32.67 107.29,32.84 107.21,32.93 106.64,32.93 106.56,33.01 106.56,33.18 106.64,33.26 107.21,33.26 107.29,33.34 107.29,33.51 107.21,33.6 106.64,33.6 106.56,33.68 106.56,33.85 106.64,33.93 107.21,33.93 107.29,34.02 107.29,34.18 107.21,34.27 106.64,34.27 106.56,34.35 106.56,34.52 106.64,34.6 107.21,34.6 107.29,34.69 107.29,34.85 107.21,34.94 106.64,34.94 106.56,35.02 106.56,35.19 106.64,35.27 107.21,35.27 107.29,35.36 107.29,35.52 107.21,35.61 106.64,35.61 106.56,35.69 106.56,56.12 110.22,59.79 110.73,59.79 112.76,61.82 112.76,63.22 114.99,65.44 114.99,65.79 v2(115.42,66.22)
  BOTTOM w0.076: UC1.AK58 115.74,66.55 v2(115.42,66.22)
  BOTTOM w0.102: v2(107.15,29.05) 105.7,27.6 JDIMM1.147
DDR_A_D22: length 53.8
  IN1 w0.084: v2(108.96,19.13) 109.37,19.54 109.37,20.22 109.54,20.4 110.05,20.4 110.12,20.47 110.12,20.65 110.04,20.73 109.79,20.73 109.7,20.82 109.7,20.99 109.79,21.07 110.04,21.07 110.12,21.15 110.12,21.32 110.04,21.41 109.79,21.41 109.7,21.49 109.7,21.66 109.79,21.74 110.04,21.74 110.12,21.82 110.12,21.99 110.04,22.08 109.79,22.08 109.7,22.16 109.7,22.33 109.79,22.41 110.15,22.41 110.24,22.5 110.24,30.49 109.87,30.85 109.87,32.45 109.97,32.56 110.88,32.56 110.99,32.66 110.99,37.5 109.24,39.25 109.24,55.26 110.43,56.46 110.43,56.82 114,60.38 114.74,60.38 116.37,62.01 v2(116.37,62.97)
  BOTTOM w0.076: UC1.AR57 116.69,63.3 v2(116.37,62.97)
  BOTTOM w0.102: JDIMM1.158 109,19.1 v2(108.96,19.13)
DDR_A_D23: length 55.8
  IN1 w0.084: v2(116.37,64.27) 115.99,63.9 115.99,61.88 114.67,60.55 113.93,60.55 110.26,56.89 110.26,56.71 108.94,55.39 108.94,39.13 110.69,37.38 110.69,33.07 110.47,32.85 109.73,32.85 109.57,32.7 109.57,30.73 109.94,30.36 109.94,24.85 109.85,24.77 109.43,24.77 109.35,24.68 109.35,24.52 109.43,24.43 109.85,24.43 109.94,24.35 109.94,24.18 109.85,24.1 109.43,24.1 109.35,24.01 109.35,23.85 109.43,23.76 109.85,23.76 109.94,23.68 109.94,23.51 109.85,23.43 109.43,23.43 109.35,23.34 109.35,23.17 109.43,23.09 109.66,23.09 109.75,22.99 109.75,22.85 109.66,22.76 109.49,22.76 109.39,22.65 109.39,21.08 v2(108.96,20.66)
  BOTTOM w0.076: v2(116.37,64.27) 116.69,64.6 UC1.AN57
  BOTTOM w0.102: v2(108.96,20.66) 109.6,20.02 JDIMM1.160
DDR_A_D24: length 80.1
  IN4 w0.084: v2(117.32,63.67) 116.94,63.29 116.94,62.77 115.08,60.92 113.79,60.92 106.14,53.27 102.15,53.27 99.94,51.05 84.64,51.05 66.94,33.36 66.94,29.06 66.66,28.78 66.66,19.82 v2(67.14,19.35)
  BOTTOM w0.076: v2(117.32,63.67) 117.6,63.95 UC1.AP55
  BOTTOM w0.102: JDIMM1.24 66.4,18.76 66.99,19.35 v2(67.14,19.35)
DDR_A_D25: length 79.3
  IN4 w0.084: v2(117.31,62.97) 117.31,62.98 117.32,62.97 117.32,62.91 115.16,60.74 114.04,60.74 106.26,52.97 102.28,52.97 100.07,50.75 84.76,50.75 67.24,33.23 67.24,27.85 67.53,27.56 67.53,21.27 v2(67.14,20.87)
  BOTTOM w0.076: v2(117.31,62.97) 117.32,62.97 117.65,63.3 UC1.AR55
  BOTTOM w0.102: v2(67.14,20.87) 65.8,19.54 JDIMM1.22
DDR_A_D26: length 81.9
  IN4 w0.084: v2(68.8,20.87) 69.3,21.37 69.3,24.69 70.01,25.41 70.01,31.38 70.79,32.16 70.79,32.7 76.51,38.43 76.51,39.77 85.6,48.86 101.03,48.86 101.78,49.61 105.68,49.61 113.2,57.12 113.5,57.12 116.34,59.96 117.37,59.96 118.86,61.46 118.86,63.8 118.65,64.02 118.65,65.2 v2(118.27,65.57)
  BOTTOM w0.076: v2(118.27,65.57) 118.6,65.25 UC1.AM54
  BOTTOM w0.102: JDIMM1.36 70,19.67 v2(68.8,20.87)
DDR_A_D27: length 83.4
  IN4 w0.084: v2(118.22,66.22) 118.82,65.63 118.82,64.21 119.11,63.91 119.11,61 117.21,59.09 115.71,59.09 112.65,56.03 112.44,56.03 111.16,54.75 111.16,54.66 105.81,49.31 101.91,49.31 101.15,48.56 85.73,48.56 76.81,39.65 76.81,38.3 71.09,32.58 71.09,32.03 70.31,31.26 70.31,28.55 70.4,28.46 70.62,28.46 70.71,28.37 70.71,28.23 70.62,28.13 70.4,28.13 70.31,28.05 70.31,20.86 v2(68.8,19.35)
  BOTTOM w0.076: UC1.AK54 118.55,66.55 v2(118.22,66.22)
  BOTTOM w0.102: v2(68.8,19.35) 69.4,18.75 JDIMM1.34
DDR_A_D28: length 81.9
  IN4 w0.084: v2(117.32,65.57) 116.77,65.02 116.77,62.85 116.09,62.17 114.15,62.17 105.55,53.57 102.03,53.57 99.82,51.35 84.51,51.35 66.64,33.48 66.64,32.75 66.56,32.67 66.06,32.67 65.96,32.57 65.96,32.43 66.06,32.33 66.56,32.33 66.64,32.25 66.64,32.08 66.56,32 65.68,32 65.58,31.9 65.58,31.76 65.68,31.66 66.56,31.66 66.64,31.58 66.64,31.41 66.56,31.33 65.68,31.33 65.58,31.23 65.58,31.09 65.68,30.99 66.56,30.99 66.64,30.91 66.64,30.74 66.56,30.66 65.68,30.66 65.58,30.56 65.58,30.42 65.68,30.32 66.56,30.32 66.64,30.24 66.64,30.07 66.56,29.99 66.3,29.99 66.22,29.9 66.22,29.73 66.3,29.65 66.56,29.65 66.64,29.57 66.64,29.23 66.47,29.05 v2(65.75,29.05)
  BOTTOM w0.076: UC1.AL55 117.65,65.9 v2(117.32,65.57)
  BOTTOM w0.102: JDIMM1.23 66.1,27.07 66.33,27.3 66.33,28.48 v2(65.75,29.05)
DDR_A_D29: length 82.6
  IN4 w0.084: v2(65.75,27.53) 65.46,27.53 65.28,27.71 65.28,32.55 65.86,33.12 65.97,33.12 66.1,32.99 66.24,32.99 66.34,33.09 66.34,33.23 66.21,33.36 66.21,33.47 80.83,48.1 80.83,48.22 80.61,48.44 80.61,48.58 80.71,48.68 80.84,48.68 81.06,48.46 81.2,48.46 81.3,48.56 81.3,48.7 81.07,48.92 81.07,49.04 81.19,49.16 81.31,49.16 81.54,48.93 81.66,48.93 81.78,49.05 81.78,49.16 81.55,49.4 81.55,49.52 81.66,49.64 81.78,49.64 82.02,49.4 82.14,49.4 82.26,49.52 82.26,49.64 82.02,49.87 82.02,49.99 82.14,50.11 82.26,50.11 82.49,49.88 82.61,49.88 82.73,49.99 82.73,50.11 82.49,50.35 82.49,50.47 82.61,50.59 82.73,50.59 82.97,50.35 83.09,50.35 83.2,50.47 83.2,50.59 82.97,50.82 82.97,50.94 83.09,51.06 83.21,51.06 83.44,50.82 83.56,50.82 83.68,50.94 83.68,51.06 83.44,51.3 83.44,51.42 83.56,51.53 83.68,51.53 83.92,51.3 84.03,51.3 84.39,51.65 99.69,51.65 101.9,53.87 105.42,53.87 113.9,62.34 115.31,62.34 115.8,62.83 115.8,66.55 116.05,66.8 117.06,66.8 117.27,66.59 v2(117.27,66.22)
  BOTTOM w0.076: v2(117.27,66.22) 117.6,66.55 UC1.AK55
  BOTTOM w0.102: JDIMM1.21 65.5,27.28 v2(65.75,27.53)
DDR_A_D30: length 80.3
  IN4 w0.084: v2(69.02,29.05) 69.41,29.45 69.41,31.63 70.19,32.41 70.19,32.95 72.91,35.67 72.91,35.79 72.52,36.18 72.52,36.32 72.62,36.41 72.76,36.41 73.15,36.03 73.27,36.03 73.45,36.21 73.45,36.33 72.92,36.85 72.92,36.97 73.04,37.09 73.16,37.09 73.69,36.56 73.8,36.56 73.92,36.68 73.92,36.8 73.4,37.32 73.4,37.44 73.52,37.56 73.64,37.56 74.16,37.04 74.28,37.04 74.4,37.16 74.4,37.27 73.87,37.8 73.87,37.92 73.99,38.04 74.11,38.04 74.63,37.51 74.75,37.51 74.87,37.63 74.87,37.75 74.35,38.27 74.35,38.39 74.47,38.51 74.58,38.51 75.11,37.99 75.23,37.99 75.35,38.11 75.35,38.22 74.82,38.75 74.82,38.87 74.94,38.99 75.06,38.99 75.58,38.46 75.7,38.46 75.92,38.67 75.92,38.79 75.43,39.28 75.43,39.53 85.35,49.46 100.78,49.46 101.53,50.21 105.43,50.21 110.99,55.76 110.99,56.62 114.35,59.99 115.87,59.99 118.27,62.39 v2(118.27,62.97)
  BOTTOM w0.076: v2(118.27,62.97) 118.6,63.3 UC1.AR54
  BOTTOM w0.102: v2(69.02,29.05) 68.61,28.65 68.61,27.33 69.1,26.84 JDIMM1.33
DDR_A_D31: length 81.7
  IN4 w0.084: v2(118.27,64.27) 118.27,64.15 118.66,63.76 118.66,61.54 117.28,60.17 116.3,60.17 113.43,57.3 112.95,57.3 105.56,49.91 101.66,49.91 100.91,49.16 85.48,49.16 76.22,39.89 76.22,38.55 70.49,32.82 70.49,32.28 69.71,31.51 69.71,27.03 69.63,26.95 68.92,26.95 68.82,26.85 68.82,26.71 68.92,26.61 69.63,26.61 69.71,26.53 69.71,26.36 69.63,26.28 68.79,26.28 68.71,26.19 68.71,26.03 68.79,25.94 69.63,25.94 69.71,25.86 69.71,25.53 69.61,25.43 68.24,25.43 68.14,25.53 68.14,27.43 68.24,27.53 v2(69.02,27.53)
  BOTTOM w0.076: UC1.AN54 118.6,64.6 v2(118.27,64.27)
  BOTTOM w0.102: JDIMM1.35 69.7,26.72 69.7,27.04 69.21,27.53 v2(69.02,27.53)
DDR_A_D32: length 47.8
  IN1 w0.084: v2(111.5,19.13) 111.08,19.56 111.08,24.01 111.16,24.08 112.12,24.08 112.25,24.22 112.25,37.93 110.43,39.75 110.43,54.42 110.99,54.97 110.99,56.55 113.13,58.69 v2(113.66,58.69)
  BOTTOM w0.076: v2(113.66,58.69) 113.7,58.65 114.96,58.65 115.72,59.41 115.72,60.07 UC1.AY58
  BOTTOM w0.102: v2(111.5,19.13) 111.4,19.03 JDIMM1.166
DDR_A_D33: length 48.7
  IN1 w0.084: v2(111.48,27.53) 111.48,27.79 111.35,27.92 110.96,27.92 110.83,27.79 110.83,25.01 110.96,24.88 111.83,24.88 111.95,25.01 111.95,25.8 111.83,25.93 111.42,25.93 111.34,26.02 111.34,26.18 111.42,26.27 111.85,26.27 111.95,26.37 111.95,26.5 111.85,26.6 111.42,26.6 111.34,26.69 111.34,26.85 111.42,26.94 111.79,26.94 111.88,27.02 111.88,37.88 110.13,39.63 110.13,54.44 110.81,55.12 110.81,56.62 113.31,59.12 v2(114.09,59.12)
  BOTTOM w0.076: UC1.AW58 115.54,60.54 115.54,59.47 115.2,59.12 v2(114.09,59.12)
  BOTTOM w0.102: JDIMM1.165 111.1,27.15 v2(111.48,27.53)
DDR_A_D34: length 48.6
  IN1 w0.084: v2(115.88,58.25) 115.88,57.47 112.63,54.21 112.63,51.35 112.71,51.26 113.04,51.26 113.14,51.17 113.14,51.03 113.04,50.93 112.71,50.93 112.63,50.85 112.63,50.68 112.71,50.59 113.04,50.59 113.14,50.5 113.14,50.36 113.04,50.26 112.71,50.26 112.63,50.17 112.63,50.01 112.71,49.92 113.04,49.92 113.14,49.82 113.14,49.69 113.04,49.59 112.71,49.59 112.63,49.5 112.63,49.34 112.71,49.25 113.04,49.25 113.14,49.15 113.14,49.02 113.04,48.92 112.71,48.92 112.63,48.83 112.63,48.67 112.71,48.58 113.04,48.58 113.14,48.48 113.14,48.35 113.04,48.25 112.71,48.25 112.63,48.16 112.63,48 112.71,47.91 113.04,47.91 113.14,47.81 113.14,47.67 113.04,47.58 112.71,47.58 112.63,47.49 112.63,47.32 112.71,47.24 113.04,47.24 113.14,47.14 113.14,47 113.04,46.91 112.71,46.91 112.63,46.82 112.63,46.65 112.71,46.57 113.04,46.57 113.14,46.47 113.14,46.33 113.04,46.24 112.71,46.24 112.63,46.15 112.63,45.98 112.71,45.9 113.04,45.9 113.14,45.8 113.14,45.66 113.04,45.56 112.71,45.56 112.63,45.48 112.63,45.31 112.71,45.23 113.04,45.23 113.14,45.13 113.14,44.99 113.04,44.89 112.71,44.89 112.63,44.81 112.63,44.64 112.71,44.56 113.04,44.56 113.14,44.46 113.14,44.32 113.04,44.22 112.71,44.22 112.63,44.14 112.63,43.97 112.71,43.89 113.04,43.89 113.14,43.79 113.14,43.65 113.04,43.55 112.71,43.55 112.63,43.47 112.63,43.3 112.71,43.22 112.96,43.22 113.06,43.12 113.06,42.98 112.96,42.88 112.71,42.88 112.63,42.8 112.63,40.66 115.58,37.71 115.58,29.45 v2(115.18,29.05)
  BOTTOM w0.076: v2(115.88,58.25) 115.91,58.28 116.47,58.28 116.8,58.61 116.8,58.74 117.17,59.11 117.17,59.99 117.19,60.01 UC1.AY56
  BOTTOM w0.102: v2(115.18,29.05) 114.59,28.46 114.59,27.44 114.1,26.95 JDIMM1.175
DDR_A_D35: length 49.4
  IN1 w0.084: v2(114.96,57.33) 114.96,56.8 112.33,54.16 112.33,40.54 115.28,37.59 115.28,30.48 114.76,29.96 114.76,28.16 113.91,27.3 113.91,25.61 113.82,25.52 113.53,25.52 113.44,25.42 113.44,25.28 113.53,25.19 113.82,25.19 113.91,25.1 113.91,22.34 114.76,21.49 114.76,19.36 114.53,19.13 v2(113.95,19.13)
  BOTTOM w0.076: v2(114.96,57.33) 115.48,57.33 115.89,57.73 v1(115.98,57.73) 116.16,57.73 116.96,58.54 116.96,58.67 117.33,59.04 117.33,59.92 117.48,60.06 117.48,60.31 117.19,60.6 UC1.AW56
  BOTTOM w0.102: JDIMM1.174 113.8,18.99 v2(113.95,19.13)
DDR_A_D36: length 49.4
  IN1 w0.084: v2(111.48,29.05) 111.3,29.05 111.18,28.93 111.18,28.55 111.07,28.45 110.93,28.45 110.83,28.55 110.83,29.16 110.96,29.28 111.05,29.28 111.14,29.37 111.14,29.53 111.05,29.62 110.91,29.62 110.83,29.7 110.83,30 111.05,30.23 111.48,30.23 111.58,30.32 111.58,31.54 111.49,31.63 111.25,31.63 111.17,31.54 111.17,31.1 111.07,31 110.93,31 110.83,31.1 110.83,31.54 110.75,31.63 110.56,31.63 110.46,31.73 110.46,31.86 110.56,31.96 111.49,31.96 111.58,32.05 111.58,37.75 109.83,39.49 109.83,54.56 110.13,54.86 110.13,54.97 109.94,55.16 109.94,55.3 110.04,55.4 110.18,55.4 110.36,55.21 110.53,55.21 110.64,55.33 110.64,55.49 110.31,55.82 110.31,56.09 110.6,56.38 110.6,56.66 113.52,59.57 113.64,59.57 113.74,59.47 113.86,59.47 113.98,59.59 113.98,59.71 113.88,59.81 113.88,59.93 113.99,60.05 114.67,60.05 114.8,59.92 114.8,59.74 114.67,59.61 v2(114.5,59.61)
  BOTTOM w0.076: UC1.AV58 115.61,61.26 115.61,61.08 114.86,60.32 114.86,59.97 v2(114.5,59.61)
  BOTTOM w0.102: JDIMM1.163 110.5,27.29 110.6,27.39 110.83,27.39 110.93,27.49 110.93,27.7 110.83,27.8 110.6,27.8 110.5,27.9 110.5,28.1 110.6,28.21 110.83,28.21 110.93,28.31 110.93,29.21 111.06,29.34 111.35,29.34 111.48,29.21 v2(111.48,29.05)
DDR_A_D37: length 50.9
  IN1 w0.084: v2(111.5,20.66) 112.6,21.76 112.6,38 110.73,39.88 110.73,54.47 111.36,55.1 v2(111.36,56.4)
  BOTTOM w0.076: v2(111.36,56.4) 112.73,56.4 114.16,57.82 114.88,57.82 116.2,59.15 116.61,59.15 116.84,59.38 116.84,59.89 116.73,60 116.73,60.29 116.75,60.34 116.76,60.34 116.8,60.45 116.8,60.58 116.73,60.73 116.73,60.94 116.75,60.99 116.8,61.08 116.8,61.09 116.8,61.35 116.79,61.37 116.79,61.61 116.8,61.62 116.8,61.97 116.64,62.14 116.6,62.14 116.6,62.14 UC1.AU58
  BOTTOM w0.102: JDIMM1.164 110.8,19.96 v2(111.5,20.66)
DDR_A_D38: length 50
  IN1 w0.084: v2(115.18,27.53) 114.56,27.53 114.46,27.43 114.46,25.07 114.58,24.94 114.86,24.94 114.99,25.07 114.99,26.98 115.07,27.06 115.24,27.06 115.32,26.98 115.32,25.31 115.41,25.22 115.78,25.22 115.88,25.32 115.88,37.83 112.93,40.79 112.93,42.34 113.05,42.47 113.31,42.47 113.43,42.6 113.43,52.32 112.93,52.83 112.93,54.26 116.34,57.67 v2(116.34,58.71)
  BOTTOM w0.076: v2(116.34,58.71) 116.62,58.98 116.67,58.98 117,59.31 117,59.96 116.9,60.06 116.9,60.25 116.94,60.36 116.97,60.38 116.97,60.61 116.94,60.67 116.9,60.76 116.9,60.77 116.9,60.9 116.92,60.95 116.95,61.01 117.08,61.14 UC1.AV56
  BOTTOM w0.102: JDIMM1.177 114.7,27.05 v2(115.18,27.53)
DDR_A_D39: length 51
  IN1 w0.084: v2(114.5,56.87) 113.97,56.87 111.83,54.72 111.83,53.87 112.03,53.67 112.03,40.41 114.98,37.46 114.98,30.6 114.41,30.03 114.41,28.33 113.07,26.99 113.07,20.89 113.3,20.66 v2(113.95,20.66)
  BOTTOM w0.076: v2(114.5,56.87) 115.53,56.87 117.13,58.47 117.13,58.6 117.5,58.97 117.5,59.85 117.64,60 117.64,60.79 117.37,61.07 117.37,61.36 117.37,61.37 117.37,61.61 117.21,61.77 117.21,62.01 UC1.AU56
  BOTTOM w0.102: v2(113.95,20.66) 114.4,20.21 JDIMM1.176
DDR_A_D40: length 75.4
  IN4 w0.084: v2(112.2,54.57) 112.35,54.42 112.35,54.11 106.36,48.12 102.47,48.12 101.72,47.37 86.22,47.37 80.37,41.51 80.37,40.17 72.31,32.11 72.31,20.1 v2(73.07,19.35)
  BOTTOM w0.076: UC1.AY54 118.14,60.06 118.14,59.79 117.99,59.64 117.99,58.77 117.63,58.4 117.63,58.27 113.93,54.57 v2(112.2,54.57)
  BOTTOM w0.102: JDIMM1.42 71.8,19.05 72.1,19.35 v2(73.07,19.35)
DDR_A_D41: length 76.1
  IN4 w0.084: v2(71.56,27.53) 71.56,27.14 71.47,27.06 71.01,27.06 70.93,26.97 70.93,26.72 71.01,26.64 71.47,26.64 71.56,26.56 71.56,26.3 71.47,26.22 71.01,26.22 70.93,26.14 70.93,25.88 71.01,25.8 71.47,25.8 71.56,25.72 71.56,25.47 71.47,25.38 71.01,25.38 70.93,25.3 70.93,24.68 71.03,24.57 71.39,24.57 71.49,24.68 71.49,24.83 71.59,24.93 71.88,24.93 71.98,25.03 71.98,32.21 80.07,40.29 80.07,41.64 86.1,47.67 101.52,47.67 102.28,48.42 106.21,48.42 111.83,54.04 111.83,54.9 112.42,55.49 v2(113.12,55.49)
  BOTTOM w0.076: v2(113.12,55.49) 114.34,55.49 115.22,56.36 115.49,56.36 117.46,58.33 117.46,58.47 117.83,58.84 117.83,59.71 117.98,59.86 117.98,60.31 118.27,60.6 UC1.AW54
  BOTTOM w0.102: v2(71.56,27.53) 71.5,27.47 JDIMM1.41
DDR_A_D42: length 75.5
  IN4 w0.084: v2(74.88,20.87) 74.42,21.33 74.42,23.43 74.51,23.51 74.76,23.51 74.85,23.61 74.85,23.75 74.76,23.85 74.51,23.85 74.42,23.93 74.42,24.1 74.51,24.19 74.76,24.19 74.85,24.28 74.85,24.42 74.76,24.52 74.51,24.52 74.42,24.6 74.42,27.27 74.78,27.62 74.78,30.23 75.28,30.74 75.28,32.4 88.35,45.47 102.56,45.47 103.31,46.22 109.05,46.22 113.78,50.94 113.78,53.83 115.46,55.52 v2(115.99,55.52)
  BOTTOM w0.076: UC1.AY52 119.49,60.06 119.49,59.58 119.47,59.56 119.47,58.09 117.19,55.81 116.96,55.81 116.66,55.52 v2(115.99,55.52)
  BOTTOM w0.102: JDIMM1.50 74.2,20.19 v2(74.88,20.87)
DDR_A_D43: length 76.6
  IN4 w0.084: v2(115.07,54.6) 115.07,53.53 114.83,53.3 114.83,51.15 108.55,44.87 88.6,44.87 76.09,32.36 76.09,28.55 76.01,28.47 75.71,28.47 75.63,28.38 75.63,28.22 75.71,28.13 76.01,28.13 76.09,28.05 76.09,27.88 76.01,27.8 75.71,27.8 75.63,27.71 75.63,27.55 75.71,27.46 76.01,27.46 76.09,27.38 76.09,27.21 76.01,27.13 75.56,27.13 75.48,27.04 75.48,26.88 75.56,26.79 76.01,26.79 76.09,26.71 76.09,26.53 76.01,26.45 75.59,26.45 75.49,26.35 75.49,26.21 75.59,26.11 76.01,26.11 76.09,26.03 76.09,25.85 76.01,25.76 75.6,25.76 75.5,25.66 75.5,25.53 75.6,25.43 76.01,25.43 76.09,25.34 76.09,25.01 75.99,24.9 75.08,24.9 74.89,25.09 74.89,27.22 v2(75.2,27.53)
  BOTTOM w0.076: v2(115.07,54.6) 116.21,54.6 119.64,58.03 119.64,59.49 119.91,59.76 119.91,60.25 119.86,60.35 119.84,60.41 119.84,60.62 UC1.AW52
  BOTTOM w0.102: v2(75.2,27.53) 74.5,26.83 JDIMM1.51
DDR_A_D44: length 76.5
  IN4 w0.084: v2(113.58,55.95) 113.49,55.86 112.52,55.86 111.62,54.97 111.62,54.25 106.08,48.72 102.15,48.72 101.4,47.97 85.97,47.97 79.3,41.29 79.3,41.08 79.77,40.61 79.77,40.42 79.59,40.24 79.47,40.24 78.95,40.76 78.81,40.76 78.71,40.66 78.71,40.52 79.23,40 79.23,39.88 79.12,39.77 79,39.77 78.51,40.26 78.37,40.26 78.27,40.16 78.27,40.02 78.76,39.53 78.76,39.41 78.64,39.29 78.52,39.29 78.12,39.7 78,39.7 77.88,39.58 77.88,39.46 78.29,39.05 78.29,38.94 78.17,38.82 78.05,38.82 77.64,39.22 77.53,39.22 77.41,39.1 77.41,38.98 77.81,38.58 77.81,38.46 71.68,32.33 71.68,31.2 71.58,31.1 70.99,31.1 70.9,31.01 70.9,30.76 70.99,30.68 71.58,30.68 71.68,30.58 71.68,30.36 71.58,30.26 70.99,30.26 70.9,30.17 70.9,29.21 71.06,29.05 v2(71.56,29.05)
  BOTTOM w0.076: UC1.AV54 118.37,61.36 117.81,60.79 117.81,59.93 117.66,59.78 117.66,58.9 117.29,58.54 117.29,58.4 115.52,56.63 115.25,56.63 114.57,55.95 v2(113.58,55.95)
  BOTTOM w0.102: v2(71.56,29.05) 70.9,28.4 JDIMM1.39
DDR_A_D45: length 77.5
  IN4 w0.084: v2(118.73,58.72) 117.44,58.72 106.54,47.82 102.59,47.82 101.84,47.07 86.34,47.07 80.67,41.39 80.67,40.04 72.64,32.02 72.64,21.3 v2(73.07,20.87)
  BOTTOM w0.076: UC1.AU54 119.03,62.14 119.23,61.93 119.23,61.09 119.23,61.08 119.19,60.99 119.16,60.94 119.16,60.73 119.23,60.58 119.23,60.45 119.19,60.34 119.16,60.29 119.16,59.78 119.14,59.76 119.14,59.14 v2(118.73,58.72)
  BOTTOM w0.102: v2(73.07,20.87) 71.2,19 JDIMM1.40
DDR_A_D46: length 76.6
  IN4 w0.084: v2(116.45,55.98) 115.68,55.98 113.48,53.78 113.48,51.07 108.93,46.52 103.19,46.52 102.44,45.77 88.23,45.77 74.95,32.5 74.95,30.87 74.45,30.36 74.45,27.84 74.12,27.52 74.12,27.27 74.04,27.18 73.83,27.18 73.74,27.08 73.74,26.95 73.83,26.85 74.04,26.85 74.12,26.76 74.12,26.6 74.04,26.51 73.81,26.51 73.71,26.41 73.71,26.28 73.81,26.18 74.04,26.18 74.12,26.09 74.12,20.11 v2(74.88,19.35)
  BOTTOM w0.076: v2(116.45,55.98) 117.12,55.98 119.31,58.16 119.31,59.63 119.33,59.65 119.33,60.25 119.4,60.41 119.4,60.61 119.38,60.67 119.33,60.76 119.33,60.77 119.33,60.9 119.35,60.95 119.38,61.01 119.51,61.14 UC1.AV52
  BOTTOM w0.102: v2(74.88,19.35) 74.8,19.26 JDIMM1.52
DDR_A_D47: length 77.9
  IN4 w0.084: v2(75.2,29.05) 75.66,29.05 75.79,29.18 75.79,32.48 88.48,45.17 102.93,45.17 103.01,45.25 103.01,45.32 103.11,45.41 103.25,45.41 103.35,45.32 103.35,45.25 103.43,45.17 103.67,45.17 103.75,45.25 103.75,45.84 103.84,45.92 104,45.92 104.09,45.84 104.09,45.25 104.17,45.17 104.34,45.17 104.42,45.25 104.42,45.84 104.51,45.92 104.67,45.92 104.76,45.84 104.76,45.25 104.84,45.17 105.01,45.17 105.09,45.25 105.09,45.84 105.18,45.92 105.34,45.92 105.43,45.84 105.43,45.25 105.51,45.17 105.68,45.17 105.76,45.25 105.76,45.84 105.85,45.92 106.02,45.92 106.1,45.84 106.1,45.25 106.18,45.17 106.35,45.17 106.43,45.25 106.43,45.84 106.52,45.92 106.69,45.92 106.77,45.84 106.77,45.25 106.85,45.17 107.02,45.17 107.1,45.25 107.1,45.84 107.19,45.92 107.36,45.92 107.44,45.84 107.44,45.25 107.52,45.17 107.69,45.17 107.78,45.25 107.78,45.84 107.86,45.92 108.03,45.92 108.11,45.84 108.11,45.25 108.19,45.17 108.42,45.17 108.51,45.25 108.51,45.82 108.61,45.92 109.18,45.92 114.14,50.88 114.14,52.84 114.61,53.32 v2(114.61,54.14)
  BOTTOM w0.076: v2(114.61,54.14) 115.99,54.14 119.8,57.95 119.8,59.42 119.8,59.42 120.08,59.69 120.08,60.29 120.05,60.34 120,60.45 120,61.75 UC1.AU52
  BOTTOM w0.102: JDIMM1.53 75.1,26.73 75.66,27.3 75.66,28.59 v2(75.2,29.05)
DDR_A_D48: length 86.1
  IN4 w0.084: v2(126.76,66.27) 127.32,66.27 127.69,65.9 127.69,62.57 127.31,62.2 126.3,62.2 126.28,62.21 125.97,62.21 125.96,62.2 124.4,62.2 124.17,61.97 124.17,61.5 123.77,61.1 123.77,56.56 123.2,55.98 121.25,55.98 118.7,53.43 118.7,48.54 111.35,41.18 90.13,41.18 81.47,32.53 81.47,27.67 81.86,27.28 81.86,25.26 81.76,25.16 80.92,25.16 80.82,25.26 80.82,25.43 80.92,25.53 81.04,25.53 81.14,25.63 81.14,25.77 81.04,25.87 80.34,25.87 80.26,25.95 80.26,26.15 80.34,26.23 81.06,26.23 81.14,26.32 81.14,26.48 81.06,26.57 80.34,26.57 80.26,26.65 80.26,26.82 80.34,26.9 81.06,26.9 81.14,26.99 81.14,27.15 81.06,27.24 80.34,27.24 80.26,27.32 v2(80.26,27.53)
  BOTTOM w0.076: v2(126.76,66.27) 127.04,66.55 UC1.AK40
  BOTTOM w0.102: v2(80.26,27.53) 79.9,27.17 JDIMM1.69
DDR_A_D49: length 86.2
  IN4 w0.084: v2(125.84,66.27) 126.22,65.89 126.98,65.89 127.13,65.75 127.13,62.58 126.94,62.39 124.32,62.39 123.96,62.02 123.96,61.53 123.57,61.15 123.57,56.6 123.13,56.15 120.84,56.15 118.4,53.72 118.4,48.66 111.22,41.48 90,41.48 81.17,32.65 81.17,32 81.09,31.92 80.53,31.92 80.44,31.83 80.44,31.67 80.53,31.58 81.09,31.58 81.17,31.5 81.17,31.33 81.09,31.25 80.41,31.25 80.32,31.15 80.32,31.01 80.41,30.91 81.09,30.91 81.17,30.83 81.17,30.66 81.09,30.58 80.4,30.58 80.3,30.48 80.3,30.34 80.4,30.24 81.09,30.24 81.17,30.16 81.17,29.99 81.09,29.91 80.4,29.91 80.3,29.81 80.3,29.67 80.4,29.57 81.09,29.57 81.17,29.49 81.17,27.64 81.07,27.54 80.78,27.54 80.68,27.64 80.68,28.93 80.55,29.05 v2(80.26,29.05)
  BOTTOM w0.076: v2(125.84,66.27) 126.11,66.55 UC1.AK42
  BOTTOM w0.102: JDIMM1.67 79.3,28.1 v2(80.26,29.05)
