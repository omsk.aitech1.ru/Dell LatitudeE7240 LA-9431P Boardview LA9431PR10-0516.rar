# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PROCHOT_GATE: length 132.8
  TOP w0.102: v2(103.76,89.53) 103.76,89.22 v1(104.11,88.86) ; RP11.8 12.54,37.95 13.56,37.95 v2(14.01,37.5) 14.28,37.77 U37.A50
  TOP w0.254: PU3.2 103.67,89.62 v2(103.76,89.53)
  IN4 w0.084: v2(103.76,89.53) 103.51,89.79 101.8,89.79 101.4,90.19 100,90.19 98.63,88.82 84.86,88.82 83.67,87.64 81.55,87.64 81.15,87.23 75.81,87.23 74.14,88.91 66.38,88.91 58.05,80.58 57.82,80.58 52.68,75.44 52.68,65.84 53.79,64.73 53.79,61.88 54.77,60.91 54.77,57.02 52.98,55.23 52.98,53.38 52.22,52.63 52.22,52.42 51.62,51.82 51.62,51.18 46.84,46.4 40.36,46.4 38.2,44.23 34.53,44.23 34.01,43.71 31.71,43.71 31.32,43.32 29.57,43.32 27.14,40.89 25.41,40.89 24.43,39.91 16.19,39.91 13.97,37.68 13.97,37.54 v2(14.01,37.5)
PS_ID: length 151.4
  TOP w0.102: v2(18.53,15.63) 18.83,15.33 U38.A55
  TOP w0.254: PU111.4 v1(80.9,97.92) 80.9,98.24 79.77,99.38 v2(79.6,99.38)
  IN1 w0.084: v2(79.6,99.38) 80.12,98.86 80.12,97.18 79.42,96.47 72,96.47 61.6,86.08 58.9,86.08 54.17,81.36 54.17,77.49 54.79,76.87 54.79,75.48 53.26,73.95 53.26,72.57 52.08,71.39 52.08,68.3 50.86,67.08 50.86,62.38 53.65,59.59 53.65,57.66 50.62,54.63 50.62,53.61 47.53,50.52 44.71,50.52 44.52,50.32 44.52,50.04 44.29,49.81 43.72,49.81 42.69,48.78 36.98,48.78 v2(32.64,44.44)
  IN2 w0.122: v2(32.64,44.44) 32.98,44.09 32.98,41.53 31.36,39.91 25.53,39.91 24.76,39.14 16.24,39.14 15.27,38.17 11.04,38.17 10.46,37.59 8.57,37.59 8.27,37.29 8.27,33.7 8.94,33.03 8.94,32.68 11.95,29.67 11.95,27.26 14.15,25.07 14.15,23.23 14.94,22.44 15.34,22.44 15.34,22.44 15.55,22.44 15.92,22.07 16.82,22.07 17.64,21.24 17.64,17.88 16.8,17.04 16.8,16.04 17.21,15.63 v2(18.53,15.63)
PS_USBP0_D+: length 2.2
  TOP w0.102: R249.1 73.11,89.09 L42.4 73.11,88.41 73.54,87.99 73.54,87.8 73.4,87.66 U39.3
PS_USBP0_D-: length 2.3
  TOP w0.102: U39.2 73.9,87.66 73.76,87.8 73.76,87.9 74.31,88.46 L42.1 74.31,89.09 R251.1
PSID_DISABLE#: length 104.6
  TOP w0.102: v2(22.2,40.89) 22.2,40.65 21.93,40.38 U37.A37
  TOP w0.254: v2(87.97,91.24) 88.46,91.72 PR13.2
  IN1 w0.084: v2(87.97,91.24) 87.81,91.07 84.53,91.07 83.8,91.8 71.86,91.8 67.2,87.14 67.2,85.13 63.73,81.67 63.21,81.67 59.49,77.95 59.49,73.19 58.76,72.46 58.76,70.4 55.82,67.45 55.82,61.37 55.09,60.64 55.09,56.95 52.17,54.03 52.17,52.17 52.45,51.89 52.45,51.16 51.44,50.14 50.77,50.14 47.26,46.63 40.2,46.63 36.83,43.26 29.91,43.26 29.57,43.6 27.04,43.6 26.7,43.26 25.95,43.26 25.3,42.61 25.3,41.05 24.36,40.11 22.87,40.11 22.2,40.78 v2(22.2,40.89)
  BOTTOM w0.102: v1(22.34,41.49) 22.29,41.44 22.29,40.98 v2(22.2,40.89)
PWM1: length 11
  TOP w0.203: v2(86.87,72.67) 87.04,72.84 PU500.6
  BOTTOM w0.203: v2(86.87,72.67) 85.47,71.27 83.83,71.27 v1(83.59,71.03) 82.02,71.03 80.3,69.31 80.3,68.94 80.06,68.69 80.06,68.16 80.3,67.92 PU501.8
PWR_SRC_ON: length 5.3
  TOP w0.102: v2(68,67.98) 68.38,67.98 v1(68.72,68.33) 69.2,68.81 R99.1 R97.2 C66.2
  BOTTOM w0.102: v2(68,67.98) 67.74,67.98 67.42,68.3 Q2.3
PWRSHARE_EN: length 35
  TOP w0.102: U39.1 74.4,87.5 v2(74.68,87.78) ; v2(55.17,73.18) 54.89,72.9 v5(54.53,72.9) 53.37,72.9 53.12,73.14 R241.2 53.12,74.65 53.12,74.65 Q7.2
  IN2 w0.122: v2(74.68,87.78) 70.14,87.78 66.16,83.79 58.42,83.79 57.35,82.73 57.35,75.39 55.17,73.2 v2(55.17,73.18)
PWRSHARE_EN#: length 63.4
  TOP w0.102: v1(53.39,79.92) v2(53.39,79.03) 53.76,78.66 R243.1 53.76,77.83 53.77,77.81 Q7.1 ; U35.4 v2(100.38,104.77)
  IN3 w0.122: v2(100.38,104.77) 100.38,103.33 95.61,98.56 95.61,97.8 94.01,96.2 75.59,96.2 68.34,88.95 65.04,88.95 62.1,86.01 59.85,86.01 53.39,79.55 v2(53.39,79.03)
RED_DOCK: length 113.8
  TOP w0.102: v2(216.24,94.07) 216.24,92.95 215.24,91.95 215.24,88.15 212.09,85 R311.1 212.09,82.8 R73.2
  IN2 w0.122: v2(216.24,94.07) 215.68,93.51 214.66,93.51 213.6,94.56 212.52,94.56 212,94.04 202.43,94.04 201.61,94.85 188.1,94.85 186.97,93.73 185.57,93.73 184.82,92.98 184.46,92.98 184.1,92.62 v2(183.5,92.62)
  BOTTOM w0.102: JDOCK1.53 127.45,96.21 130.32,93.34 135.16,93.34 136.99,95.17 143.6,95.17 144.27,94.5 145.48,94.5 146.32,93.66 153.02,93.66 155.78,96.42 156.71,96.42 157.1,96.03 159.23,96.03 159.46,95.8 165,95.8 168.15,92.65 181.36,92.65 181.68,92.32 182.27,92.32 182.58,92.62 v2(183.5,92.62)
REGCTL_PNP10: length 2.8
  TOP w0.203: U21.7 256.18,77.77 256.35,77.94 256.97,77.94 257.29,78.26 v2(257.29,78.4)
  TOP w0.254: v1(260.88,73.55) 260.88,73.43 260.79,73.34 v2(260.79,72.95)
  vias: v2(260.19,72.95)
REM_DIODE1_N: length 158.8
  TOP w0.102: v2(27.49,11.18) 27.37,11.18 26.69,10.5 U38.B13 ; v2(27.51,5.85) 27.33,6.03 27.33,6.3 27.79,6.76 27.79,6.93 C358.1 ; v2(127.89,72.19) 128.05,72.03 128.35,72.03 C370.1 129.06,72.73 130.86,72.73 Q11.3
  IN1 w0.084: v2(35.52,7.76) 35.71,7.58 36.06,7.58 36.99,8.51 40.45,8.51 40.85,8.1 42.15,8.1 44.04,9.99 44.04,13.17 49.1,18.24 49.1,22.41 51.15,24.46 56.37,24.46 57.78,25.87 60.42,25.87 62.02,27.47 62.02,31.75 64.1,33.83 76.82,33.83 88.87,45.88 88.87,47.48 97.85,56.45 v2(97.85,56.71)
  IN4 w0.084: v2(27.51,5.85) 27.31,5.66 27.31,5.62 27.75,5.19 28.31,5.19 28.72,5.6 30.65,5.6 31.2,6.14 34.27,6.14 34.75,6.62 34.75,7.31 34.99,7.55 35.31,7.55 v2(35.52,7.76) ; v2(97.85,56.71) 98.11,56.71 100.1,58.7 100.1,63.52 101.55,64.97 104.71,64.97 106.38,63.3 107.77,63.3 108.18,63.71 110.07,63.71 114.72,68.35 115.19,68.35 116.17,67.37 118.51,67.37 118.99,67.85 118.99,71.23 119.71,71.95 127.65,71.95 v2(127.89,72.19)
  BOTTOM w0.102: v2(27.51,5.85) 28.37,5.85 29.38,6.85 29.38,8.67 27.89,10.16 27.89,10.78 v2(27.49,11.18)
REM_DIODE1_P: length 155.1
  TOP w0.102: v2(127.89,71.6) 128.08,71.8 128.37,71.8 C370.2 129.32,70.84 v1(129.59,70.84) 129.67,70.77 Q11.1 132.22,71.42 Q11.2 ; U38.A13 26.94,7.77 27.22,7.49 C358.2 27.56,6.93 27.56,6.85 27.1,6.39 27.1,6.03 v2(26.92,5.85)
  IN1 w0.084: v2(35.52,7.18) 35.71,7.37 36.14,7.37 37.08,8.3 40.36,8.3 40.77,7.89 42.23,7.89 44.25,9.91 44.25,13.08 49.31,18.15 49.31,22.33 51.24,24.25 56.46,24.25 57.87,25.65 60.5,25.65 62.23,27.38 62.23,31.66 64.19,33.62 76.91,33.62 89.09,45.79 89.09,47.39 98,56.3 v2(98.26,56.3)
  IN4 w0.084: v2(98.26,56.3) 98.26,56.56 100.32,58.62 100.32,63.43 101.64,64.76 104.62,64.76 106.29,63.09 107.86,63.09 108.27,63.49 110.16,63.49 114.81,68.14 115.1,68.14 116.08,67.16 118.59,67.16 119.2,67.77 119.2,71.14 119.8,71.74 127.75,71.74 v2(127.89,71.6) ; v2(35.52,7.18) 35.36,7.34 35.08,7.34 34.96,7.22 34.96,6.53 34.36,5.93 31.28,5.93 30.73,5.38 28.8,5.38 28.4,4.98 27.66,4.98 27.1,5.54 27.1,5.67 v2(26.92,5.85)
REM_DIODE2_N: length 131.9
  TOP w0.102: v2(125.59,16.55) C372.2 125.59,17.88 125.46,18.01 125.46,19.14 125.93,19.61 125.93,19.75 125.83,19.85 125.49,19.85 125.37,19.97 Q13.3 ; U38.B14 27.19,10.3 v2(27.48,10.6) ; C359.1 29.29,6.71 v2(28.97,7.02)
  IN3 w0.122: v2(28.97,7.02) 28.79,7.02 28.65,7.16 28.65,7.34 28.75,7.45 31.14,7.45 32.08,6.51 35.85,6.51 37.75,8.41 47.97,8.41 48.17,8.61 50.35,8.61 50.9,9.15 50.9,12.04 48.31,14.63 48.31,18.36 50.55,20.6 51.92,20.6 54.92,23.6 82.7,23.6 83.31,22.99 95.28,22.99 95.73,22.53 95.73,18.49 97.06,17.16 111.71,17.16 112.47,16.41 117.59,16.41 118.6,15.4 119.57,15.4 120.03,15.85 122.81,15.85 123.85,16.9 125.07,16.9 125.34,17.16 125.66,17.16 125.81,17.02 125.81,16.77 v2(125.59,16.55)
  BOTTOM w0.102: v2(28.97,7.02) 28.87,7.12 28.87,8.31 27.38,9.79 27.38,10.49 v2(27.48,10.6)
REM_DIODE2_P: length 131.1
  TOP w0.102: Q13.2 126.67,19.94 126.58,19.85 126.24,19.85 126.14,19.75 126.14,19.47 126.02,19.35 Q13.1 126.5,18.06 C372.1 126.5,16.83 v2(126.23,16.55) ; U38.A14 v2(27.44,7.97) 27.53,7.87 28.47,7.87 28.56,7.78 28.56,6.5 C359.2
  IN3 w0.122: v2(27.44,7.97) 27.74,7.67 31.23,7.67 32.17,6.74 35.76,6.74 37.66,8.64 47.88,8.64 48.08,8.83 50.26,8.83 50.67,9.25 50.67,11.95 48.09,14.54 48.09,18.46 50.45,20.82 51.83,20.82 54.82,23.82 82.8,23.82 83.4,23.21 95.37,23.21 95.96,22.62 95.96,18.58 97.15,17.39 111.81,17.39 112.56,16.63 117.68,16.63 118.69,15.62 119.48,15.62 119.94,16.08 122.72,16.08 123.76,17.12 124.98,17.12 125.25,17.39 125.76,17.39 126.04,17.11 126.04,16.74 v2(126.23,16.55)
REM_DIODE4_N: length 118.6
  TOP w0.102: U38.A16 28.44,8.82 28.78,8.48 29.38,8.48 30.15,7.71 30.15,7.61 C361.1 30.16,6.93 30.16,5.9 29.53,5.27 29.53,4.72 v2(29.37,4.56)
  IN1 w0.084: v2(84.32,57.9) 84.13,57.71 83.84,57.71 83.52,57.39 83.52,41.51 76.53,34.52 63.76,34.52 61.24,32 61.24,27.75 60.32,26.83 57.57,26.83 55.99,25.25 54.71,25.25 54.53,25.43 49.91,25.43 48.59,24.11 48.59,22.9 48.08,22.39 48.08,18.49 47.07,17.47 45.87,17.47 43.84,15.44 43.84,14.04 43.27,13.47 43.27,10.22 41.89,8.84 41.1,8.84 40.73,9.2 35.53,9.2 35.17,8.84 33.67,8.84 32.98,9.52 31.08,9.52 v2(30.89,9.71)
  BOTTOM w0.102: v2(84.32,57.9) 84.56,57.66 84.72,57.66 84.98,57.4 84.98,55.47 85.28,55.17 91.28,55.17 92.78,56.67 92.93,56.67 C373.1 93.27,57 93.52,56.75 93.79,56.75 93.95,56.91 93.95,57.1 94.06,57.2 Q14.3 ; v2(30.89,9.71) 30.76,9.58 30.33,9.58 30.05,9.29 30.05,6.29 29.53,5.78 29.53,4.72 v2(29.37,4.56)
REM_DIODE4_P: length 121.4
  TOP w0.102: v2(29.96,4.56) 29.76,4.75 29.76,5.17 30.39,5.8 30.39,6.93 C361.2 30.38,7.63 30.38,7.81 29.47,8.71 28.98,8.71 28.82,8.88 28.82,9.44 28.69,9.56 U38.B17
  IN1 w0.084: v2(30.89,9.13) 31.08,9.31 32.89,9.31 33.58,8.63 35.25,8.63 35.62,8.99 40.64,8.99 41.01,8.63 41.98,8.63 43.49,10.13 43.49,13.39 44.05,13.95 44.05,15.36 45.96,17.26 47.15,17.26 48.29,18.4 48.29,22.31 48.8,22.82 48.8,24.02 50,25.22 54.44,25.22 54.62,25.04 56.08,25.04 57.66,26.62 60.41,26.62 61.46,27.67 61.46,31.91 63.85,34.3 76.62,34.3 83.73,41.42 83.73,57.3 83.93,57.5 84.13,57.5 v2(84.32,57.31)
  BOTTOM w0.102: v2(84.32,57.31) 84.43,57.43 84.63,57.43 84.75,57.31 84.75,55.38 85.19,54.94 91.38,54.94 92.87,56.44 92.93,56.44 C373.2 93.27,56.11 93.66,56.5 93.84,56.5 93.9,56.44 93.9,56.03 94.03,55.9 Q14.2 96.36,55.9 Q14.1 ; v2(30.89,9.13) 30.89,9.14 30.68,9.35 30.43,9.35 30.28,9.19 30.28,6.2 29.76,5.68 29.76,4.75 v2(29.96,4.56)
RES_BIAS: length 3.2
  TOP w0.102: U21.12 256,79.77 256.71,80.48 v1(257.24,80.48) 258.03,80.48 R185.1
RESET_OUT#: length 282
  TOP w0.102: v2(26.37,18.49) 26.69,18.81 U38.B39 ; RC263.2 106.08,96.47 v2(106.2,96.58) ; v2(46.64,27.31) 46.61,27.28 v1(46.61,26.16) 46.61,25.27 44.46,23.13 43.37,23.13 42.62,22.38 R373.2 38.75,21.83 38.75,21.27 v2(38.41,20.93)
  IN2 w0.122: v2(155.26,90.77) 155.26,90.38 153.04,88.15 153.04,87.35 150.74,85.05 150.74,78.02 150.52,77.8 150.52,77.39 150.88,77.03 150.88,76.58 153.11,74.36 153.11,73.93 153.39,73.65 154.18,73.65 158.65,69.18 158.65,66.41 161.86,63.19 161.86,59.88 161.71,59.73 161.71,59.14 v2(163.04,57.81) 163.28,57.57 163.28,56.4 162.17,55.29 162.17,47.54 148.96,34.33 63.22,34.33 61.73,32.84 53.73,32.84 48.44,27.56 47.78,27.56 47.53,27.31 v2(46.64,27.31)
  IN3 w0.122: v2(106.2,96.58) 106.54,96.24 111.98,96.24 112.45,96.71 129.22,96.71 130.84,95.09 136.12,95.09 136.53,95.5 149.25,95.5 149.52,95.23 152.12,95.23 155.26,92.09 v2(155.26,90.77)
  IN4 w0.084: v2(38.41,20.93) 37.57,20.93 36.57,19.93 33.05,19.93 31.56,18.44 29.47,18.44 29.14,18.11 27.33,18.11 26.95,18.49 v2(26.37,18.49)
  BOTTOM w0.102: RC88.1 163.75,56.87 163.04,57.58 v2(163.04,57.81) 163.41,57.81 164.44,58.84 164.44,59.93 164.21,60.16 163.79,60.16 162.88,61.07 162.88,62.53 163.91,63.56 163.91,64.43 164.71,65.23 164.71,66.14 162.93,67.92 162.93,68.17 162.67,68.43 162.67,69.13 162.93,69.38 162.93,70.05 162.71,70.27 162.12,70.27 161.6,70.79 156.67,70.79 156.16,70.28 RC84.1
RF_+V1.05SP: length 3.5
  TOP w0.102: v1(238.21,77.8) 238.76,77.25 PR305.1
  TOP w0.254: PR305.1 239.13,76.38 239.13,75.31 238.9,75.08 PU300.5
RING2: length 0.7
  TOP w0.102: v2(273.65,47.54) v1(272.94,47.54)
  vias: v2(273.65,46.95) v2(274.24,46.61) v2(276.97,39.57) v2(277.18,39.01) v2(277.75,39.24)
RING2_L: length 17
  TOP w0.254: v2(274.93,54.01) v1(274.21,54.01)
  IN1 w2.032: 272.97,53.06 270.84,53.06 268.88,55.02 268.88,65.72 269.37,66.2
  vias: v2(274.98,53.43) v2(275.6,54.01) v2(275.59,53.43)
RSMRST#: length 4.6
  TOP w0.102: U41.3 38.61,14.31 v5(39.05,13.87) R440.2 U42.2
RSVD_AL1: length 4.2
  BOTTOM w0.076: UC1.AL1 152.2,65.85 153.09,64.97 153.85,64.97
  BOTTOM w0.102: 153.85,64.97 153.85,64.97 154.07,65.19 154.57,65.19 T56.1
RSVD_AM11: length 10.6
  TOP w0.102: v2(144.64,64.74) 144.77,64.74 145.15,64.36 145.15,60.87 145.02,60.74 143.72,60.74 143.37,60.39 143.37,56.77 T57.1
  BOTTOM w0.076: v2(144.64,64.74) 144.96,65.06 UC1.AM11
RSVD_AP7: length 8.9
  TOP w0.102: T59.1 147.37,56.93 147.37,58.39 147.31,58.46 147.31,59.92 148.07,60.68 148.07,62.71 148.39,63.02 148.39,64.05 v2(148,64.44)
  BOTTOM w0.076: UC1.AP7 147.65,64.09 v2(148,64.44)
RSVD_AT2: length 4.1
  BOTTOM w0.076: UC1.AT2 150.62,62.89 151.05,63.31 151.48,63.31 151.71,63.08 152.17,63.08 152.54,62.71 153.85,62.71
  BOTTOM w0.102: T50.1 153.91,62.71 153.85,62.71
RSVD_AU10: length 9.4
  TOP w0.102: v2(146.04,61.82) 145.87,61.82 145.44,61.39 145.44,60.68 145.31,60.55 143.8,60.55 143.56,60.31 143.56,55.46 T61.1
  BOTTOM w0.076: v2(146.04,61.82) 145.72,62.14 UC1.AU10
RSVD_AU15: length 5
  BOTTOM w0.076: T63.1 142.75,57.97 142.75,58.53 142.57,58.7 142.57,59.6 142.49,59.68 142.49,59.69 142.31,59.87 142.31,60.31 142.38,60.39 142.38,60.63 142.27,60.75 142.27,60.96 142.34,61.04 142.34,61.28 142.32,61.3 142.32,61.61 142.62,61.9 UC1.AU15
RSVD_AU44: length 4.3
  BOTTOM w0.076: UC1.AU44 124.08,62.07 123.67,61.66 123.67,58.09 T52.1
RSVD_AV44: length 6
  BOTTOM w0.076: UC1.AV44 123.94,61.49 123.83,61.38 123.83,59.22 125.08,57.97 T54.1
RSVD_AW14: length 4.2
  BOTTOM w0.076: UC1.AW14 143.7,60.54 143.7,58.89 144.09,58.5
  BOTTOM w0.089: T64.1 145.07,57.52 144.09,58.5
RSVD_AY14: length 4.8
  BOTTOM w0.076: UC1.AY14 143.4,58.93 144.74,57.59 144.74,56.32 T65.1
RSVD_D15: length 8
  TOP w0.102: T55.1 142.96,85.93 142.96,84.67 143.66,83.97 143.66,81.67 v2(142.53,80.54)
  BOTTOM w0.076: UC1.D15 142.84,80.85 v2(142.53,80.54)
RSVD_F22: length 8.6
  TOP w0.102: v2(138.74,83.67) 138.74,84.98 137.49,86.22 T58.1
  BOTTOM w0.076: UC1.F22 138.56,80.42 138.96,80.82 138.96,81.1 139.32,81.46 139.32,81.81 139.04,82.09 139.04,82.3 139.37,82.63 139.37,83.03 v2(138.74,83.67)
RSVD_H22: length 1.5
  TOP w0.102: v2(139.05,78.65) 139.05,79.39 T60.1
  BOTTOM w0.076: UC1.H22 138.67,78.27 v2(139.05,78.65)
RSVD_J21: length 2.4
  TOP w0.102: v2(139.59,78.08) 139.59,77.65 T62.1
  BOTTOM w0.076: UC1.J21 139.37,78.02 139.53,78.02 v2(139.59,78.08)
RSVD_N23: length 2.6
  TOP w0.102: v2(137.66,74.97) 136.91,75.72 T48.1
  BOTTOM w0.076: v2(137.66,74.97) 138.08,75.39 UC1.N23
RSVD_R23: length 2.4
  TOP w0.102: v2(137.08,74.98) 136.86,74.98 T49.1
  BOTTOM w0.076: UC1.R23 137.49,74.58 v2(137.08,74.98)
RSVD_T23: length 1.2
  TOP w0.102: T51.1 137.66,73.44 v2(137.78,73.32)
  BOTTOM w0.076: UC1.T23 137.78,73.39 v2(137.78,73.32)
RSVD_U10: length 1.9
  TOP w0.102: T53.1 144.49,74.04 v2(144.83,74.38)
  BOTTOM w0.076: UC1.U10 145.8,73.62 145.8,73.75 145.16,74.38 v2(144.83,74.38)
RUN_ON: length 385.7
  TOP w0.102: R154.1 266.19,23.04 v2(266.38,23.23) ; U37.A11 21.43,28.63 21.83,28.23 21.83,27.79 v2(21.82,27.78) 21.32,27.28 R303.2 ; v2(64.31,39.33) v5(64.31,39.91) ; Q5.2 32.85,24.65 33.11,24.9 33.11,25.21 32.64,25.68 30.02,25.68 29.29,26.41 v2(28.89,26.41)
  IN1 w0.084: v2(267.55,28.94) 267.47,28.87 267.47,25.56 266.95,25.04 266.95,24.13 266.38,23.56 v2(266.38,23.23)
  IN3 w0.122: v2(191,65.61) 190.51,66.1 184.49,66.1 182.11,63.72 182.11,52.6 167.98,38.48 136.38,38.48 130.92,33.01 130.17,33.01 128.72,31.57 128.72,30.69 128.37,30.33 127.56,30.33 125.24,32.66 122.98,32.66 118.56,37.08 68.66,37.08 65.74,40 64.99,40 v2(64.31,39.33)
  IN4 w0.084: v2(214.48,70.07) 214.24,70.07 213.78,69.61 213.1,69.61 212.67,70.03 209.86,70.03 209.19,69.36 205.56,69.36 204.56,68.36 201.13,68.36 199.43,66.67 192.4,66.67 191.99,66.26 191.99,65.44 191.67,65.13 191.25,65.13 191,65.38 v2(191,65.61) ; v2(262.38,74.87) 262.06,75.19 259.22,75.19 257.93,76.49 250.99,76.49 250.5,76.98 244.97,76.98 244.18,77.77 241.4,77.77 240.69,78.47 240.27,78.47 236.51,82.23 234.2,82.23 232.75,83.68 226.44,83.68 225.02,85.1 218.14,85.1 217.7,84.67 215.47,84.67 212.86,82.06 212.86,80.01 v2(212.08,79.23)
  BOTTOM w0.102: v2(64.31,39.33) 64.04,39.06 62.37,39.06 61.21,40.21 56.1,40.21 54.6,41.71 51.91,41.71 46.57,47.05 40.9,47.05 35.46,41.61 35.46,40 31.22,35.76 30.48,35.76 28.54,33.82 28.54,26.95 28.89,26.6 v2(28.89,26.41) 28.89,26.31 28.04,25.46 25.75,25.46 24.08,27.14 22.48,27.14 21.84,27.78 v2(21.82,27.78) ; v2(212.08,79.23) 210.44,79.23 208.92,77.71 208.92,76.91 209.45,76.38 209.83,76.38 210.27,75.93 R418.1 211.04,76.47 211.76,76.47 212.19,76.03 212.19,74.62 212.5,74.32 212.5,72.77 213.46,71.81 214.74,71.81 215.33,71.22 215.33,70.46 214.94,70.07 v2(214.48,70.07) ; v2(267.55,28.94) 267.55,29.95 269.55,31.94 269.55,38.04 269.35,38.23 269.35,40.03 268.82,40.56 268.82,47.27 267.64,48.45 267.64,72.94 265.98,74.6 262.64,74.6 262.38,74.85 v2(262.38,74.87) ; v2(191,65.61) 191,66.27 190.67,66.6 R426.1
RUN_ON#: length 2.7
  TOP w0.102: v1(35.47,22.49) 35.36,22.38 R36.2 34.47,22.44 Q5.6 Q5.5
RUNPWROK: length 188.2
  TOP w0.102: v2(28.51,14.14) 28.63,14.14 29.07,14.58 U38.B26 ; v2(32.56,25.06) 32.2,24.7 Q5.3 32.2,23.87 31.85,23.52 R35.2 ; v2(13.68,24.36) 13.87,24.17 v1(15.1,24.17) 16.57,24.17 18.08,25.67 18.08,28.37 17.93,28.52 U37.A4
  TOP w0.254: UC6.1 75.29,74.07 75.17,73.95 75.17,73.16 v2(75.03,73.02) ; v2(77.78,76.42) 77.78,76.42 77.83,76.37 UC6.10 ; UC6.13 76.33,76.29 v2(76.21,76.41) ; UC6.4 v2(77.33,71.78)
  IN2 w0.122: v2(67.09,81.78) 66.31,81 59.8,81 59.01,80.21 59.01,72.8 56.97,70.77 56.97,66.5 55.28,64.81 55.28,55.14 55.04,54.9 55.04,51.04 51.73,47.73 49.74,47.73 48.59,48.87 43.19,48.87 37.94,43.62 35.22,43.62 33.72,45.12 32.73,45.12 31.53,43.93 31.53,42.23 32.1,41.66 32.1,41 31.26,40.15 25.43,40.15 24.66,39.38 15.85,39.38 15.17,38.71 14.24,38.71 13.97,38.98 13.97,39.35 13.72,39.59 13.38,39.59 12.89,39.1 11.62,39.1 10.36,37.84 8.47,37.84 8.02,37.39 8.02,33.6 8.69,32.93 8.69,32.58 11.7,29.57 11.7,27.16 13.22,25.64 13.22,24.81 v2(13.68,24.36) 13.68,23.35 14.84,22.19 15.45,22.19 17.39,20.25 17.39,17.98 16.56,17.14 16.56,15.93 18.16,14.33 20.31,14.33 20.41,14.23 26.98,14.23 27.36,14.6 28.04,14.6 v2(28.51,14.14)
  IN4 w0.084: v2(76.21,76.41) 74.88,75.08 73.55,75.08 72.73,75.89 72.73,76.8 68.92,80.61 68.26,80.61 v2(67.09,81.78) ; v2(13.68,24.36) 13.68,24.04 15.12,22.6 22.04,22.6 23.23,23.79 23.71,23.79 25.59,25.67 30.84,25.67 31.46,25.06 v2(32.56,25.06)
SATA_ACT#: length 80.3
  TOP w0.102: v2(200.66,94.28) 200.66,94.59 200.4,94.85 Q24.4
  IN2 w0.089: v2(153.5,74.1) 153.5,74.24 151.47,76.26 151.47,77.28 151.22,77.53 151.22,84.38 152.41,85.57
  IN2 w0.122: 152.41,85.57 152.72,85.88 153.53,85.88 154.55,86.9 v2(154.55,88.38)
  IN4 w0.084: v2(154.55,88.38) 156.09,88.38 156.45,88.74 163,88.74 163.77,87.97 165.64,87.97 166.84,86.77 174.34,86.77 174.49,86.92 181.19,86.92 183.65,89.38 189.39,89.38 189.86,88.92 190.66,88.92 192.51,87.07 192.99,87.07 194.69,85.37 198.5,85.37 199.82,86.69 199.82,88.98 200.18,89.33 200.18,92.99 200.66,93.47 v2(200.66,94.28)
  BOTTOM w0.076: v2(153.5,74.1) 153.5,73.41 152.84,72.76 151.81,72.76 151.52,73.05 150.23,73.05 UC1.U3
SATA_COMP: length 7.1
  BOTTOM w0.076: 143.53,85.57 143.53,84.61 143.87,84.28 143.87,82.69 144.29,82.27 144.29,81.74 UC1.C12
  BOTTOM w0.102: RC19.1 v1(142.68,86.38) 142.76,86.31 142.98,86.31 143.53,85.76 143.53,85.57
SATA_IREF: length 5.3
  BOTTOM w0.254: RC14.2 143.83,87.65 v1(143.83,86.93) 143.83,84.85 144.16,84.53 UC1.A12
SATA_LED: length 31.3
  TOP w0.102: v1(185.37,100.29) 184.9,100.76 LED6.2 184.65,101.7 184.65,102.64 v2(184.8,102.79)
  IN2 w0.122: v2(205.97,99.61) 205.59,99.98 204.1,99.98 203.53,99.42 199.53,99.42 198.39,100.56 186.13,100.56 185.62,101.07 185.62,102.51 185.34,102.79 v2(184.8,102.79)
  BOTTOM w0.102: v2(205.97,99.61) 205.97,99.47 205.28,98.78 205.28,97.95 204.71,97.38 204.71,96.75 205.16,96.3 R430.2
SATA_PRX_DKTX_N0: length 7.6
  TOP w0.102: v2(127.99,110.52) 127.75,110.28 127.75,109.87 129.29,108.33 v3(129.29,107.62) 129.29,106.27 C313.2
  BOTTOM w0.102: JDOCK1.56 127.88,109.54 127.74,109.69 127.74,110.27 v2(127.99,110.52)
SATA_PRX_DKTX_N0_C: length 47.6
  TOP w0.102: v2(144.12,97.7) 144.35,97.48 144.35,97.35 143.98,96.98 135.28,96.98 135.04,96.74 v3(130.29,96.74) 129.54,96.74 129.08,97.2 129.08,99.92 129.16,100 129.16,104.5 C313.1
  IN2 w0.089: 144.11,85.57 144.11,85.56 144.13,85.54 144.13,84.42 144.81,83.74 145.24,83.74 145.47,83.52 145.47,83.06 146.72,81.8 146.72,78.79 147.06,78.46 147.44,78.46 147.83,78.07 148.04,78.07 148.2,77.91 v2(148.2,77.8)
  IN2 w0.132: v2(144.12,97.7) 144.36,97.47 144.36,95.54 144.65,95.25 144.65,92.09 143.94,91.38 143.94,89.04 143.84,88.95 143.84,86.91 144.11,86.64 144.11,85.57
  BOTTOM w0.076: UC1.J5 148.4,77.59 v2(148.2,77.8)
SATA_PRX_DKTX_P0: length 7.6
  TOP w0.102: C312.2 129.07,106.27 129.07,107.17 129.04,107.2 129.04,107.89 129.07,107.91 129.07,108.24 127.53,109.78 127.53,110.39 v2(127.4,110.52)
  BOTTOM w0.102: JDOCK1.54 127.38,109.55 127.52,109.69 127.52,110.36 127.52,110.36 127.52,110.4 v2(127.4,110.52)
SATA_PRX_DKTX_P0_C: length 47.7
  TOP w0.102: C312.1 128.94,104.75 128.94,100.09 128.86,100.01 128.86,97.11 129.45,96.52 129.93,96.52 129.96,96.49 130.62,96.49 130.65,96.52 135.13,96.52 135.37,96.76 144.07,96.76 144.57,97.26 144.57,97.56 v2(144.71,97.7)
  IN2 w0.089: v2(148.22,78.45) 148.04,78.27 147.92,78.27 147.52,78.66 147.14,78.66 146.93,78.88 146.93,81.89 145.67,83.15 145.67,83.6 145.33,83.95 144.89,83.95 144.34,84.5 144.34,85.54 144.36,85.56 144.36,85.57
  IN2 w0.132: 144.36,85.57 144.36,86.74 144.09,87.01 144.09,88.85 144.18,88.94 144.18,91.27 144.89,91.99 144.89,95.35 144.61,95.64 144.61,97.61 v2(144.71,97.7)
  BOTTOM w0.076: UC1.H5 148.42,78.24 v2(148.22,78.45)
SATA_PRX_DTX_N1: length 3.2
  TOP w0.102: v2(46.1,19.16) 45.83,19.43 45.63,19.43 C109.1
  BOTTOM w0.102: v2(46.1,19.16) 46.28,19.34 46.88,19.34 47.17,19.05 JMINI3.25
SATA_PRX_DTX_N1_C: length 142.4
  TOP w0.102: v2(43.52,19.24) 43.78,19.49 44.2,19.49 C109.2
  IN4 w0.091: v2(43.52,19.24) 43.79,19.51 44.63,19.51 45.32,20.2 47.03,20.2 49.4,22.57 49.4,22.62 50.51,23.73 50.51,24.12 52.63,26.24 52.63,27.89 53.82,29.08 53.82,29.97 55.87,32.02 55.87,33.85 58.39,36.38 58.39,36.96 64.84,43.41 69.16,43.41 81.69,55.94 96.4,55.94 99.64,59.17 99.64,63.72 101.39,65.47 109.01,65.47 110.56,67.03 112.34,67.03 113.21,67.89 113.21,75.51 113.79,76.1 115.11,76.1 116.18,77.16 116.48,77.16 117.04,76.61 136.76,76.61 138.69,74.68 139.65,74.68 140.54,75.57 142.5,75.57 142.72,75.79 142.72,76.43 142.91,76.61 145.81,76.61 146.83,77.63 147,77.63 v2(147.22,77.41)
  BOTTOM w0.076: UC1.J8 147.03,77.59 v2(147.22,77.41)
SATA_PRX_DTX_P1: length 3.2
  TOP w0.102: v2(46.1,19.74) 46.04,19.68 45.8,19.68 45.4,20.08 C108.1
  BOTTOM w0.102: v2(46.1,19.74) 46.28,19.56 46.89,19.56 47.18,19.85 JMINI3.23
SATA_PRX_DTX_P1_C: length 142.5
  TOP w0.102: v2(43.52,19.82) 43.65,19.7 44.11,19.7 44.49,20.08 C108.2
  IN4 w0.091: v2(43.52,19.82) 43.67,19.68 44.52,19.68 45.21,20.37 46.96,20.37 49.23,22.64 49.23,22.69 50.34,23.8 50.34,24.19 52.46,26.31 52.46,27.96 53.65,29.15 53.65,30.04 55.69,32.09 55.69,33.93 58.22,36.45 58.22,37.03 64.77,43.58 69.09,43.58 81.62,56.11 96.33,56.11 99.46,59.25 99.46,63.79 101.32,65.65 108.94,65.65 110.49,67.2 112.27,67.2 113.04,67.97 113.04,75.59 113.72,76.27 115.04,76.27 116.11,77.34 116.56,77.34 117.11,76.78 136.83,76.78 138.76,74.85 139.58,74.85 140.47,75.74 142.43,75.74 142.55,75.86 142.55,76.5 142.83,76.78 145.74,76.78 146.76,77.8 147.04,77.8 v2(147.28,78.04)
  BOTTOM w0.076: v2(147.28,78.04) 147.08,78.24 UC1.H8
SATA_PRX_MSATATX_N3: length 106.3
  IN1 w0.091: v2(201.94,75.36) 201.77,75.19 201.77,74.89 201.09,74.21 183.07,74.21 182,75.28 182,77.94 180.66,79.28 176.9,79.28 176,80.18 170.06,80.18 169.6,80.64 168.63,80.64 167.98,81.3 167.98,81.42 167.76,81.64 167.76,81.64 v2(167.76,81.64)
  IN2 w0.089: v2(148.13,79.79) 148.13,79.92 148.31,80.1 148.6,80.1 148.67,80.03 149.83,80.03 150.37,80.57 150.37,85.53 150.39,85.55 150.39,85.57
  IN2 w0.132: v2(167.76,81.64) 167.76,81.64 167.76,81.64 167.98,81.87 167.98,82.74 167.98,82.74 167.98,87.58 167.98,87.58 167.98,87.6 164.89,90.69 157.68,90.69 157.1,91.27 154.97,91.27 154.57,90.88 154.57,90.59 153.17,89.19 152.69,89.19 151.26,87.76 151.26,86.72 150.39,85.84 150.39,85.57 ; v2(202.74,52.97) 202.58,52.81 202.49,52.81 202.26,53.03 202.26,55.44 202.75,55.94 202.75,61.33 202.12,61.96 202.12,67.18 202.51,67.58 202.51,68.25 200.81,69.95 200.81,73.88 201.79,74.86 201.79,75.21 v2(201.94,75.36)
  BOTTOM w0.076: UC1.F5 148.67,79.7 148.39,79.98 148.32,79.98 v2(148.13,79.79)
  BOTTOM w0.102: v2(202.74,52.97) 203.07,52.64 204.86,52.64 205.38,53.16 206.49,53.16 206.68,53.35 JMINI2.25
SATA_PRX_MSATATX_P3: length 106.5
  IN1 w0.091: v2(201.36,75.36) 201.6,75.11 201.6,74.96 201.02,74.38 183.14,74.38 182.17,75.35 182.17,78.02 180.73,79.46 176.97,79.46 176.07,80.35 170.13,80.35 169.67,80.82 168.7,80.82 168.15,81.37 168.15,81.45 168.34,81.64 v2(168.34,81.64)
  IN2 w0.089: 150.14,85.57 150.14,85.56 150.17,85.54 150.17,80.65 149.75,80.24 148.75,80.24 148.69,80.3 148.3,80.3 v2(148.04,80.56)
  IN2 w0.132: v2(201.36,75.36) 201.55,75.17 201.55,74.96 200.57,73.98 200.57,69.85 202.27,68.15 202.27,67.68 201.87,67.28 201.87,61.86 202.51,61.23 202.51,56.04 202.01,55.54 202.01,52.93 202.39,52.56 202.57,52.56 v2(202.74,52.38) ; 150.14,85.57 150.14,85.94 151.02,86.82 151.02,87.86 152.59,89.44 153.07,89.44 154.33,90.69 154.33,90.98 154.86,91.52 157.2,91.52 157.79,90.94 164.99,90.94 168.23,87.7 168.23,87.48 168.23,87.48 168.23,82.84 168.23,82.84 168.23,81.75 168.34,81.64 v2(168.34,81.64)
  BOTTOM w0.076: UC1.E5 148.4,80.2 v2(148.04,80.56)
  BOTTOM w0.102: JMINI2.23 206.81,52.55 206.41,52.95 205.47,52.95 204.95,52.43 202.78,52.43 v2(202.74,52.38)
SATA_PTX_DKRX_N0: length 23.8
  TOP w0.102: v2(129.42,110.52) 129.05,110.15 129.05,109.86 129.73,109.18 130.47,108.44 v3(130.47,101.6) 130.47,97.89 130.93,97.43 134.59,97.43 134.84,97.68 136.78,97.68 137.25,98.15 137.9,98.15 C315.1
  BOTTOM w0.102: v2(129.42,110.52) 129.25,110.34 129.25,109.71 129.45,109.51 JDOCK1.62
SATA_PTX_DKRX_N0_C: length 20
  TOP w0.102: C315.2 139.31,98.16 139.9,98.16 140.04,98.3 141.05,98.3 141.36,97.99 v2(141.36,97.43)
  IN2 w0.132: v2(142.55,85.35) 142.39,85.19 142.25,85.19 142.14,85.3 142.14,85.83 141.73,86.24 141.73,91.27 141.81,91.35 141.81,95.31 141.31,95.81 141.31,97.39 v2(141.36,97.43)
  BOTTOM w0.076: UC1.B15 141.92,82.25 141.92,83.27 141.65,83.54 141.65,84.68 142.13,85.15 142.35,85.15 v2(142.55,85.35)
SATA_PTX_DKRX_P0: length 24
  TOP w0.102: v2(128.84,110.52) 128.84,109.77 129.58,109.03 130.25,108.36 130.25,101.94 130.23,101.92 130.23,101.19 130.25,101.17 130.25,97.8 130.84,97.22 134.68,97.22 134.93,97.46 136.87,97.46 137.34,97.93 137.73,97.93 C314.1
  BOTTOM w0.102: JDOCK1.60 128.95,109.44 129.03,109.52 129.03,110.32 v2(128.84,110.52)
SATA_PTX_DKRX_P0_C: length 20
  TOP w0.102: v2(140.77,97.43) 141.14,97.8 141.14,97.9 140.96,98.08 140.13,98.08 139.99,97.94 138.95,97.94 138.87,97.87 138.87,97.7 C314.2
  IN2 w0.132: v2(142.55,84.77) 142.38,84.94 142.15,84.94 141.89,85.2 141.89,85.73 141.49,86.14 141.49,91.38 141.57,91.46 141.57,95.21 141.07,95.71 141.07,97.13 140.77,97.42 v2(140.77,97.43)
  BOTTOM w0.076: UC1.A15 142.13,83.02 142.13,83.35 141.84,83.64 141.84,84.6 142.2,84.96 142.35,84.96 v2(142.55,84.77)
SATA_PTX_DRX_N1: length 3.2
  TOP w0.102: C106.1 45.72,16.42 46.01,16.42 v2(46.13,16.54)
  BOTTOM w0.102: v2(46.13,16.54) 46.31,16.36 46.81,16.36 47.11,16.65 JMINI3.31
SATA_PTX_DRX_N1_C: length 152.4
  TOP w0.102: C106.2 44.68,16.55 44.68,16.37 44.62,16.31 44.12,16.31 43.61,16.82 v3(43.61,17.92) 43.61,18.47 43.04,19.04 43.04,19.66 42.8,19.9 42.8,20.83 42.89,20.92 42.98,20.92 v2(43.22,20.68)
  IN4 w0.091: v2(141.47,85.09) 141.08,84.7 141.08,83.88 142.09,82.86 142.09,77.69 141.46,77.06 139.72,77.06 138.94,77.84 120.16,77.84 119.54,78.46 119.54,78.79 118.81,79.53 115.6,79.53 115.14,79.07 113.72,79.07 112.83,78.19 112.83,77.68 112.4,77.25 112,77.25 109.89,75.14 109.89,75.08 109.02,74.22 109.02,68.8 107.66,67.44 107.34,67.44 106.05,66.15 101.11,66.15 98.98,64.01 98.98,59.47 96.1,56.59 80.78,56.59 77.55,53.35 77.55,52.71 70.61,45.77 68.89,44.05 64.54,44.05 60.4,39.91 59.55,39.91 53.06,33.43 53.06,29.44 51.95,28.32 51.95,26.52 50.52,25.09 50.24,25.09 48.79,23.65 48.79,22.87 46.76,20.84 44.49,20.84 44.3,21.04 43.59,21.04 v2(43.22,20.68)
  BOTTOM w0.076: UC1.A17 141.29,83.11 141.29,84.91 v2(141.47,85.09)
SATA_PTX_DRX_P1: length 3.2
  TOP w0.102: v2(46.13,15.96) 45.98,16.1 45.66,16.1 C105.1
  BOTTOM w0.102: v2(46.13,15.96) 46.31,16.14 46.76,16.14 47.05,15.85 JMINI3.33
SATA_PTX_DRX_P1_C: length 152.5
  TOP w0.102: C105.2 44.26,16.08 44.03,16.08 43.38,16.72 43.38,18.37 42.81,18.94 42.81,19.56 42.57,19.8 42.57,20.92 42.79,21.14 43.11,21.14 v2(43.22,21.26)
  IN4 w0.091: v2(43.22,21.26) 43.27,21.21 44.37,21.21 44.57,21.02 46.69,21.02 48.62,22.94 48.62,23.72 50.17,25.26 50.45,25.26 51.77,26.59 51.77,28.39 52.89,29.51 52.89,33.5 59.48,40.09 60.33,40.09 64.46,44.22 68.82,44.22 70.49,45.89 76.94,52.34 77.38,52.78 77.38,53.43 80.71,56.76 96.03,56.76 98.81,59.54 98.81,64.08 101.04,66.32 105.98,66.32 107.27,67.61 107.59,67.61 108.85,68.87 108.85,74.29 109.72,75.16 109.72,75.21 111.93,77.42 112.33,77.42 112.66,77.75 112.66,78.26 113.65,79.24 115.07,79.24 115.52,79.7 118.88,79.7 119.71,78.87 119.71,78.54 120.24,78.01 139.01,78.01 139.79,77.23 141.39,77.23 141.92,77.76 141.92,82.79 140.91,83.81 140.91,85.07 v2(140.89,85.09)
  BOTTOM w0.076: UC1.B17 141.08,82.31 141.08,84.89 v2(140.89,85.09)
SATA_PTX_MSATARX_N3: length 89.6
  TOP w0.102: C244.1 205.21,59.75 205.21,60.31 204.61,60.91 204.61,63.12 204.36,63.37 204.36,65.19 204.38,65.21 204.38,65.91 204.36,65.94 204.36,67.18 203.91,67.63 202.9,68.64 199.01,68.64 198.55,68.19 192.43,68.19 192.27,68.35 192.27,68.53 v2(192.45,68.71)
  IN2 w0.132: v2(192.45,68.71) 192.3,68.87 192.3,74.73 191.73,75.29 191.2,75.29 v2(191.02,75.47)
  IN4 w0.091: v2(142.31,83.77) 142.52,83.98 142.52,84.1 142.95,84.53 144.14,84.53 144.26,84.41 145.07,84.41 146.24,85.57 152.53,85.57 152.95,85.99 155.88,85.99 156.95,87.06 159.64,87.06 160.6,86.1 164.67,86.1 165.68,85.09 165.68,84.15 166.6,83.24 169.68,83.24 170.83,82.09 171.11,82.09 172.84,80.37 176.14,80.37 177.95,78.55 177.95,77.11 178.18,76.89 180.44,76.89 182.87,74.46 189.74,74.46 190.52,75.24 190.8,75.24 v2(191.02,75.47)
  BOTTOM w0.076: v2(142.31,83.77) 142.51,83.57 142.51,83.18 142.68,83 142.68,82.71 142.41,82.44 142.41,82.12 141.91,81.62 UC1.C17
SATA_PTX_MSATARX_N3_C: length 5.7
  TOP w0.102: C244.2 205.24,58.19 205.24,57.24 206,56.48 206,55.77 206.36,55.41 v2(206.37,55.41)
  BOTTOM w0.102: v2(206.37,55.41) 206.36,55.41 206.08,55.69 206.08,55.9 206.33,56.15 206.51,56.15 206.91,55.75 JMINI2.31
SATA_PTX_MSATARX_P3: length 89.4
  TOP w0.102: C245.1 204.99,59.75 204.99,60.22 204.39,60.82 204.39,63.03 204.14,63.28 v3(204.14,65.56) 204.14,67.09 203.82,67.41 202.81,68.43 199.1,68.43 198.64,67.97 192.34,67.97 192.05,68.26 192.05,68.53 v2(191.87,68.71)
  IN2 w0.132: v2(191.02,74.88) 191.18,75.04 191.63,75.04 192.05,74.62 192.05,68.9 v2(191.87,68.71)
  IN4 w0.091: v2(142.89,83.77) 142.69,83.97 142.69,84.03 143.02,84.36 144.06,84.36 144.19,84.23 145.14,84.23 146.31,85.4 152.6,85.4 153.02,85.82 155.95,85.82 157.02,86.89 159.57,86.89 160.53,85.93 164.6,85.93 165.51,85.02 165.51,84.08 166.53,83.06 169.61,83.06 170.76,81.92 171.04,81.92 172.77,80.19 176.06,80.19 177.78,78.48 177.78,77.04 178.11,76.71 180.37,76.71 182.8,74.28 189.81,74.28 190.59,75.07 190.83,75.07 v2(191.02,74.88)
  BOTTOM w0.076: v2(142.89,83.77) 142.7,83.57 142.7,83.26 142.88,83.08 142.88,82.64 142.68,82.45 142.68,81.41 142.31,81.03 UC1.D17
SATA_PTX_MSATARX_P3_C: length 5.8
  TOP w0.102: v2(205.79,55.41) 205.79,56.39 205.61,56.57 205.59,56.57 v3(205.44,56.71) 205.28,56.88 205.28,56.89 205.03,57.15 205.03,58.11 C245.2
  BOTTOM w0.102: JMINI2.33 206.8,56.55 206.62,56.36 206.24,56.36 205.87,55.99 205.87,55.49 v2(205.79,55.41)
SB#: length 40.9
  TOP w0.102: U39.8 74.4,84.49 74.5,84.39 74.5,83.41 73.93,82.84 69.81,82.84 v2(69.09,82.12) ; R242.2 v1(50.98,74.14) 52.25,74.14 52.86,73.53 52.86,72.9 55.17,70.59 v2(55.17,70.33)
  IN2 w0.122: v2(55.17,70.33) 57.6,72.77 57.6,82.63 58.52,83.55 67.66,83.55 v2(69.09,82.12)
SD/MMCCD#: length 12.3
  TOP w0.102: R493.1 C256.1 249.81,15.23 250.84,15.23 251.16,14.91 v2(251.16,14.71) ; v2(254.15,19.09) 254.34,18.9 U27.21
  IN1 w0.084: v2(251.16,14.71) 251.69,15.24 251.69,17.47 253.3,19.09 v2(254.15,19.09)
  BOTTOM w0.102: v2(251.16,14.71) 250.47,15.39 JSD1.18
SD/MMCCLK: length 34
  TOP w0.102: v2(264.97,20.7) 264.97,21.01 C255.1 R230.2
  BOTTOM w0.102: v2(264.97,20.7) 263.89,19.62 263.89,17.57 261.99,15.66 260.83,15.66 260.71,15.53 260.71,14.32 260.58,14.2 260.31,14.2 260.21,14.3 260.21,16 260.11,16.1 259.91,16.1 259.81,16 259.81,14.3 259.71,14.2 259.5,14.2 259.4,14.3 259.4,16 259.3,16.1 259.1,16.1 258.99,16 258.99,14.3 258.89,14.2 258.69,14.2 258.59,14.3 258.59,16 258.49,16.1 258.28,16.1 258.18,16 258.18,14.3 258.08,14.2 254.02,14.2 251.42,16.79 JSD1.5
SD/MMCCLK_R: length 2.6
  TOP w0.102: R230.1 263.06,20.42 v1(262.18,20.42) 261.82,20.42 261.5,20.1 U27.43
SD/MMCCMD: length 36.7
  TOP w0.102: v2(262.75,20.98) 261.59,20.98 261.52,20.9 U27.45
  BOTTOM w0.102: JSD1.2 250.34,22.5 251.51,21.32 254.08,21.32 254.66,20.74 254.66,19.18 254.77,19.06 254.94,19.06 255.06,19.18 255.06,20.85 255.19,20.98 255.34,20.98 255.47,20.85 255.47,19.22 255.59,19.1 255.76,19.1 255.88,19.22 255.88,20.85 256,20.98 256.81,20.98 256.91,20.87 256.91,19.13 257.03,19.01 257.19,19.01 257.31,19.13 257.31,20.87 257.42,20.98 258.34,20.98 258.47,20.85 258.47,19.19 258.59,19.07 258.76,19.07 258.88,19.19 258.88,20.85 259,20.98 260.18,20.98 260.28,20.87 260.28,19.2 260.38,19.1 260.59,19.1 260.69,19.2 260.69,20.87 260.79,20.98 260.99,20.98 261.09,20.87 261.09,19.2 261.2,19.1 261.4,19.1 261.5,19.2 261.5,20.87 261.6,20.98 v2(262.75,20.98)
SD/MMCDAT0: length 21.8
  TOP w0.102: R231.1 268.97,13.18 L46.4 v2(268.97,14.33) ; v2(261.93,18.18) 261.85,18.1 U27.38 ; U27.30 257.79,15.96 v2(257.72,15.9)
  IN1 w0.084: v2(261.93,18.18) 262.12,18.37 262.12,18.47 262.01,18.58 261.1,18.58 259.89,17.37 258.52,17.37 257.54,16.4 257.54,16.08 v2(257.72,15.9)
  IN4 w0.084: v2(257.72,15.9) 257.72,15.54 258.12,15.15 268.15,15.15 v2(268.97,14.33)
SD/MMCDAT0_D: length 24.2
  TOP w0.102: R231.2 268.97,11.97 L46.3 268.97,10.2 v2(268.94,10.17)
  BOTTOM w0.102: JSD1.7 250.37,12.6 250.7,12.27 253.07,12.27 255.77,9.58 265.75,9.58 267.45,11.28 268.56,11.28 268.94,10.91 v2(268.94,10.17)
SD/MMCDAT1: length 23.8
  TOP w0.102: R297.1 268.12,13.18 L46.1 v2(268.12,14.36) ; v2(257.14,15.76) 257.14,15.96 257.39,16.2 U27.29 ; v2(262.56,18.14) 262.13,17.7 U27.37
  IN1 w0.084: v2(257.14,15.76) 257.29,15.9 257.29,16.5 258.42,17.63 259.79,17.63 260.99,18.83 262.09,18.83 262.37,18.55 262.37,18.33 v2(262.56,18.14)
  IN4 w0.084: v2(268.12,14.36) 268.33,14.56 268.33,14.67 268.06,14.94 258.03,14.94 257.51,15.45 257.51,15.54 257.3,15.76 v2(257.14,15.76)
SD/MMCDAT1_D: length 24
  TOP w0.102: v2(268.35,10.17) 268.47,10.29 268.47,10.82 268.12,11.17 L46.2 268.12,11.97 R297.2
  BOTTOM w0.102: v2(268.35,10.17) 268.45,10.27 268.45,10.71 268.36,10.79 267.73,10.79 266.03,9.09 255.56,9.09 252.87,11.79 250.61,11.79 250.5,11.68 250.5,11.31 250.39,11.2 JSD1.8
SD/MMCDAT2: length 3.4
  TOP w0.102: U27.48 261.5,22.1 261.93,22.53 261.93,23.24 v1(262.28,23.6) R341.1
SD/MMCDAT2_R: length 32.5
  TOP w0.102: R341.2 v2(264.9,23.6)
  BOTTOM w0.102: v2(264.9,23.6) 264.26,22.96 259.83,22.96 259,23.79 254.96,23.79 254.86,23.89 254.86,26.25 254.74,26.36 254.57,26.36 254.45,26.25 254.45,23.89 254.35,23.79 254.15,23.79 254.04,23.89 254.04,26.25 253.93,26.36 253.76,26.36 253.64,26.25 253.64,23.89 253.54,23.79 253.33,23.79 253.23,23.89 253.23,26.22 253.11,26.34 252.94,26.34 252.83,26.22 252.83,23.89 252.72,23.79 252.55,23.79 252.43,23.91 252.43,25.17 252.3,25.3 JSD1.9
SD/MMCDAT3: length 2.7
  TOP w0.102: R410.1 262.62,22.64 v1(262.21,22.23) 261.68,21.7 U27.47
SD/MMCDAT3_R: length 34.9
  TOP w0.102: R410.2 v2(264.9,22.64)
  BOTTOM w0.102: JSD1.1 251.54,23.9 251.64,23.8 251.64,22.96 251.74,22.86 251.74,22.63 251.84,22.53 252.14,22.53 252.25,22.63 252.25,22.86 252.35,22.96 252.65,22.96 252.75,22.86 252.75,22.63 252.86,22.53 253.16,22.53 253.26,22.63 253.26,22.86 253.36,22.96 253.7,22.96 253.81,22.86 253.81,22.43 253.91,22.33 254.11,22.33 254.21,22.43 254.21,23.18 254.33,23.3 254.49,23.3 254.62,23.18 254.62,21.58 254.74,21.46 254.91,21.46 255.02,21.58 255.02,23.18 255.14,23.3 255.31,23.3 255.43,23.18 255.43,21.58 255.55,21.46 255.72,21.46 255.84,21.58 255.84,23.18 255.96,23.3 256.12,23.3 256.24,23.18 256.24,22.15 256.36,22.03 256.53,22.03 256.65,22.15 256.65,23.18 256.77,23.3 256.94,23.3 257.06,23.18 257.06,21.58 257.18,21.46 257.34,21.46 257.46,21.58 257.46,23.18 257.58,23.3 257.75,23.3 257.87,23.18 257.87,22.15 257.99,22.03 258.16,22.03 258.28,22.15 258.28,23.18 258.4,23.3 258.6,23.3 258.72,23.18 258.72,22.58 258.83,22.48 264.73,22.48 v2(264.9,22.64)
SD_UHS2_D0N: length 7.9
  TOP w0.089: U27.34 259.39,16.29 259.43,16.25 v3(259.43,14.71) 259.43,10.98 259.73,10.68 L47.1 261,10.53 R315.1
SD_UHS2_D0N_D: length 42.6
  TOP w0.089: v2(270.38,10.45) 270.38,9.56 269.87,9.05 268.13,9.05 266.24,10.94 264.12,10.94 263.85,10.68 L47.2 262.41,10.53 R315.2
  BOTTOM w0.089: v2(270.38,10.45) 270.22,10.61 270.22,11.62 271.54,12.94 276.1,12.94 280.35,17.19 280.35,21.64 279.72,22.27 279.72,25.19 277.52,27.39 277.52,28.84 275.56,30.8 275.4,30.8 274.31,31.89 274.31,32.1 274.7,32.49 JSD1.12
SD_UHS2_D0P: length 7.8
  TOP w0.089: U27.35 259.79,16.29 259.75,16.25 v3(259.75,13.25) 259.75,11.11 259.86,10.99 260.19,10.99 260.26,11.06 260.26,11.44 260.34,11.53 L47.4 261,11.67 R306.1
SD_UHS2_D0P_D: length 42.6
  TOP w0.089: R306.2 262.41,11.67 L47.3 263.16,11.53 263.23,11.45 263.23,11.07 263.31,10.99 263.72,10.99 263.99,11.26 v3(264.85,11.26) 266.38,11.26 268.26,9.37 269.74,9.37 270.06,9.7 270.06,10.18 v2(269.79,10.45)
  BOTTOM w0.089: JSD1.11 273.6,32.49 273.99,32.1 273.99,31.76 275.27,30.48 275.43,30.48 277.2,28.71 277.2,27.25 279.4,25.06 279.4,22.14 280.03,21.51 280.03,17.32 275.97,13.26 271.41,13.26 269.9,11.75 269.9,10.56 v2(269.79,10.45)
SD_UHS2_D1N: length 10.1
  TOP w0.089: R337.1 261,9.58 L48.4 260.27,9.43 260.17,9.33 260.17,9.08 260.1,9 259.69,9 258.95,9.75 v3(258.95,10.07) 258.95,16.25 258.99,16.29 U27.33
SD_UHS2_D1N_D: length 40.3
  TOP w0.089: R337.2 262.41,9.58 L48.3 263.04,9.43 263.17,9.31 263.77,9.31 264.01,9.07 264.01,8.17 264.13,8.05 264.56,8.05 264.67,8.16 v3(264.67,8.99) 264.67,10.19 264.93,10.45 265.49,10.45 265.75,10.19 265.75,8.29 265.84,8.2 266.14,8.2 266.2,8.26 266.2,9.24 266.47,9.51 267,9.51 267.28,9.24 267.28,8.47 267.7,8.05 267.85,8.05 267.93,8.13 267.93,8.27 268.25,8.58 269.89,8.58 270.12,8.36 270.12,7.4 270.19,7.32 270.94,7.32 271.01,7.38 271.01,10.24 271.27,10.5 272.25,10.5 272.61,10.15 272.61,9.55 272.35,9.3 272.35,7.28 272.45,7.18 v2(272.45,7.16)
  BOTTOM w0.089: v2(272.45,7.16) 272.31,7.03 272.31,6.31 272.44,6.18 273.43,6.18 273.55,6.3 273.55,10.37 273.86,10.68 274.39,10.68 274.7,10.37 274.7,5.4 274.31,5 274.31,4.84 274.4,4.75 274.61,4.75 274.7,4.66 JSD1.15
SD_UHS2_D1P: length 10.4
  TOP w0.089: R333.1 261,8.43 L48.1 260.33,8.58 260.22,8.69 259.56,8.69 258.63,9.62 v3(258.63,12.23) 258.63,16.25 258.59,16.29 U27.32
SD_UHS2_D1P_D: length 40.1
  TOP w0.089: R333.2 262.41,8.43 L48.2 263.11,8.58 263.17,8.64 263.17,8.86 263.3,8.99 263.63,8.99 263.69,8.94 263.69,8.04 264,7.73 264.69,7.73 264.99,8.03 264.99,10.06 265.07,10.13 265.36,10.13 265.43,10.06 265.43,8.16 265.71,7.89 266.27,7.89 266.51,8.13 266.51,9.11 266.6,9.19 266.87,9.19 266.96,9.11 266.96,8.34 267.56,7.73 267.98,7.73 268.25,8 268.25,8.14 268.38,8.27 269.76,8.27 269.8,8.22 269.8,7.26 270.06,7 271.08,7 271.32,7.25 271.32,10.11 271.4,10.18 272.12,10.18 272.29,10.02 272.29,9.68 272.03,9.43 v3(272.03,8.93) 272.03,7.33 v2(271.86,7.16)
  BOTTOM w0.089: JSD1.16 273.6,4.66 273.69,4.75 273.9,4.75 273.99,4.84 273.99,5.14 274.38,5.53 274.38,10.24 274.26,10.36 273.99,10.36 273.86,10.24 273.86,6.17 273.56,5.87 272.31,5.87 272,6.18 272,7.03 v2(271.86,7.16)
SDWP: length 15.7
  TOP w0.102: U27.20 254.54,19.3 v2(254.11,19.73)
  IN1 w0.084: v2(254.11,19.73) 253.17,19.73 250.08,16.64 250.08,10.44 v2(251.13,9.38)
  BOTTOM w0.102: v2(251.13,9.38) 250.72,9.8 JSD1.19
SEL: length 3.3
  TOP w0.102: U39.4 72.9,87.53 72.7,87.73 72.24,87.73 72.06,87.55 R244.1 70.85,87.55 v1(70.36,88.05)
SIO_EXT_SCI#: length 200
  TOP w0.102: U38.A33 28.44,20.67 v2(28.5,20.74) ; v2(162.63,75.67) 162.63,75.18 v1(162.49,75.04) 161.66,74.21 RC199.1
  IN2 w0.089: v2(149.03,75.22) 149.1,75.22 149.48,74.84 152.34,74.84 152.91,74.28 152.91,73.85 153.49,73.27 153.85,73.27
  IN2 w0.122: 153.85,73.27 154.2,73.27 158.4,69.07 158.4,66.3 161.6,63.09 161.6,60.32 161.16,59.88 161.16,50.47 146.02,35.34 62.8,35.34 61.31,33.84 56.6,33.84 55.89,34.56 52.86,34.56 50.22,31.92 50.22,31.51 47.65,28.93 45.7,28.93 43.11,26.34 37.19,26.34 36.73,25.88 v2(33.96,25.88)
  IN3 w0.089: 153.85,75.16 153.72,75.29 151.7,75.29 151.38,75.6 149.42,75.6 v2(149.03,75.22)
  IN3 w0.122: v2(162.63,75.67) 162.22,76.08 161.85,76.08 161.57,75.8 161.57,74.94 160.34,73.71 158.77,73.71 157.32,75.16 153.85,75.16
  BOTTOM w0.076: v2(149.03,75.22) 148.94,75.22 UC1.N5
  BOTTOM w0.102: v2(28.5,20.74) 29.2,20.74 31.4,22.94 31.78,22.94 34,22.94 34.66,23.6 34.66,25.15 33.96,25.85 v2(33.96,25.88)
SIO_EXT_SMI#: length 219.4
  TOP w0.102: RP7.5 161.26,69.31 161.06,69.11 161.06,68.62 v2(160.93,68.49) ; v2(23.21,7.72) 23.23,7.72 23.71,8.2 23.71,8.55 23.44,8.82 U38.A6
  IN1 w0.084: v2(23.21,7.72) 23.21,7.74 22.83,8.12 22.83,11.12 22.68,11.26 22.68,14.43 22.68,14.43 22.68,18.82 22.53,18.97 22.53,22.7 23.65,23.82 23.65,26.54 23.01,27.18 21.37,27.18 20.81,27.74 v2(20.57,27.74)
  IN2 w0.089: v2(148.86,68.38) 148.88,68.38 149.16,68.1 149.16,67.29 148.51,66.64 148.51,65.84 148.39,65.72 148.39,61.44 148.45,61.38 148.45,58.65 148.62,58.48 v2(148.62,58.47) 148.84,58.24 148.84,53.94 147.88,52.98 147.88,51.62 148.07,51.43 148.07,51.41
  IN2 w0.122: v2(165.42,58.18) 165.42,58.33 164.69,59.05 164.69,59.64 164.06,60.27 164.06,62.12 163.91,62.27 163.91,62.52 163.75,62.67 163.75,63.13 163.94,63.32 163.94,64.46 163.4,65 162.88,65 161.66,66.22 161.36,66.22 160.72,66.87 160.72,68.27 v2(160.93,68.49) ; v2(20.57,27.74) 20.78,27.74 21.28,27.24 23.64,27.24 24.02,27.61 24.02,28.64 24.31,28.93 24.88,28.93 25.07,28.74 25.07,28.17 25.39,27.85 26.44,27.85 28.9,30.31 28.9,32.8 30.74,34.64 35.08,34.64 35.22,34.77 38.95,34.77 40.18,36.01 43.07,36.01 44.77,37.71 45.81,37.71 49.3,41.2 50.68,41.2 52.77,43.28 54.55,43.28 54.83,43 117.31,43 118.36,44.05 143.38,44.05 148.07,48.74 148.07,51.41
  IN3 w0.122: v2(165.42,58.18) 165.13,58.47 162.16,58.47 160.98,57.29 156.43,57.29 156.2,57.06 150.66,57.06 149.25,58.47 v2(148.62,58.47)
  BOTTOM w0.076: UC1.AG5 148.64,68.14 148.86,68.36 v2(148.86,68.38)
  BOTTOM w0.102: v1(164.77,58.27) 165.33,58.27 v2(165.42,58.18)
SIO_EXT_WAKE#: length 190.5
  TOP w0.102: U37.B49 17.18,38.8 17.46,38.52 v2(17.46,38.4) ; v2(153.19,59.88) 153.19,59.6 155.08,57.72 155.08,57.33 155.49,56.92 RP10.6
  IN1 w0.084: v2(17.46,38.4) 18.04,37.83 18.04,37.22 17.58,36.76 15.76,36.76 15.49,36.49 15.49,30.3 16.46,29.33 16.46,28.47 16.03,28.04 16.03,26.71 16.81,25.94 16.81,25.15 v2(16.83,25.14)
  IN2 w0.089: 153.85,52.54 153.02,53.37 153.02,57.25 151.97,58.3 151.97,58.98 152.88,59.88 v2(153.19,59.88)
  IN2 w0.122: 153.85,52.54 154.57,51.82 154.57,47.06 144.91,37.41 60.47,37.41 59.79,36.73 59.21,36.73 59.06,36.88 59.06,37.16 58.3,37.92 54.99,37.92 53.72,36.65 53.19,36.65 50.46,33.92 49.01,33.92 48.36,33.27 48.36,32.56 45.73,29.93 45.3,29.93 43.61,28.24 42.02,28.24 41.57,27.79 38.02,27.79 37.62,28.19 35.71,28.19 34.91,27.4 32.93,27.4 32.16,26.62 30.63,26.62 29.89,27.35 25.65,27.35 24.81,26.52 20.05,26.52 19.36,25.82 18.15,25.82 17.29,24.96 17.01,24.96 v2(16.83,25.14)
  BOTTOM w0.076: v2(153.19,59.88) 152.2,60.87 152.2,61.86 152.24,61.9 152.24,62.31 152.06,62.49 150.94,62.49 UC1.AU2
SIO_PWRBTN#: length 186.4
  TOP w0.102: RC107.1 70.93,58.33 v2(71.17,58.33) ; U38.B58 21.12,15.58 21.4,15.86 v2(21.4,16)
  IN1 w0.084: v2(66.68,45.06) 69.33,45.06 71.11,46.84 71.11,52.34 72.36,53.6 72.36,58.01 72.05,58.33 v2(71.17,58.33)
  IN2 w0.089: v2(147.58,66.52) 147.59,66.51 147.59,62.34 147.15,61.9 147.15,58.63 148.06,57.72 148.06,55.53 147.69,55.16 147.69,53.66 146.5,52.47 146.5,51.41
  IN2 w0.122: 146.5,51.41 146.5,49.73 142.41,45.63 117.61,45.63 116.61,44.63 67.1,44.63 v2(66.68,45.06) 66.25,44.63 56.8,44.63 v2(56.43,44.26)
  IN4 w0.084: v2(56.43,44.26) 56.43,41 54.54,39.12 53.99,39.12 50.32,35.44 50.32,30.96 48.25,28.88 48.25,26.95 45.51,24.21 43.66,24.21 43.11,24.76 39.88,24.76 38.5,23.38 37.35,23.38 36.29,22.32 32.95,22.32 32.55,22.72 25.62,22.72 24.34,21.44 24.34,20.49 22.7,18.85 22.7,17.3 v2(21.4,16)
  BOTTOM w0.076: UC1.AL7 147.54,66.47 v2(147.58,66.52)
SIO_RCIN#: length 189.3
  TOP w0.102: RP2.6 157.15,74.79 156.79,75.15 156.39,75.15 156.03,74.79 154.08,74.79 153.07,75.79 148.53,75.79 148.11,75.38 148.11,74.88 148.31,74.68 149.33,74.68 150.05,73.95 150.05,73.38 149.92,73.25 148.93,73.25 v2(148.82,73.14) ; v2(30.89,15.83) U38.A27
  IN1 w0.084: v2(31.92,27.14) 31.93,27.14 31.93,27.15 31.57,26.8 31.57,23.11 31.06,22.61 31.06,20.37 30.75,20.06 30.75,19.82 30,19.06 30,16.71 v2(30.89,15.83)
  IN2 w0.089: v2(148.82,73.14) 149.88,73.14 151.06,71.97 151.06,66.73 151.44,66.34 151.44,63.61 151.49,63.56 151.49,62.77 151.02,62.31 151.02,60.53 151.15,60.4 151.15,58.37 152.43,57.09 152.43,52.95 153.57,51.82 153.57,51.41
  IN2 w0.122: 153.57,51.41 153.57,47.48 144.5,38.41 59.22,38.41 58.71,38.92 54.03,38.92 50.1,34.99 48.67,34.99 47.36,33.69 47.36,32.98 45.32,30.93 41.5,30.93 40.96,31.47 35.87,31.47 33.83,29.42 33.83,29.04 31.93,27.14 v2(31.92,27.14)
  BOTTOM w0.076: UC1.V4 149.32,72.64 v2(148.82,73.14)
SIO_SLP_A#: length 372.7
  TOP w0.102: v2(43.53,47.71) 42.66,47.71 39.72,44.77 38.64,44.77 38.51,44.89 JAPS1.6 ; v2(202.92,32.49) 202.65,32.75 v5(199.07,32.75) 198.79,32.75 197.14,34.4 196.42,34.4 R423.1 ; UC7.1 70.61,72.19 v2(70.54,72.11) ; v2(17.06,33.44) 17.07,33.44 16.65,33.02 U37.B63
  TOP w0.254: PR303.1 v2(241.48,72.55)
  IN1 w0.084: v2(43.53,47.71) 40.98,47.71 36.74,43.47 30,43.47 29.66,43.81 26.96,43.81 26.62,43.47 25.87,43.47 25.09,42.69 25.09,41.13 24.27,40.32 23.36,40.32 22,41.67 20.36,41.67 20.26,41.57 18.71,41.57 18.3,41.16 18.3,37.19 17.94,36.83 17.94,34.31 17.07,33.44 17.07,33.44 v2(17.06,33.44) ; v2(148.14,66.46) 148.14,66.64 147.89,66.89 147.43,66.89 147.39,66.85 146.38,66.85 145.28,65.75 143.89,65.75 143.23,66.41 142.57,66.41 141.58,67.4 141.58,67.89 141.11,68.36 139.74,68.36 139.47,68.1 137.57,68.1 136.63,69.04 116.92,69.04 116.64,69.32 116.26,69.32 115.6,69.98 113.02,69.98 112.31,69.27 111.29,69.27 110.96,68.94 110.33,68.94 110.01,69.25 109.6,69.25 109.53,69.33 109.14,69.33 107.27,71.19 94.99,71.19 94.05,72.13 94.05,73.82 91.83,76.04 88.95,76.04 88.58,76.41 88.58,77.26 88.13,77.71 72.51,77.71 70.54,75.74 v2(70.54,72.11) 69.77,72.11 69.6,71.94 69.6,64.17 67.65,62.22 67.65,48.17 63.16,43.68 v2(63.16,39.48)
  IN2 w0.122: v2(181.22,69.67) 181.22,68.9 182.08,68.03 182.08,51.85 187.51,46.42 190.64,46.42 192.23,44.83 193.24,44.83 194.08,44 194.08,43.2 194.83,42.45 195.21,42.45 195.83,41.83 198.05,41.83 200.58,39.29 200.58,34.44 202.54,32.49 v2(202.92,32.49)
  IN4 w0.084: v2(202.92,32.49) 202.65,32.49 202,33.14 202,37.75 205.06,40.81 205.06,42.64 204.34,43.36 204.34,51.2 205.14,52 205.14,63 205.33,63.19 205.33,64.59 209.26,68.52 213.87,68.52 215.82,70.47 241.26,70.47 242.06,71.27 242.06,72.26 241.77,72.55 v2(241.48,72.55) ; v2(148.14,66.46) 148.58,66.03 149.03,66.03 149.42,65.65 151.83,65.65 152.74,64.73 155.15,64.73 155.77,65.35 159.61,65.35 163.29,61.66 165.14,61.66 166.37,62.89 166.37,62.92 170.14,66.7 170.82,66.7 171.03,66.92 177.99,66.92 178.57,67.5 178.57,68.48 179.07,68.97 180.18,68.97 180.48,69.28 180.82,69.28 v2(181.22,69.67)
  BOTTOM w0.076: UC1.AL5 148.36,66.04 148.14,66.26 v2(148.14,66.46)
  BOTTOM w0.102: v2(43.53,47.71) 43.93,48.1 45.63,48.1 46.22,47.51 46.76,47.51 52.1,42.17 54.79,42.17 56.29,40.66 61.98,40.66 63.16,39.49 v2(63.16,39.48)
SIO_SLP_LAN#: length 232.4
  TOP w0.102: R196.2 196.63,39.15 v1(187.44,39.15) v2(186.93,39.66) ; U37.A5 18.43,28.39 v2(18.48,28.34)
  IN2 w0.089: v2(146.95,67.4) 147.03,67.32 147.03,66.29 147.24,66.08 147.24,62.49 146.79,62.05 146.79,58.48 147.29,57.99 147.29,56.87 147.05,56.63 147.05,53.52 145.5,51.97 145.5,51.41
  IN2 w0.122: v2(18.48,28.34) 18.48,28.43 19.24,29.18 23.83,29.18 25.66,31.01 25.66,32.89 26.28,33.5 27.81,33.5 29.95,35.64 34.66,35.64 36.03,37.01 42.65,37.01 44.35,38.71 45.11,38.71 51.12,44.73 54.94,44.73 55.85,45.64 61.49,45.64 61.92,46.07 67.09,46.07 67.52,45.64 116.19,45.64 117.19,46.64 141.99,46.64 145.5,50.15 145.5,51.41
  IN4 w0.084: v2(186.93,39.66) 185.31,39.66 183.95,41.02 160.2,41.02 154.12,47.1 154.12,50.42 150.78,53.77 149.55,53.77 148.61,54.7 148.61,55.92 147.72,56.81 146.92,56.81 144.45,59.28 144.45,59.74 143.59,60.6 143.59,62.61 143.28,62.91 143.28,65.19 144.06,65.96 145.45,65.96 146.89,67.4 v2(146.95,67.4)
  BOTTOM w0.076: v2(146.95,67.4) 147.34,67.01 UC1.AJ7
SIO_SLP_S0#: length 195.3
  TOP w0.102: v2(49.39,33.01) 49.14,33.01 44.25,37.9 43.21,37.9 42.78,38.33 42.37,38.33 39,41.69 v5(38.79,41.69) 38.7,41.6 35.38,41.6 35.1,41.88 JAPS1.15 ; v2(26.94,20.77) U38.A36
  IN2 w0.089: v2(152.45,69.51) 153.11,68.85 153.85,68.85
  IN2 w0.122: v2(49.39,33.01) 50.6,33.01 53.5,35.91 54.03,35.91 55.29,37.17 57.99,37.17 58.24,36.92 58.24,35.99 58.47,35.76 59.97,35.76 60.39,36.18 61.87,36.18 62.28,36.59 145.5,36.59 156.93,48.01 156.93,53.45 154.62,55.76 154.62,60.25 154.2,60.67 154.2,63.87 155.63,65.3 155.63,66 155.5,66.14 155.5,67.39 154.04,68.85 153.85,68.85
  BOTTOM w0.076: 152.14,69.21 152.08,69.14 151.67,69.14 151.67,69.14 151.15,69.14 150.98,68.97 150.98,68.79 150.75,68.56 150.23,68.56 UC1.AF3
  BOTTOM w0.102: 152.14,69.21 v2(152.45,69.51) ; v2(26.94,20.77) 27.46,20.77 27.82,21.14 28.46,21.14 28.46,21.14 29.28,21.14 31.3,23.16 32.7,23.16 33.45,23.91 33.45,25.48 33.45,25.97 33.85,26.37 33.85,29.47 37.07,32.69 42.68,32.69 43.88,33.89 45.4,33.89 46.29,33.01 v2(49.39,33.01)
