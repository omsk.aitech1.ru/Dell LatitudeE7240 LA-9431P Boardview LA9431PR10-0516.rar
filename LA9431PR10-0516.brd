# Allegro board LA9431PR10-0516.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_S3#: length 332.1
  TOP w0.102: JAPS1.2 39.55,46.92 39.55,47.09 40.41,47.95 41.35,47.95 43.03,49.63 48.9,49.63 v5(49.17,49.91) 49.51,50.24 55.15,50.24 v2(55.33,50.07) ; U37.B65 16.47,32.02 v2(17.01,32.55)
  TOP w0.254: PR211.1 120.74,7.29 122.03,8.58 122.03,12.66 122.75,13.37 122.75,14.96 123.13,15.34 128.59,15.34 129.12,15.88 131.9,15.88 132.19,16.17 132.85,16.17 v2(133.14,15.88)
  IN2 w0.089: 151.77,51.41 151.77,52.27 150.21,53.83 150.21,60.05 150.13,60.12 150.13,62.54 149.71,62.96 v2(149.71,63.23)
  IN2 w0.122: 151.77,51.41 151.77,48.52 144.18,40.93 v2(133.3,40.93) 132.86,40.49 58.96,40.49 58.7,40.75 54.23,40.75 v2(53.7,41.28)
  IN3 w0.122: v2(55.33,50.07) 54.07,50.07 52.23,48.23 48.69,48.23 48.27,48.65 37.53,48.65 34.17,45.29 32.15,45.29 30.61,43.75 30.1,43.75 27.25,40.89 25.46,40.89 24.38,39.81 20.5,39.81 20.06,39.37 18.26,39.37 18.09,39.2 17.27,39.2 17.01,38.94 16.39,38.94 15.83,38.37 15.83,33.47 16.36,32.93 16.51,32.93 16.89,32.55 v2(17.01,32.55)
  IN4 w0.084: v2(214.86,70.62) 214.3,70.62 213.51,69.84 213.21,69.84 212.8,70.24 209.78,70.24 209.11,69.57 205.45,69.57 204.46,68.58 201.04,68.58 199.34,66.88 192.29,66.88 191.58,66.17 v2(191.58,65.61) ; v2(55.33,50.07) 55.49,49.91 55.49,47.74 52.95,45.2 52.95,42.03 v2(53.7,41.28) ; v2(184.04,69.19) 183.86,69.01 180.61,69.01 178.21,66.61 171.02,66.61 170.9,66.49 170.23,66.49 166.71,62.97 166.71,61.35 166.27,60.91 163.45,60.91 159.54,64.82 156.07,64.82 154.02,62.78 150.09,62.78 149.71,63.15 v2(149.71,63.23)
  BOTTOM w0.076: UC1.AT4 149.32,62.84 v2(149.71,63.23)
  BOTTOM w0.102: v2(214.86,70.62) 214.86,71.28 214.57,71.58 213.37,71.58 212.27,72.68 212.27,74.23 211.96,74.53 211.96,75.7 211.72,75.95 R417.1 ; v2(184.04,69.19) 183.58,68.73 183.58,67.21 184.19,66.6 R425.1 189.9,67.09 190.87,67.09 191.58,66.38 v2(191.58,65.61) ; v2(133.3,40.93) 132.28,39.92 132.28,31.2 133.08,30.4 133.08,25.13 132.47,24.52 132.47,20.55 133.74,19.28 133.74,16.48 v2(133.14,15.88)
SIO_SLP_S4#: length 397.2
  TOP w0.102: v2(147.51,67.45) 147.51,67.4 147.87,67.04 153.61,67.04 154.22,67.65 155.31,67.65 155.77,67.2 T12.1 ; v2(13.37,31.98) 13.66,32.27 U37.A61 ; v2(197.52,32.98) 197.31,33.2 R421.1 ; v2(45.47,47.69) 44.39,48.77 43.39,48.77 43.15,48.53 43.15,48.52 39.63,45 38.94,45 JAPS1.5
  TOP w0.254: PR207.1 120.88,10.85 v2(121.16,11.12)
  IN1 w0.084: v2(62.57,39.5) 62.57,43.4 67.44,48.26 67.44,62.3 69.15,64.02 69.15,72.31 69.92,73.09 69.92,75.42 72.42,77.93 88.21,77.93 89.06,77.08 91.09,77.08 94.26,73.91 94.26,72.22 95.07,71.4 107.36,71.4 109.21,69.56 109.6,69.56 109.69,69.47 110.07,69.47 110.4,69.14 110.8,69.14 111.07,69.42 111.07,70.01 111.21,70.15 115.75,70.15 116.08,69.82 117.36,69.82 117.39,69.79 135.21,69.79 135.61,69.39 136.53,69.39 137.12,68.8 137.44,68.8 138.34,69.7 139.38,69.7 140.55,68.53 145.94,68.53 146.66,67.82 147.15,67.82 147.52,67.45 v2(147.51,67.45)
  IN3 w0.122: v2(197.52,32.98) 197.1,32.98 194.97,30.84 193.99,30.84 193.52,31.32 193.52,32.44 192.62,33.33 189.99,33.33 188.86,32.2 188.86,32.19 188.52,31.85 187.19,31.85 186.15,32.89 185.81,32.89 184.73,33.97 139.72,33.97 133.64,27.9 133.64,27.36 132.17,25.88 132.17,25.58 131.79,25.2 v2(131.67,25.2)
  IN4 w0.084: v2(121.16,11.12) 120.68,11.61 120.68,14.83 121.44,15.6 121.44,23.61 124.03,26.2 130.36,26.2 131.37,25.2 v2(131.67,25.2) ; v2(197.52,32.98) 197.14,32.6 193.81,32.6 193.36,32.14 187.8,32.14 181.77,38.18 160.18,38.18 153.91,44.45 153.91,50.34 150.65,53.59 149.48,53.59 148.44,54.63 148.44,55.85 147.65,56.64 146.85,56.64 144.28,59.21 144.28,59.67 143.42,60.53 143.42,62.54 143.11,62.84 143.11,65.26 143.78,65.92 143.78,66.61 143.94,66.78 143.94,67.92 144.13,68.11 146.32,68.11 146.61,67.82 147.14,67.82 v2(147.51,67.45) ; v2(13.37,31.98) 12.95,32.4 12.95,33.68 13.23,33.96 13.96,33.96 14.15,34.15 14.15,35.31 13.91,35.56 12.66,35.56 12.22,36 12.22,38.68 14.58,41.04 15.99,41.04 16.53,41.59 18.44,41.59 18.63,41.78 20.01,41.78 20.11,41.87 22.16,41.87 23,42.71 24.91,42.71 25.86,43.66 28.12,43.66 29.05,44.58 30.63,44.58 31.93,45.89 33.4,45.89 36.69,49.18 43.98,49.18 v2(45.47,47.69)
  BOTTOM w0.076: v2(147.51,67.45) 147.51,67.45 147.99,66.97 UC1.AJ6
  BOTTOM w0.102: v2(45.47,47.69) 45.87,47.28 46.66,47.28 52,41.94 54.69,41.94 56.2,40.44 61.63,40.44 v2(62.57,39.5)
SIO_SLP_S5#: length 271.1
  TOP w0.102: T11.1 158.21,54.46 v2(158.21,53.75) ; U38.A18 30.39,11.33 31.04,10.68 v2(31.04,10.54) ; JAPS1.4 38.43,46.77 v2(38.41,46.77)
  IN1 w0.084: v2(31.93,30.98) 32.58,30.33 32.58,28.61 31.11,27.14 31.11,23.31 30.6,22.8 30.6,20.56 30.29,20.25 30.29,20.01 29.53,19.25 29.53,17.25 28.89,16.61 28.25,16.61 28,16.37 28,14.96 28.33,14.63 29.08,14.63 29.83,13.88 29.83,11.75 v2(31.04,10.54)
  IN2 w0.089: v2(148.83,64.48) 149.27,64.04 149.27,63.59 149.05,63.38 149.05,63.02 149.48,62.59 149.48,60.5 149.02,60.05 149.02,58.46 149.43,58.05 149.43,56.54 149.02,56.13 149.02,53.87 148.18,53.03 148.18,51.64 148.4,51.42 148.4,51.41
  IN2 w0.122: v2(38.41,46.77) 38.02,46.39 36.44,46.39 35.92,45.87 31.91,45.87 27.57,41.53 25.25,41.53 24.14,40.42 18.87,40.42 17.87,41.43 14.94,41.43 13.86,40.35 11.26,40.35 10.13,39.22 9.08,39.22 8.62,38.76 8.33,38.76 7.02,37.45 7.02,33.22 7.76,32.48 7.76,31.6 9.96,29.4 9.96,27.22 10.27,26.9 10.91,26.9 12.47,25.34 12.47,23.04 15.32,20.19 15.32,18.97 14.18,17.84 14.18,14.66 15.11,13.74 15.11,12.72 16.8,11.02 18.91,11.02 19.63,11.74 22.11,11.74 22.53,12.17 25.15,12.17 27.18,10.13 29.04,10.13 29.67,10.76 30.82,10.76 v2(31.04,10.54) ; 148.4,51.41 148.4,48.71 143.49,43.8 118.46,43.8 117.42,42.75 54.72,42.75 54.45,43.03 52.87,43.03 50.79,40.95 49.47,40.95 45.98,37.46 44.87,37.46 43.17,35.76 40.29,35.76 38.99,34.47 36.38,34.47 34.53,32.61 33.56,32.61 v2(31.93,30.98)
  IN4 w0.084: v2(158.21,53.75) 157.44,54.52 156.78,54.52 154.36,56.94 154.36,59.57 153.2,60.74 149.26,60.74 148.39,61.61 148.39,64.16 148.7,64.48 v2(148.83,64.48)
  BOTTOM w0.076: v2(148.83,64.48) 148.76,64.48 UC1.AP5
SIO_SLP_SUS#: length 169.2
  TOP w0.102: U37.B6 18.68,30.11 18.92,30.35 18.92,30.84 v2(18.49,31.27)
  IN2 w0.089: v2(151.99,63.86) 151.84,63.7 151.84,62.62 151.38,62.16 151.38,60.68 151.5,60.55 151.5,58.52 152.8,57.22 152.8,53.23 153.85,52.19
  IN2 w0.122: 153.85,52.19 154.32,51.72 154.32,47.17 144.81,37.66 58.91,37.66 58.4,38.17 54.84,38.17 53.63,36.96 53.13,36.96 50.42,34.24 48.98,34.24 48.11,33.38 48.11,32.67 45.63,30.18 42.97,30.18 v2(42.34,29.55)
  IN4 w0.084: v2(18.49,31.27) 18.58,31.27 18.97,31.66 19.61,31.66 20.31,30.96 21.58,30.96 22.4,30.14 24.75,30.14 25.12,30.5 27.86,30.5 29.22,31.86 32.32,31.86 34.28,29.9 41.99,29.9 v2(42.34,29.55)
  BOTTOM w0.076: UC1.AP4 149.63,63.95 150.09,63.95 150.15,63.9 150.92,63.9 151.08,64.06 151.79,64.06 v2(151.99,63.86)
SIO_SLP_WLAN#: length 160.9
  TOP w0.102: v1(24.77,27.94) 24.77,28.35 v2(24.63,28.49) 24.61,28.47 23.23,28.47 22.93,28.77 U37.A14
  IN2 w0.089: v2(148.89,66.41) 148.92,66.41 149.52,65.81 149.72,65.81 150.65,64.88 150.65,63.4 150.78,63.27 150.78,63.09 150.31,62.63 150.31,60.19 150.41,60.1 150.41,58.1 151.11,57.39 151.11,53.37 152.12,52.37 152.12,51.41
  IN2 w0.122: v2(24.63,28.49) 24.63,28.17 25.19,27.6 31.68,27.6 33.32,29.25 33.32,29.63 36.86,33.17 42.79,33.17 43.53,33.91 44.6,33.91 46.68,36 49,36 53.5,40.5 58.57,40.5 58.83,40.24 143.84,40.24 152.12,48.52 152.12,51.41
  BOTTOM w0.076: UC1.AM5 148.37,65.62 148.89,66.14 v2(148.89,66.41)
SKIP#: length 4.4
  TOP w0.102: PR520.2 85.34,73.14 84.14,73.14 v1(83.99,73.29)
  TOP w0.203: 86.54,72.19 87.05,72.19 87.3,72.44 PU500.7
  TOP w0.254: PR520.2 86.11,72.62 86.54,72.19
SKIP#1: length 8.7
  TOP w0.102: v1(83.43,71.44) 83.43,71.78 84.16,72.52 v2(84.16,72.62)
  TOP w0.254: PR520.1 v2(84.16,72.62)
  IN4 w0.254: v2(84.16,72.62) 83.64,72.1 83.64,68.97 v2(84.13,68.49)
  BOTTOM w0.203: v2(84.13,68.49) 84.75,68.49 84.87,68.36 84.87,68.02 84.77,67.92 PU501.1
SL_BAT_PRES#: length 2.2
  TOP w0.254: PU800.21 7.78,31.64 7.93,31.79 7.93,32.63 7.85,32.7 PR860.1
SLATE_MODE_R: length 19
  TOP w0.102: RP9.7 163.02,66.74 162.93,66.65 162.93,65.64 v2(162.91,65.62)
  IN3 w0.089: v2(149.66,66.2) 149.66,66.13 150.83,64.96 150.83,64.23 151.66,63.4 153.72,63.4 153.85,63.52
  IN3 w0.122: v2(162.91,65.62) 162.56,65.28 161.2,65.28 160.71,65.77 156.53,65.77 154.29,63.52 153.85,63.52
  BOTTOM w0.076: v2(149.66,66.2) 149.32,65.87 UC1.AL4
  BOTTOM w0.102: v1(162.75,66.19) 162.91,66.04 v2(162.91,65.62)
SLEEVE: length 28.7
  TOP w0.381: v2(268.83,23.7) 268.86,23.73 Q123.3
  IN4 w0.381: 275.43,38.92 275.43,37.97 276.4,36.99 278.21,36.99 278.51,36.69 278.51,32.49 279.82,31.18 279.82,28.75 278.7,27.63 278.7,24.82 277.3,23.42 269.11,23.42 v2(268.83,23.7)
  vias: v1(271.78,49.58) v2(272.2,50.13) v2(272.43,49.55) v2(272.61,48.96) v2(275.34,40.5) v2(275.34,39.56) v2(275.5,41.07) v2(275.69,40.03)
SLEEVE_L:
  vias: v1(280.21,49.95)
SLEWA: length 4.3
  TOP w0.203: PR500.1 91.3,69.98 91.3,70.52 90.85,70.97 PU500.15
  TOP w0.254: PR500.1 91.87,70.01 v2(91.87,70.33)
  BOTTOM w0.102: v1(91.86,69.72) 91.87,69.74 v2(91.87,70.33)
  BOTTOM w0.254: PR510.2 92.39,70.85 v2(91.87,70.33)
SLICE_BAT_ON: length 286.7
  TOP w0.102: U37.A31 27.68,37.77 27.88,37.57 v2(28,37.57) R307.2 ; v1(1.07,33.5) PR850.2
  TOP w0.254: v2(124.89,13.18) 124.96,13.25 128.19,13.25 128.45,12.99 128.45,11.91 128.77,11.59 130.8,11.59 131.25,11.14 PU801.2 ; v2(136.2,6.83) 136.4,6.63 PU807.1 ; PR850.2 v2(1.94,34.14) ; PQ812.5 v2(177.61,10.1)
  TOP w0.381: v2(124.77,6.45) 124.51,6.71 PQ806.5
  IN3 w0.254: v2(177.61,10.1) 175.82,8.31 170.73,8.31 166.24,12.8 153.4,12.8 153.12,13.08 146.19,13.08 145.53,12.42 139.57,12.42 139.27,12.72 v2(136.26,12.72) 133.51,12.72 133.1,12.32 130.17,12.32 129.31,13.18 v2(124.89,13.18) ; v2(1.94,34.14) 1.94,33.24 1.14,32.44 1.14,23.88 2.58,22.44 8.99,22.44 9.97,21.46 12.31,21.46 13.28,22.44 22.87,22.44 23.39,21.92 28.15,21.92 29.08,20.99 29.08,17.86 29.8,17.14 33.71,17.14 34.86,18.29 37.31,18.29 38.89,19.86 38.89,22.52 41.44,25.07 41.44,25.93 44.78,29.27 45.77,29.27 47.4,30.9 50.06,30.9 53.6,34.44 61.61,34.44 62.4,35.22 117.48,35.22 125.37,27.34 v2(125.37,27.27)
  IN4 w0.084: v2(1.94,34.14) 2.63,34.82 4.72,34.82 5.33,34.21 6.27,34.21 8.67,31.81 10.21,31.81 10.59,32.19 10.59,34.72 10.87,35 12.8,35 13.02,34.78 v2(13.45,34.78)
  IN4 w0.508: v2(124.77,6.45) 124.77,8.33 123.95,9.14 123.95,12.24 v2(124.89,13.18)
  BOTTOM w0.102: v2(28,37.57) 27.84,37.57 27.13,36.85 27.13,36.22 26.82,35.92 26.02,35.92 24.7,34.59 22.96,34.59 22.15,35.41 17.97,35.41 17.59,35.03 16.21,35.03 16.08,35.15 13.83,35.15 v2(13.45,34.78)
  BOTTOM w0.254: v2(136.2,6.83) 136.2,6.84 136.92,7.57 136.92,12.06 v2(136.26,12.72)
  BOTTOM w0.508: v2(125.37,27.27) 125.65,26.99 125.65,17.55 124.89,16.79 v2(124.89,13.18)
SLICE_BAT_PRES#: length 461.5
  TOP w0.102: U37.B33 24.12,38.02 23.95,37.85 23.95,37.85 23.71,37.61 23.71,37.6 23.6,37.49 v2(23.51,37.49)
  TOP w0.254: v2(5.44,35.15) 5.56,35.28 6.74,35.28 7.85,34.17 PR860.2 ; PD820.1 v2(1.88,34.99) ; PR834.2 148.78,14.49 v2(148.31,14.96) 149.07,15.72 152.2,15.72 153.85,14.07 154.36,14.07 154.61,13.82 PR6.1 ; PU808.1 209.6,6.2 209.83,6.43 v2(210.3,6.43) ; PU805.1 141.72,13.26 v1(141.32,13.66) 140.99,13.99 136.58,13.99 135.52,15.05 134.26,15.05 132.39,13.18 v2(131.96,13.18) 131.05,13.18 130.92,13.06 130.92,12.04 131.31,11.66 131.62,11.66 131.9,11.38 PU801.1 ; PR861.1 202.4,19.14 201.83,19.71 v2(201.83,20.7)
  IN1 w0.084: v2(23.51,37.49) 23.51,37.79 24.18,38.46 24.18,38.94 26.61,41.37 v2(26.61,42.82)
  IN2 w0.122: v2(26.61,42.82) 26.04,43.39 21.88,43.39 20.7,42.21 15.44,42.21 14.94,42.71 9.96,42.71 7.65,40.4 7.65,39.56 4.65,36.56 4.65,35.94 v2(5.44,35.15) ; v2(151.03,97.71) 151.6,97.14 151.6,96.07 152.94,94.74 166.5,94.74 171.23,90.01 171.23,89 170.29,88.06 170.29,86.21 169.22,85.13 169.22,83.47 170.14,82.55 170.14,81.13 169.06,80.05 168.35,80.05 167.64,79.33 167.64,77.38 167.89,77.13 167.89,75.26 167.85,75.22 167.85,73.31 168.17,72.99 168.17,70.74 167.58,70.15 167.58,63.61 168.46,62.73 168.46,62.36 169.09,61.73 169.09,55.63 170.75,53.97 170.75,47.88 153.92,31.06 137.47,31.06 135.46,29.04 132.13,29.04 130.55,27.46 129.63,27.46 128.77,28.32 v2(126.86,28.32)
  IN3 w0.254: v2(148.31,14.96) 147.78,14.43 138.96,14.43 138.16,13.63 132.4,13.63 v2(131.96,13.18) ; v2(5.44,35.15) 5.44,34.71 6.09,34.06 6.65,34.06 7.96,32.75 7.96,32.03 9.73,30.26 11.63,30.26 12.55,29.35 12.55,26.39 13.08,25.86 14.3,25.86 14.91,25.25 16,25.25 16.63,24.61 20.44,24.61 20.82,24.99 23.26,24.99 23.68,25.41 29.32,25.41 30.05,26.14 31.09,26.14 31.27,25.96 32.35,25.96 33.14,26.75 36.19,26.75 36.73,27.29 38.55,27.29 41.29,30.03 45.46,30.03 50.62,35.2 61.3,35.2 62.08,35.99 117.8,35.99 122.19,31.59 124.8,31.59 127.05,29.34 127.05,28.51 v2(126.86,28.32)
  IN4 w0.254: v2(1.88,34.99) 2.17,35.28 5.31,35.28 v2(5.44,35.15) ; v2(210.3,6.43) 210.3,4.58 208.31,2.59 206.13,2.59 204.7,4.03 204.7,7.43 203.83,8.3 203.83,11.53 202.34,13.02 202.34,20.31 201.94,20.7 v2(201.83,20.7) 201.59,20.7 199.43,18.54 199.43,17.35 197.32,15.24 190.92,15.24 188.54,17.61 159.79,17.61 157.14,14.96 v2(148.31,14.96)
  BOTTOM w0.102: v2(26.61,42.82) 26.08,43.34 25.69,43.34 R285.2 ; JDOCK1.141 150.45,99.32 150.61,99.16 150.86,99.16 ; 150.86,99.16 150.95,99.25 JDOCK1.143 ; 150.86,99.16 150.86,98.72 151.03,98.55 v2(151.03,97.71)
  BOTTOM w0.254: PQ807.5 148.13,14.78 v2(148.31,14.96) ; v2(131.96,13.18) 130.86,13.18 126.49,17.55 126.49,19.86 126.75,20.12 126.75,22.3 127.85,23.41 127.85,24.25 126.58,25.52 126.58,28.04 v2(126.86,28.32)
SLICE_PERF_EN: length 300.4
  TOP w0.102: v2(27.61,18.52) 27.69,18.6 U38.B37 ; v2(10.04,41.19) 10.04,41.22 9.82,41.44 PQ824.5
  TOP w0.254: PQ819.2 142.16,4.72 142.47,5.03 142.47,7.21 143.1,7.85 v2(143.1,8.41) ; PR851.1 206.17,16.32 v2(206.49,16)
  IN1 w0.084: v2(30.71,30.63) 28.43,28.35 28.43,25.35 28.94,24.83 28.94,20.62 27.61,19.28 v2(27.61,18.52)
  IN2 w0.254: v2(206.49,16) 206.63,16.14 210.26,16.14 211.3,15.1 211.3,6.08 210.46,5.24 207.12,5.24 206.78,4.9 206.78,4.64 205.67,3.54 199.68,3.54 v2(199.28,3.14)
  IN3 w0.254: v2(50.85,3.23) 51.46,3.83 51.86,3.83 52.49,3.21 55.21,3.21 55.7,3.7 59.24,3.7 59.78,3.15 76.87,3.15 77.41,3.68 77.41,6.26 78.99,7.85 81.88,7.85 86.56,3.17 93.19,3.17 97.46,7.44 107.72,7.44 109.55,9.27 116.27,9.27 117.34,10.34 123.7,10.34 124.21,9.83 127.72,9.83 128.09,10.2 129.19,11.3 131.93,11.3 133.27,9.96 137.95,9.96 139.09,8.81 142.62,8.81 143.03,8.41 v2(143.1,8.41) 144.22,8.41 147.22,11.4 165.66,11.4 170.57,6.49 175.29,6.49 177.59,4.19 179.89,4.19 180.54,3.54 188.11,3.54 189.46,2.2 198.34,2.2 v2(199.28,3.14)
  IN4 w0.084: v2(10.04,41.19) 10.06,41.17 10.06,36.99 11.7,35.35 13.82,35.35 13.94,35.23 13.94,34.4 13.71,34.17 13.15,34.17 12.27,33.29 12.27,30.78 14.28,28.78 14.28,27.72 14.59,27.41 15.18,27.41 15.77,26.81 17.52,26.81 17.96,27.25 19.46,27.25 19.94,27.74 19.94,28.32 21.21,29.59 24.92,29.59 25.32,30 28.14,30 28.78,30.63 v2(30.71,30.63)
  BOTTOM w0.102: v2(27.61,18.52) 27.89,18.24 27.89,16.42 27.99,16.32 27.99,14.81 28.19,14.6 29.38,14.6 30.63,13.35 33.41,13.35 34.62,14.55 36.93,14.55 37.85,13.64 37.85,10.52 35.84,8.51 34.15,8.51 33.77,8.13 33.77,7.15 32.61,5.99 32.61,4.37 33.66,3.33 42.88,3.33 43.31,3.76 44.91,3.76 45.64,3.02 50.65,3.02 v2(50.85,3.23)
  BOTTOM w0.254: v2(199.28,3.14) 199.48,2.93 200.39,2.93 200.71,3.25 PR848.1
SLP_ME_CSW_DEV#: length 223.2
  TOP w0.102: v2(16.29,35.52) U37.B58
  IN1 w0.084: v2(16.29,35.52) 16.29,35.52 15.91,35.13 15.91,30.48 17.05,29.34 17.05,26.67 18.14,25.58 v2(18.14,25.14)
  IN2 w0.122: v2(153.28,81.32) 154.17,80.43 154.17,78.78 153.96,78.57 153.96,78.02 153.41,77.48 153.41,76.37 153.8,75.99 153.8,75.84 155.68,73.96 157.37,73.96 157.97,73.36 157.97,70.29 158.93,69.33 158.93,66.48 162.11,63.3 162.11,61.17 162.73,60.55 162.73,59.08 164.06,57.75 164.06,56.48 162.66,55.08 162.66,47.14 149.36,33.83 133.92,33.83 133.09,33 125.45,33 124.72,33.73 62.97,33.73 61.66,32.43 55.74,32.43 54.93,31.62 53.82,31.62 51.92,29.72 51.03,29.72 50.17,28.86 50.17,27.43 49.5,26.77 46.56,26.77 45.09,25.3 43.39,25.3 42.72,24.64 32.28,24.64 30.04,22.4 24.99,22.4 22.94,24.45 18.9,24.45 18.21,25.14 v2(18.14,25.14)
  BOTTOM w0.076: UC1.E2 150.78,80.09 150.99,79.87 151.56,79.87 153,81.32 v2(153.28,81.32) 153.75,80.85 153.85,80.85
  BOTTOM w0.102: 153.85,80.85 154.36,80.85 154.64,81.12 154.64,81.99 154.46,82.17 154.46,82.56 154.41,82.66 154.41,82.66 154.4,82.7 154.4,82.72 154.1,83.02 154.1,84.37 154.31,84.57 154.31,85.62 156.02,87.34 RC289.2
SM_RCOMP0: length 9.1
  TOP w0.305: v2(114.86,62.71) v1(116.38,61.19) 117.46,60.11 117.46,58.27 115.82,56.63 RC125.1
  BOTTOM w0.229: v2(114.86,62.71) 114.86,62.29 UC1.AU60
SM_RCOMP1: length 6.6
  TOP w0.305: RC129.1 110.6,57.67 v1(112.01,59.08) v2(114.23,61.3)
  BOTTOM w0.229: UC1.AV60 114.42,61.49 v2(114.23,61.3)
SM_RCOMP2: length 8
  TOP w0.305: v2(113.52,62.61) v1(110.2,59.28) 109.72,58.8 RC133.1
  BOTTOM w0.229: v2(113.52,62.61) 113.72,62.41 UC1.AU61
SML0CLK: length 30.8
  TOP w0.102: RC29.2 157.73,67.91 157,67.91 156.94,67.97 156.94,68.59 156.72,68.81 156.4,68.81 156.16,68.57 156.16,67.6 156.25,67.51 157.28,67.51 157.51,67.28 157.51,66.92 157.65,66.78 157.76,66.78 157.94,66.6 157.94,65.99 157.74,65.79 156.41,65.79 155.39,64.77 155.1,64.77 155,64.67 155,64.08 154.9,63.98 154.7,63.98 154.6,64.08 154.6,64.67 154.49,64.77 v1(154.08,64.77) 153.29,64.77 153.15,64.63 153.15,64.38 153.24,64.28 154.02,64.28 154.15,64.15 154.15,63.57 154.04,63.45 153.07,63.45 152.97,63.35 152.97,63.15 153.07,63.05 154.29,63.05 154.38,62.96 154.38,62.76 154.27,62.64 153.07,62.64 152.97,62.54 152.97,62.34 153.07,62.23 154.11,62.23 154.22,62.13 154.22,61.91 154.05,61.75 152.74,61.75 152.58,61.91 152.58,63.84 152.6,63.86 v2(152.6,63.82) ; RC29.2 158.17,67.13 158.33,66.97 158.33,66.61 158.45,66.5 RC33.2 ; RC29.2 RC38.2
  BOTTOM w0.076: UC1.AN1 151.4,64.23 152.22,64.23 152.6,63.84 v2(152.6,63.82)
SML0DATA: length 29.3
  TOP w0.102: v2(164.26,62.74) 165.04,62.74 165.16,62.87 v1(165.16,63.27) 165.16,63.47 165.04,63.6 164.03,63.6 163.91,63.73 163.91,63.92 164.03,64.05 165,64.05 165.13,64.17 165.13,64.44 165,64.57 163.87,64.57 163.74,64.69 163.74,64.99 163.87,65.11 166.01,65.11 RC35.2 RC31.2 166.94,66.99 167.07,66.99 RC39.2
  IN1 w0.084: v2(154.35,67.09) 154.35,67.47 154.71,67.83 157.91,67.83 158.27,67.47 159.17,67.47 159.58,67.07 160.81,67.07 162.84,65.04 163.31,65.04 164.26,64.08 v2(164.26,62.74)
  BOTTOM w0.076: UC1.AK1 152.68,66.6 153.3,67.22 153.85,67.22
  BOTTOM w0.102: 153.85,67.22 154.21,67.22 v2(154.35,67.09)
SML1_SMBCLK: length 181.3
  TOP w0.102: v2(152.37,59.91) 152.31,59.91 151.9,59.5 151.9,59.49 151.18,58.76 v1(151.18,58.71) 150.67,58.2 RC36.1 ; v2(23.29,11.66) 23.12,11.49 23.12,10.39 23.19,10.32 U38.B6
  IN1 w0.084: v2(27.66,26.63) 27.66,26.24 27.29,25.87 27.29,23.44 25.57,21.72 25.57,20.55 24.92,19.9 24.92,18.16 24.56,17.8 24.56,16.99 24.05,16.48 24.05,12.42 v2(23.29,11.66)
  IN2 w0.089: v2(152.37,59.91) 152.83,60.36 153.25,60.36 153.72,59.89 153.72,54.58 153.57,54.42
  IN2 w0.122: 153.57,54.42 153.57,53.17 154.38,52.36 155.37,52.36 155.8,51.93 155.8,47.95 144.94,37.09 61.91,37.09 61.52,36.7 60.15,36.7 59.79,36.34 58.93,36.34 58.75,36.53 58.75,37.12 58.19,37.67 55.09,37.67 53.83,36.41 53.3,36.41 50.56,33.67 49.11,33.67 48.61,33.17 48.61,32.46 45.83,29.68 45.4,29.68 42.94,27.23 36.8,27.23 36.37,26.8 32.88,26.8 32.22,26.13 30,26.13 29.69,25.83 28.46,25.83 v2(27.66,26.63)
  BOTTOM w0.076: UC1.AU3 150.18,62.17 150.51,61.84 150.75,61.84 150.76,61.82 151.13,61.82 151.14,61.83 151.41,61.83 151.41,61.82 151.58,61.66 151.88,61.66 152.03,61.51 152.03,60.19 152.31,59.91 v2(152.37,59.91)
SML1_SMBDATA: length 198.8
  TOP w0.102: v2(23.27,8.34) 23.25,8.36 23.04,8.36 22.94,8.46 U38.A5
  IN1 w0.084: v2(23.27,8.34) 23.27,8.32 23.04,8.55 23.04,11.2 22.89,11.35 22.89,11.96 23.04,12.1 23.44,12.1 23.84,12.51 23.84,16.57 24.35,17.08 24.35,17.89 24.71,18.25 24.71,19.99 25.35,20.64 25.35,21.8 26.77,23.22 v2(26.77,23.91)
  IN2 w0.089: 153.85,64.24 152.39,65.7 152.39,66.59 153.09,67.28 v2(153.09,68.14)
  IN2 w0.122: 153.85,64.24 153.95,64.13 153.95,60.57 154.35,60.16 154.35,55.44 156.68,53.11 156.68,52.51 156.05,51.88 156.05,47.84 145.05,36.84 62.01,36.84 61.62,36.45 60.25,36.45 59.89,36.09 58.83,36.09 58.5,36.42 58.5,37.02 58.09,37.42 55.2,37.42 53.93,36.16 53.4,36.16 50.67,33.42 49.22,33.42 48.86,33.07 48.86,32.36 45.93,29.43 45.5,29.43 43.05,26.98 36.91,26.98 36.48,26.55 32.99,26.55 32.32,25.88 30.1,25.88 29.79,25.58 28.44,25.58 v2(26.77,23.91)
  IN3 w0.089: v2(153.09,68.14) 153.55,68.6 153.85,68.6
  IN3 w0.122: v2(162.26,68.31) 161.95,68.31 161.33,68.94 159.14,68.94 158.06,67.86 155.31,67.86 154.56,68.6 153.85,68.6
  BOTTOM w0.076: UC1.AH3 150.23,67.06 150.75,67.06 150.98,67.3 150.98,67.47 151.15,67.64 151.57,67.64 151.59,67.61 152.56,67.61 v2(153.09,68.14)
  BOTTOM w0.102: RC37.1 v1(162.26,69.13) v2(162.26,68.31)
SNUB_1.35V: length 1.6
  TOP w0.102: PR203.1 v1(99.56,15.34)
SOFT_START_GC: length 82.9
  TOP w0.254: v2(53.98,48.2) 53.51,47.72 53.51,44.92 52.95,44.36 52.95,43.59 53.21,43.33 53.21,42.45 53.02,42.27 PR17.2 ; PU800.2 v2(5.28,24.19)
  IN1 w0.254: v2(5.28,24.19) 4.65,24.83 4.65,32.55 3.73,33.46 3.73,34.39 4.98,35.64 7.11,35.64 7.71,36.23 7.71,40.6 9.47,42.37 12.24,42.37 12.45,42.57 19.43,42.57 19.51,42.65 20.66,42.65 21.36,43.34 24.42,43.34 25.48,44.4 26.23,44.4 26.57,44.74 31.74,44.74 36.07,49.07 38.7,49.07 v2(42.45,52.83)
  IN3 w0.254: v2(50.37,51.69) 50.22,51.84 49.15,51.84 48.59,51.28 47.3,51.28 46.25,52.32 43.97,52.32 43.47,52.83 v2(42.45,52.83)
  BOTTOM w0.254: v2(53.98,48.2) 53.56,48.62 53.56,49.74 52.2,51.1 50.95,51.1 v2(50.37,51.69)
SP_TPM_LPC_EN: length 51.9
  TOP w0.102: v1(24.21,26.76) 23.8,27.16 R304.2 23.23,27.28 23.6,27.66 v2(23.6,27.79) ; U37.B56 15.93,36.52 16.08,36.68 16.5,36.68 16.88,36.3 v2(16.88,36.11) ; R193.1 33.41,39.33 32.92,38.84 32.92,37.31 33.34,36.89 v2(34.65,36.89)
  IN1 w0.084: v2(17.28,25.56) 17.28,26.07 16.84,26.52 16.84,29.25 15.7,30.39 15.7,36.28 15.97,36.55 16.56,36.55 16.88,36.23 v2(16.88,36.11)
  IN2 w0.122: v2(23.6,27.79) 23.6,28.55 23.21,28.94 19.49,28.94 18.9,28.35 18.9,27.49 18.57,27.15 18.44,27.15 17.28,26 v2(17.28,25.56)
  IN4 w0.084: v2(16.88,36.11) 16.9,36.09 21.31,36.09 22.73,34.68 25.07,34.68 25.97,33.78 27.34,33.78 29.88,36.31 32.89,36.31 33.48,36.89 v2(34.65,36.89)
SP_TPM_LPC_EN_R: length 120.4
  TOP w0.102: v2(33.48,38.73) 33.79,38.42 v1(34.04,38.42) R193.2 35.32,38.34 U25.28
  IN4 w0.084: v2(108.24,85.18) 108.1,85.18 107.32,85.97 106.25,85.97 104.69,87.53 101.26,87.53 99.34,85.61 98.14,85.61 97.01,86.75 89.15,86.75 87.35,88.54 85.05,88.54 83.74,87.23 81.47,87.23 81.21,86.98 74.47,86.98 72.97,88.47 69.47,88.47 66.83,85.83 66.07,85.83 64.39,84.15 62.26,84.15 60.4,82.28 60.4,81.34 56.58,77.53 56.58,76.03 56.09,75.54 56.09,68.59 55.68,68.17 55.68,55.91 54.91,55.14 54.91,51.34 50.21,46.64 49.13,46.64 47.81,45.32 40.78,45.32 38.63,43.17 35.62,43.17 33.92,41.48 33.92,39.18 v2(33.48,38.73)
  BOTTOM w0.102: R198.2 108.24,84.66 v2(108.24,85.18)
SPI_CLK32: length 14.1
  BOTTOM w0.102: R20.1 R45.2 179.82,74.98 179.82,73.52 v5(178.74,72.44) 178.74,71.88 178.61,71.75 177.74,71.75 177.62,71.64 177.62,71.47 177.74,71.35 178.61,71.35 178.74,71.22 178.74,71.07 178.61,70.94 177.74,70.94 177.62,70.82 177.62,70.65 177.74,70.54 178.75,70.54 178.88,70.41 178.88,70.21 178.75,70.08 177.43,70.08 177.05,70.46 U2.6
SPI_CLK64: length 13.3
  BOTTOM w0.102: R7.1 179.73,79.59 179.73,81.1 179.13,81.69 R57.2 179.13,85.24 179.01,85.37 178.42,85.37 178.3,85.5 178.3,86.21 178.17,86.33 177.81,86.33 177.69,86.21 v5(177.69,85.86) 177.69,85.5 177.56,85.37 177.24,85.37 177.11,85.5 177.11,87.1 176.99,87.22 U1.6
SPI_DIN32: length 13.1
  BOTTOM w0.102: U2.2 167.98,69.19 167.53,69.64 167.53,70.69 167.41,70.81 166.41,70.81 166.27,70.95 166.27,71.25 166.15,71.37 165.98,71.37 165.86,71.25 165.86,70.51 165.72,70.36 165.53,70.36 165.43,70.46 165.43,71.27 165.31,71.39 165.14,71.39 165.02,71.27 165.02,70.46 164.92,70.36 164.02,70.36 163.89,70.49 v5(163.89,71.16) 163.89,71.82 164.31,72.24 165.61,72.24 R15.2
SPI_DIN64: length 13.2
  BOTTOM w0.102: R4.2 164.45,84.19 164.96,84.7 v5(164.96,84.87) 164.96,86.74 165.09,86.87 165.34,86.87 165.47,86.74 165.47,85.57 165.6,85.45 165.8,85.45 165.92,85.56 165.92,86.8 166.04,86.92 166.23,86.92 166.36,86.79 166.36,85.51 166.48,85.38 166.74,85.38 166.87,85.51 166.87,86.72 166.99,86.84 167.25,86.84 167.37,86.72 167.37,86.08 167.5,85.95 U1.2
SPI_DO32: length 13
  IN2 w0.122: v2(176.9,76.24) 177.24,76.58 177.24,77.36 176.84,77.76 175.72,77.76 v2(175.04,78.43)
  BOTTOM w0.102: v2(175.04,78.43) 175.21,78.27 175.72,78.27 176.19,78.74 R21.1 ; 175.89,71.73 174.8,71.73 174.69,71.84 174.69,72.03 175.02,72.36 176,72.36 176.2,72.57 176.2,74.02 176.58,74.4 176.58,75.92 v2(176.9,76.24)
SPI_DO64: length 15.1
  BOTTOM w0.102: U1.5 173.74,88.49 173.61,88.37 173.61,86.74 173.74,86.61 174.65,86.61 174.76,86.49 174.76,86.33 174.65,86.21 173.25,86.21 173.13,86.09 173.13,85.92 173.25,85.8 173.9,85.8 174.01,85.68 174.01,85.51 173.9,85.39 173.15,85.39 173.03,85.27 173.03,85.1 173.15,84.98 173.46,84.98 173.53,84.9 173.53,83.72 174.03,83.22 175.46,83.22 176.19,82.5 R9.1
SPI_PCH_CS0#_R: length 13.2
  BOTTOM w0.102: R3.2 169.39,83.34 169.52,83.46 171.56,83.46 171.69,83.59 171.69,84.16 171.56,84.29 170.46,84.29 170.33,84.42 170.33,84.57 170.46,84.7 172.09,84.7 172.22,84.82 172.22,84.98 172.09,85.1 170.54,85.1 170.41,85.23 170.41,86.08 170.28,86.21 169.91,86.21 169.79,86.08 169.79,84.81 169.66,84.68 U1.1
SPI_PCH_CS1#_R: length 14
  BOTTOM w0.102: R14.2 164.52,67.44 164.64,67.31 165.04,67.31 165.16,67.44 165.16,68.35 165.28,68.47 165.45,68.47 165.57,68.35 v1(165.57,67.97) 165.57,67.58 165.7,67.45 165.97,67.45 166.1,67.58 166.1,68.17 166.22,68.29 166.38,68.29 166.5,68.17 166.5,67.14 166.62,67.02 166.79,67.02 166.91,67.14 166.91,68.34 167.03,68.46 167.2,68.46 167.32,68.34 167.32,67.13 167.43,67.02 167.78,67.02 168.02,67.26 169.79,67.26 169.91,67.39 169.91,67.79 169.79,67.92 U2.1
SPI_PCH_DO2_32: length 21.2
  BOTTOM w0.102: U2.3 169.58,70.46 169.79,70.26 169.79,68.74 169.91,68.62 171.59,68.62 171.72,68.74 171.72,68.97 171.59,69.1 170.38,69.1 170.26,69.22 170.26,70.54 170.38,70.66 171.31,70.66 171.44,70.54 171.44,70.01 171.56,69.89 171.95,69.89 172.07,70.01 172.07,70.94 171.95,71.07 171.74,71.07 171.61,71.2 171.61,71.86 171.49,71.98 171.25,71.98 171.12,71.86 171.12,71.2 170.99,71.07 170.74,71.07 170.61,71.2 170.61,71.86 170.48,71.98 170.29,71.98 170.17,71.86 170.17,71.25 170.04,71.12 169.8,71.12 169.67,71.25 169.67,72.29 169.52,72.44 168.17,72.44 167.86,72.76 R23.1 R19.2
SPI_PCH_DO2_64: length 23.1
  IN2 w0.122: v2(165.52,75.73) 165.57,75.78 165.57,79.46 164.01,81.03 164.01,81.43 165.29,82.71 165.29,86.22 v2(164.36,87.15)
  BOTTOM w0.102: v2(165.52,75.73) 165.52,75.62 166.1,75.03 R8.1 166.29,75.21 168.11,75.21 168.31,75.41 169.27,75.41 169.79,74.89 R6.2 ; v2(164.36,87.15) 164.44,87.22 v1(166.56,87.22) U1.3
SPI_PCH_DO3_32: length 14.2
  BOTTOM w0.102: R16.1 174.65,72.52 172.99,72.52 172.86,72.39 172.86,72.03 172.99,71.91 174.13,71.91 174.24,71.79 174.24,71.62 174.13,71.5 172.87,71.5 172.77,71.4 172.77,71.19 172.87,71.09 174.18,71.09 174.31,70.97 174.31,70.34 174.18,70.22 172.85,70.22 172.72,70.09 172.72,69.91 172.85,69.79 174.82,69.79 174.9,69.7 174.9,69.41 175.12,69.19 U2.7
SPI_PCH_DO3_64: length 13.3
  BOTTOM w0.102: U1.7 174.87,85.95 174.21,85.29 174.21,84.85 174.84,84.21 174.84,84.05 175.27,83.62 175.49,83.62 176.66,82.45 176.66,78.56 176.34,78.25 v1(176.34,78.04) 176.57,77.81 176.7,77.81 177.09,77.42 177.09,77.01 176.1,76.02 R5.1
SPI_WP#_SEL: length 213.1
  TOP w0.102: U37.A12 21.93,28.7 22.4,28.23 v2(22.4,27.85)
  IN2 w0.122: v2(166.27,73.57) 165.88,73.18 165.88,71.04 165.66,70.82 165.66,68.49 166.83,67.32 166.83,63.29 167.71,62.4 167.71,60.89 168.25,60.34 168.25,47.68 152.63,32.06 135.05,32.06 133.73,30.73 130.97,30.73 129.91,29.67 v2(129.91,29.67)
  BOTTOM w0.102: v2(129.91,29.67) 129.4,30.18 129.4,32.62 129.06,32.96 129.06,37.03 125.3,40.79 64.96,40.79 63.21,42.54 55.68,42.54 55.19,43.03 52.56,43.03 49.42,46.18 48.42,46.18 46.85,47.74 46.31,47.74 45.72,48.33 43.58,48.33 42.53,47.28 40.81,47.28 34.77,41.25 34.77,40.72 v1(34.28,40.22) 32.02,37.97 30.16,37.97 29.17,36.98 29.17,34.78 28.31,33.91 28.31,26.05 27.95,25.69 25.85,25.69 24.17,27.37 22.76,27.37 22.4,27.73 v2(22.4,27.85) ; R23.2 166.81,73.28 166.55,73.28 v2(166.27,73.57) 165.66,73.57 165.34,73.89 165.34,74.89 R8.2
SPKR: length 205.6
  TOP w0.102: R147.2 272.96,23.42 272.64,23.74 v2(272.64,24.6)
  IN2 w0.122: v2(267.7,77.19) 268.66,77.19 269.86,75.98 269.86,55.82 273.64,52.05 273.64,51.38 276.25,48.77 276.25,41.5 276.49,41.26 276.49,38.75 276.25,38.5 276.25,31.76 274.32,29.83 274.32,28.97 273.34,27.99 273.34,25.02 272.92,24.6 v2(272.64,24.6)
  IN3 w0.122: v2(166.35,81.24) 168.22,79.37 171.96,79.37 172.59,80.01 176.56,80.01 177.01,80.47 179.78,80.47 180.59,81.28 184.28,81.28 185.85,79.7 186.91,79.7 187.45,80.25 191.22,80.25 193.98,77.49 197.06,77.49 199.31,79.74 199.31,82.78 200.02,83.49 200.02,84.57 202.51,87.07 202.51,87.83 204.11,89.43 210.48,89.43 210.75,89.16 226.42,89.16 226.67,89.41 233.99,89.41 234.24,89.66 239.26,89.66 240.12,88.8 240.12,87.72 243.34,84.51 260.83,84.51 262.1,83.24 264.82,83.24 267.37,80.69 267.37,77.52 v2(267.7,77.19)
  BOTTOM w0.076: UC1.V2 150.76,72.6 151.05,72.3 151.53,72.3 151.58,72.25 153.6,72.25 153.72,72.38 153.85,72.38
  BOTTOM w0.102: v2(166.35,81.24) 168.06,79.54 168.06,76.68 167.64,76.26 v1(164.96,76.26) 164.4,76.26 163.1,74.96 162.09,74.96 RC222.2 160.88,73.75 155.67,73.75 154.3,72.38 153.85,72.38
SRCDET: length 5.6
  TOP w0.102: R69.1 191.25,88.67 v1(191.25,87.76) 191.25,85.51 191.76,85 191.76,83.86 192.11,83.51 U6.C2
SRTCRST#: length 121.5
  TOP w0.102: v2(57.01,44.21) 56.99,44.23 56.99,44.65 56.64,45 56.64,49.87 57.02,50.25 v1(57.02,53.43) 57.02,53.94 56.31,54.65 v2(55.8,54.65)
  IN2 w0.089: v2(147.56,61.18) 147.56,60.69 147.33,60.46 147.33,58.7 148.49,57.54 148.49,54.13 147.04,52.68 147.04,51.41
  IN2 w0.122: 147.04,51.41 147.04,49.13 143.04,45.13 118.02,45.13 117.02,44.13 57.09,44.13 v2(57.01,44.21)
  BOTTOM w0.076: UC1.AV6 147.9,61.49 147.59,61.18 v2(147.56,61.18)
  BOTTOM w0.102: ME1.2 55.7,54.55 v2(55.8,54.65) 56.59,54.65 56.82,54.88 RC8.2 CC3.2
STSTART_DCBLOCK_GC: length 254.1
  TOP w0.102: v1(197.71,40.21) 197.7,40.22 197.7,41.1 v2(197.73,41.13)
  TOP w0.254: v2(11.04,28.99) 10.93,29.1 PU800.16
  IN1 w0.254: v2(196.9,7.09) 197.53,6.46 202.68,6.46 203.25,7.03 203.25,9.5 203.4,9.65 203.4,20.69 203.91,21.2 203.91,21.77 205.24,23.11 205.24,24.41 204.4,25.25 204.4,25.94 203.8,26.54 202.46,26.54 201.12,27.89 201.12,32.9 200.61,33.41 200.61,35.67 200.05,36.24 200.05,39.13 199.61,39.57 199.29,39.57 v2(197.73,41.13)
  IN3 w0.254: v2(197.73,41.13) 192.55,41.13 189.79,38.37 188.78,38.37 187.89,37.48 187.89,36.83 187.39,36.33 186.78,36.33 185.97,37.14 136.97,37.14 132.46,32.64 132.46,31.33 131.6,30.46 130,30.46 128.77,29.24 128.52,29.24 127.1,27.81 125.43,27.81 117.64,35.61 62.24,35.61 61.45,34.82 53.37,34.82 49.84,31.28 47.24,31.28 45.62,29.65 43.19,29.65 42.49,28.96 40.75,28.96 38.71,26.91 36.89,26.91 36.34,26.36 33.3,26.36 32.51,25.58 31.1,25.58 30.92,25.76 30.2,25.76 29.48,25.03 23.84,25.03 23.42,24.61 20.98,24.61 20.6,24.23 16.48,24.23 15.84,24.87 14.75,24.87 14.14,25.48 12.67,25.48 12.09,26.06 12.09,27.94 v2(11.04,28.99)
  BOTTOM w0.254: v2(196.9,7.09) 197.03,7.21 PR811.1
SUS_ON: length 305.2
  TOP w0.102: U37.B60 16.53,34.52 v2(16.63,34.62) ; R422.1 196.6,31.82 196.6,30.67 v2(196.39,30.47) ; v2(12.87,35.98) 12.87,36.37 12.78,36.46 RP11.5
  TOP w0.254: PR208.1 120.67,9.96 121.65,10.94 121.65,12.98 v1(121.84,13.17) 122.21,13.54 v2(122.21,14.67)
  IN1 w0.084: v2(9.39,33.43) 8.98,33.02 8.98,22.56 9.8,21.73 9.8,20.66 9.14,20 9.14,13.54 9.88,12.8 9.88,8.07 10.42,7.53 10.42,5.56 11.71,4.28 11.71,4.18 12.69,3.21 25.63,3.21 26.4,3.98 26.73,3.98 27.5,3.21 41.77,3.21 43.27,4.71 45.74,4.71 47.2,6.17 47.2,7.25 47.63,7.68 47.63,9.96 48,10.32 48,11.69 49.21,12.91 49.21,14.4 52.49,17.68 54.03,17.68 55.51,19.16 56.8,19.16 57.22,18.74 70.6,18.74 72.37,16.97 77.52,16.97 78.63,15.86 81,15.86 82.08,16.94 84.91,16.94 86.12,15.74 95.45,15.74 96.61,16.9 119.43,16.9 121.66,14.67 v2(122.21,14.67)
  IN3 w0.254: v2(122.21,14.67) 123.04,13.84 129.18,13.84 130.33,12.7 132.94,12.7 133.49,13.25 138.32,13.25 139.12,14.05 158.27,14.05 159.13,13.18 166.47,13.18 170.97,8.69 175.44,8.69 177.37,10.62 177.8,10.62 178.42,9.99 178.42,8.95 181.98,5.4 195.45,5.4 197.16,3.7 199.85,3.7 201.51,2.03 201.9,2.03 203.65,3.78 207.3,3.78 v2(207.61,3.47)
  IN4 w0.084: v2(207.61,3.47) 207.33,3.75 205.97,3.75 205,4.71 205,6.55 205.62,7.17 205.62,7.92 204.76,8.77 204.76,11.91 203.27,13.41 203.27,22.61 202.31,23.57 201.47,23.57 200.71,24.33 200.71,25.14 200.06,25.79 200.06,27.89 197.49,30.47 v2(196.39,30.47)
  BOTTOM w0.102: v2(9.39,33.43) 9.97,33.43 11.63,35.09 11.63,35.69 11.93,35.98 v2(12.87,35.98) 12.99,35.85 12.99,34.66 13.31,34.34 16.35,34.34 v2(16.63,34.62)
SUS_STAT#/LPCPD#: length 14.9
  TOP w0.102: RC74.2 161.2,67.58 161.4,67.78 v2(161.4,68.12) 161.45,68.12 161.8,67.78 v1(161.8,67.52)
  IN4 w0.084: v2(161.4,68.12) 161.11,67.83 154.83,67.83 154.69,67.7 154.26,67.7 153.98,67.41 153.02,67.41 152.54,66.93 151.07,66.93 150.64,67.36 150.09,67.36 v2(149.72,67.73)
  BOTTOM w0.076: UC1.AG4 149.37,68.14 149.72,67.79 v2(149.72,67.73)
SUSACK#: length 212.8
  TOP w0.102: RP7.6 161.86,69.81 162.12,69.56 162.12,68.9 161.85,68.63 161.85,68.05 162.13,67.77 162.13,66.94 v2(161.93,66.74) ; U37.A58 14.28,33.77 v2(14.04,33.52)
  IN2 w0.122: v2(127.18,33.45) 133.19,33.45 133.82,34.08 149.06,34.08 162.42,47.43 162.42,55.19 163.8,56.58 163.8,57.64 162.33,59.12 162.33,59.37 v2(162.29,59.41)
  BOTTOM w0.102: v2(14.04,33.52) 14.02,33.52 13.08,32.57 11.29,32.57 10.69,31.98 10.69,30.67 12.22,29.15 12.22,27.24 14.89,24.56 20.22,24.56 20.48,24.83 21.64,24.83 22.06,24.41 23.39,24.41 24.53,23.26 29.34,23.26 30.63,24.55 31.39,25.32 31.39,26.03 32.4,27.03 32.4,31.49 34.14,33.24 35.29,33.24 36.25,34.19 41.99,34.19 43.55,35.75 45.12,37.32 46.56,37.32 48.95,39.71 51.99,39.71 52.42,39.28 53.81,39.28 54.84,38.25 58.19,38.25 58.46,37.98 60.31,37.98 60.87,37.41 121.05,37.41 121.19,37.55 126.28,37.55 127.18,36.65 v2(127.18,33.45) ; RC86.1 158.17,69 158.39,68.77 160.33,68.77 160.46,68.63 160.46,68.33 160.93,67.86 160.93,67.78 161.13,67.59 v1(161.76,67.59) 161.93,67.42 v2(161.93,66.74) 161.93,64.71 162.65,63.98 162.65,60.27 162.73,60.19 162.73,59.84 v2(162.29,59.41)
SUSACK#_R: length 11.5
  BOTTOM w0.076: 153.85,66.86 153.17,66.86 152.62,66.31 151.15,66.31 150.86,66.6 UC1.AK2
  BOTTOM w0.102: 153.85,66.86 153.86,66.86 154.05,66.67 154.99,66.67 155.49,67.17 155.49,67.48 v1(156.18,68.17) 157.84,69.82 158.57,69.82 RC86.2 159.93,69.32 RC82.2
SUSCLK: length 9.1
  TOP w0.102: T10.1 155.32,70.59 154.4,70.59 154.27,70.72 151.76,70.72 150.8,69.76 148.61,69.76 v2(148.26,69.41)
  BOTTOM w0.076: v2(148.26,69.41) 147.99,69.14 UC1.AE6
SW1: length 9.4
  IN4 w1.016: 190.09,58.14 190.09,53.52 193.45,50.16
  vias: v1(187.81,60.83) v2(188.32,60.36) v2(188.3,59.73) v2(188.3,59.09) v2(188.89,59.73) v2(188.89,59.09) v2(188.95,60.36) v2(189.47,59.84) v2(189.74,60.4) v2(189.76,59.31) v2(191.17,60.03) v2(191.17,59.4) v2(191.76,60.03) v2(191.76,59.4) v3(193.66,49.19) v3(194.3,49.19)
SW2: length 7.9
  IN1 w1.016: 200.41,50.14 200.41,53.47 202.03,55.09 202.03,57.35
  vias: v1(202.62,58.98) v2(199.33,59.49) v2(199.96,59.51) v2(201.09,61.24) v2(201.41,60.74) v2(201.41,60.11) v2(201.41,59.47) v2(201.41,58.84) v2(201.41,58.2) v2(202.04,60.11) v2(202.04,59.47) v2(202.04,58.84) v3(199.25,49.12) v3(199.89,49.12)
SW_1.35V: length 6.6
  IN4 w1.016: 112.14,12.01 112.12,12.04 105.56,12.04 105.54,12.01
  vias: v1(102.07,10.92) v3(102.54,9.65) v3(102.54,9.02) v3(103.18,9.65) v3(103.18,9.02) v3(103.84,9.65) v3(103.84,9.02) v3(103.86,12.06) v3(103.86,11.4) v3(104.52,12.06) v3(104.52,11.38) v3(104.47,9.65) v3(104.47,9.02) v3(105.11,9.65) v3(105.11,9.02) v3(105.74,9.65) v3(105.74,9.02) v3(113.45,11.73) v3(114.08,11.73)
SW_10_GRN#: length 19.3
  TOP w0.102: Q33.1 234.76,95.69 234.92,95.53 235.76,95.53 v2(235.92,95.68) v1(236.55,95.68)
  IN1 w0.084: v2(227.13,104.69) 227.57,105.13 228.76,105.13 232.61,101.28 232.61,97.34 234.27,95.68 v2(235.92,95.68)
  BOTTOM w0.102: U23.41 226.93,104.49 v2(227.13,104.69)
SW_100_ORG#: length 8.1
  TOP w0.102: v2(230.01,93.77) 230.01,92.77 230.35,92.43 230.79,92.43 231.02,92.66 Q32.4
  BOTTOM w0.102: U23.18 v1(227.43,92.9) 227.43,92.75 227.52,92.66 227.91,92.66 228,92.75 228,93.95 228.27,94.22 229.3,94.22 229.75,93.77 v2(230.01,93.77)
SW_+V1.05SP: length 5.8
  TOP w0.102: v2(227.51,76.75) 227.51,77.63 v1(227.64,77.76)
  IN1 w0.762: 228.23,74.18 229.9,72.52 232.23,72.52
  vias: v2(227.53,76.15) v2(227.53,75.51) v2(227.53,74.88) v2(228.14,77.38) v2(228.14,76.75) v2(228.17,76.15) v2(228.17,75.51) v2(228.17,74.88) v2(233.79,73.51) v2(234.24,73.89)
SW_ACTLED_YEL#: length 6.3
  TOP w0.102: Q32.1 232.32,95.34 232.18,95.48 230.75,95.48 230.59,95.33 v2(230.59,93.79)
  BOTTOM w0.102: v2(230.59,93.79) 230.08,94.31 v1(229.64,94.31) 229.36,94.59 U23.17
SW_DPB_AUX: length 8.9
  TOP w0.089: R47.1 203.19,78.75 203.13,78.75 202.91,78.97 202.42,78.97 v2(202.29,79.1) 202.15,78.97 201.98,78.97 201.59,79.36 201.15,79.36 200.59,79.92 199.82,79.92 199.5,79.6 U6.J13
  BOTTOM w0.089: v2(202.29,79.1) 201.82,79.1 201.35,79.58 v3(201.35,80.54) 201.35,82.13 C94.2
SW_DPB_AUX#: length 9
  TOP w0.089: 202.29,78.52 202.16,78.65 201.85,78.65 201.46,79.04 201.02,79.04 200.46,79.6 199.95,79.6 199.93,79.58 U6.J14 ; 202.29,78.52 202.41,78.65 202.78,78.65 203,78.43 203.19,78.43 R44.1 ; 202.29,78.52 v2(202.29,78.52)
  BOTTOM w0.089: v2(202.29,78.52) 202.02,78.78 201.69,78.78 201.03,79.45 201.03,81.75 C95.2
SW_DPB_AUX#_C: length 4.3
  BOTTOM w0.089: C95.1 200.84,83.49 v3(200.84,84.2) 200.84,84.56 201.22,84.94 201.48,84.94 202.02,85.47 U11.5
SW_DPB_AUX_C: length 4.3
  BOTTOM w0.089: C94.1 201.16,83.49 201.16,84.42 201.35,84.62 201.54,84.62 201.92,84.24 201.92,83.73 202.12,83.52 U11.2
SW_DPC_AUX: length 20.6
  TOP w0.089: U6.B11 198.3,84.49 198.3,85.1 198.93,85.74 v3(198.93,86.27) 198.93,86.56 199.24,86.86 199.24,87.17 v2(199.33,87.27) 199.5,87.43 199.5,89.05 R92.1
  BOTTOM w0.089: C98.2 186.42,89.77 187.53,89.77 189.36,87.94 190.6,87.94 191.21,88.55 198.41,88.55 199.19,87.77 199.19,87.41 v2(199.33,87.27)
SW_DPC_AUX#: length 21.1
  TOP w0.089: R91.1 198.69,89.26 199.06,89.26 199.18,89.13 199.18,87.7 v2(198.75,87.27) 198.92,87.09 198.92,86.99 198.62,86.69 198.62,85.87 197.98,85.24 197.98,84.82 U6.A11
  BOTTOM w0.089: C99.2 185.98,88.95 185.85,89.08 185.85,89.32 185.98,89.45 187.4,89.45 189.22,87.62 190.73,87.62 191.34,88.23 198.28,88.23 198.87,87.64 198.87,87.39 v2(198.75,87.27)
SW_DPC_AUX#_C: length 5
  BOTTOM w0.089: C99.1 184.73,89.59 184.41,89.59 183.31,88.49 v1(183.31,88.34) 183.31,88.24 183.5,88.05 183.95,88.05 184.15,87.84 U13.5
SW_DPC_AUX_C: length 5
  BOTTOM w0.089: C98.1 184.28,89.9 v3(184.07,89.69) 182.9,88.52 182.9,88.33 182.2,87.64 U13.2
SW_LAN_TX0+: length 45.4
  IN4 w0.084: v2(223.7,103.95) 223.58,104.07 223.58,104.24 223.74,104.39 224.68,104.39 227.38,101.7 232.28,101.7 238.55,95.43 240.71,95.43 243.28,92.86 243.28,89.56 243.99,88.85 249.02,88.85 249.63,88.24 253.11,88.24 253.9,87.45 253.9,86.73 v2(253.82,86.65)
  BOTTOM w0.089: v2(223.7,103.95) 223.57,103.82 223.57,103.13 224.17,102.53 224.32,102.53 224.39,102.59 U23.38 ; v2(253.82,86.65) 253.96,86.52 253.96,85.85 253.48,85.38 T94.6
SW_LAN_TX0-: length 47.2
  IN4 w0.084: v2(223.12,103.95) 223.2,104.04 223.2,104.34 223.64,104.77 224.84,104.77 227.53,102.08 232.44,102.08 238.71,95.81 240.87,95.81 243.66,93.02 243.66,89.72 244.15,89.23 249.18,89.23 249.79,88.62 253.27,88.62 254.28,87.61 254.28,86.78 v2(254.41,86.65)
  BOTTOM w0.089: v2(254.41,86.65) 254.27,86.52 254.27,85.69 254.75,85.22 T94.5 ; U23.37 224.39,102.09 224.27,102.21 224.04,102.21 223.25,103 223.25,103.82 v2(223.12,103.95)
SW_LAN_TX1+: length 49.3
  IN4 w0.084: v2(258.7,87.06) 258.83,86.93 258.83,86.29 258.57,86.03 253.68,86.03 252.15,87.55 249.21,87.55 248.57,88.19 243.75,88.19 242.62,89.32 242.62,92.69 240.49,94.82 237.95,94.82 232.21,100.56 223.21,100.56 v2(223.14,100.63)
  BOTTOM w0.089: v2(258.7,87.06) 258.81,86.95 258.81,85.79 258.56,85.53 T94.2 ; U23.34 224.29,100.59 224.2,100.5 223.27,100.5 v2(223.14,100.63)
SW_LAN_TX1-: length 50.1
  IN4 w0.084: v2(259.28,87.06) 259.21,86.98 259.21,86.13 258.72,85.65 253.52,85.65 251.99,87.17 249.05,87.17 248.41,87.81 243.59,87.81 242.24,89.16 242.24,92.53 240.33,94.44 237.79,94.44 232.05,100.18 223.27,100.18 v2(223.14,100.05)
  BOTTOM w0.089: v2(259.28,87.06) 259.13,86.91 259.13,85.86 259.83,85.17 T94.1 ; v2(223.14,100.05) 223.27,100.18 224.2,100.18 224.29,100.09 U23.33
SW_LAN_TX2+: length 38.6
  IN4 w0.084: v2(248.2,87.2) 248.12,87.12 243.44,87.12 241.65,88.92 241.65,92.28 240.1,93.83 237.19,93.83 232.05,98.97 230.56,98.97 230.29,98.7 225.43,98.7 224.79,98.07 223.18,98.07 v2(223.1,98.15)
  BOTTOM w0.089: v2(223.1,98.15) 223.23,98.02 224.2,98.02 224.27,98.09 U23.29 ; v2(248.2,87.2) 248.06,87.07 247.12,87.07 246.34,86.29 246.34,85.8 245.86,85.32 T94.12
SW_LAN_TX2-: length 38.1
  IN4 w0.084: v2(248.2,86.62) 248.08,86.74 243.28,86.74 241.26,88.76 241.26,92.12 239.94,93.45 237.03,93.45 231.89,98.59 230.71,98.59 230.45,98.32 225.58,98.32 224.95,97.69 223.22,97.69 v2(223.1,97.57)
  BOTTOM w0.089: T94.11 247.13,85.29 246.65,85.77 246.65,86.16 247.25,86.75 248.06,86.75 v2(248.2,86.62) ; U23.28 224.32,97.59 224.21,97.7 223.23,97.7 v2(223.1,97.57)
SW_LAN_TX3+: length 42.4
  IN4 w0.084: v2(222.29,95.83) 222.38,95.74 222.83,95.74 223.21,96.13 224.56,96.13 225.13,95.55 226.46,95.55 228.02,97.12 229.95,97.12 231.39,95.68 233.5,95.68 236.39,92.79 239.77,92.79 240.67,91.88 240.67,88.51 243.18,86 251.12,86 251.23,86.11 251.23,86.58 v2(251.16,86.65)
  BOTTOM w0.089: T94.8 250.94,85.83 251.29,86.18 251.29,86.52 v2(251.16,86.65) ; U23.25 224.36,96.09 224.3,96.02 223.25,96.02 222.93,95.7 222.42,95.7 v2(222.29,95.83)
SW_LAN_TX3-: length 43.3
  IN4 w0.084: v2(222.29,95.25) 222.29,95.29 222.36,95.36 222.99,95.36 223.37,95.74 224.4,95.74 224.98,95.17 226.62,95.17 228.18,96.74 229.79,96.74 231.23,95.3 233.34,95.3 236.24,92.4 239.61,92.4 240.29,91.72 240.29,88.35 243.02,85.62 251.28,85.62 251.61,85.95 251.61,86.53 v2(251.74,86.65)
  BOTTOM w0.089: T94.7 252.21,85.83 251.61,86.43 251.61,86.52 v2(251.74,86.65) ; v2(222.29,95.25) 222.42,95.38 223.06,95.38 223.38,95.71 224.22,95.71 224.33,95.59 U23.24
SW_MDP_AUX#_C: length 1.5
  TOP w0.089: C175.1 U49.5
SW_MDP_AUX_C: length 1.5
  TOP w0.089: U49.2 C174.1
SW_USB3RN3: length 53.6
  TOP w0.102: U33.26 165.54,101.23 165.62,101.15 165.62,96.75 168.34,94.03 172.92,94.03 175.72,91.24 175.72,90.47 v2(175.53,90.28) ; R235.1 204.77,95.36 L37.4 204.01,95.36 203.87,95.22 203.87,94.87 203.78,94.77 202.67,94.77 200.2,92.3 v3(199.16,92.3) 197.16,92.3 196.86,92.6 195.7,92.6 195.62,92.67 v2(195.62,93.31)
  IN1 w0.091: v2(195.62,93.31) 195.42,93.51 195.42,93.69 195.14,93.96 192.73,93.96 192.13,94.56 189.33,94.56 187.39,92.62 186.28,92.62 185.63,91.97 185.63,91.23 185.29,90.89 175.98,90.89 175.74,90.65 175.74,90.46 175.56,90.28 v2(175.53,90.28)
SW_USB3RP3: length 53.1
  TOP w0.102: v2(176.12,90.28) 175.93,90.47 175.93,91.33 173.01,94.25 168.43,94.25 165.84,96.84 165.84,101.12 165.94,101.23 U33.27 ; R236.1 204.86,94.56 L37.1 202.76,94.56 200.29,92.09 199.67,92.09 199.64,92.06 198.77,92.06 198.74,92.09 197.07,92.09 196.77,92.38 195.61,92.38 195.4,92.58 195.4,92.94 v2(195.04,93.31)
  IN1 w0.091: v2(195.04,93.31) 195.24,93.51 195.24,93.62 195.07,93.79 192.65,93.79 192.06,94.39 189.4,94.39 187.46,92.45 186.35,92.45 185.8,91.9 185.8,91.16 185.36,90.72 176.05,90.72 175.92,90.58 175.92,90.46 176.1,90.28 v2(176.12,90.28)
SW_USB3TN3: length 50.3
  TOP w0.102: v2(186.35,91.56) 186.53,91.74 186.53,92.5 186.86,92.82 194.48,92.82 195.4,91.9 196.14,91.9 196.46,91.58 200.47,91.58 201.88,93 202.04,93 202.38,93.33 C282.2 ; v2(178.42,89.93) 178.6,90.11 178.6,90.74 174.56,94.78 169.18,94.78 168.52,95.44 168.52,100.76 168.05,101.23 168.05,103.57 167.79,103.83 167.69,103.83 167.6,103.73 U33.30
  BOTTOM w0.102: v2(186.35,91.56) 186.53,91.37 186.53,91.23 186.15,90.84 181.01,90.84 180.68,91.17 179.2,91.17 178.6,90.58 178.6,90.11 v2(178.42,89.93)
SW_USB3TN3_C: length 2
  TOP w0.102: C282.1 203.63,93 204.07,93 204.39,93.31 204.88,93.31 R237.1
SW_USB3TP3: length 50.3
  TOP w0.102: v2(179,89.93) 178.82,90.11 178.82,90.83 174.65,95 169.27,95 168.73,95.53 168.73,100.85 168.26,101.32 168.26,103.66 167.88,104.04 167.69,104.04 167.6,104.13 U33.31 ; v2(186.93,91.56) 186.75,91.74 186.75,92.41 186.94,92.61 194.39,92.61 195.31,91.68 196.05,91.68 196.37,91.36 200.56,91.36 201.97,92.78 202.04,92.78 202.37,92.44 C283.2
  BOTTOM w0.102: v2(179,89.93) 178.82,90.11 178.82,90.49 179.29,90.96 180.59,90.96 180.92,90.63 186.24,90.63 186.75,91.14 186.75,91.37 v2(186.93,91.56)
SW_USB3TP3_C: length 2.1
  TOP w0.102: C283.1 203.63,92.78 204.04,92.78 204.36,92.46 L38.1 204.86,92.46 R239.1
SW_USBP0+: length 8.1
  TOP w0.102: v2(78.33,84.36) 78.22,84.25 78.22,83.86 78.3,83.78 U36.1 ; v2(73.41,83.79) 73.4,83.81 U39.6
  IN1 w0.091: v2(73.41,83.79) 73.41,84.28 73.41,84.28 73.41,84.49 73.58,84.67 74.72,84.67 74.99,84.93 77.93,84.93 78.12,84.74 78.12,84.56 v2(78.33,84.36)
SW_USBP0-: length 8.1
  TOP w0.102: v2(77.74,84.36) 78,84.09 78,84.02 77.77,83.79 U36.2 ; U39.7 73.9,84.62 73.61,84.33 73.61,84.17 v2(74,83.79)
  IN1 w0.091: v2(77.74,84.36) 77.95,84.56 77.95,84.67 77.86,84.76 75.06,84.76 74.79,84.49 73.66,84.49 73.59,84.42 73.59,84.35 73.59,84.24 74,83.83 v2(74,83.79)
SW_USBP5+: length 48.6
  TOP w0.102: v2(162.71,101.11) 162.53,101.29 162.53,101.43 162.74,101.64 U33.19
  BOTTOM w0.102: v2(162.71,101.11) 162.51,100.91 162.51,100.77 163.02,100.27 165.69,100.27 169.57,96.38 182.63,96.38 182.68,96.43 187.5,96.43 188.67,95.26 188.67,91.29 190.1,89.86 190.5,89.86 190.59,89.95 199.71,89.95 199.72,89.97 200.44,89.97 200.46,89.95 201.59,89.95 201.7,90.06 201.7,90.19 202.02,90.51 L39.1
SW_USBP5-: length 48.6
  TOP w0.102: v2(162.13,101.11) 162.31,101.29 162.31,101.51 162.34,101.55 U33.18
  BOTTOM w0.102: L39.4 202.02,89.66 201.93,89.74 201.73,89.74 201.73,89.74 v3(200.1,89.74) 190.68,89.74 190.59,89.65 190.01,89.65 188.46,91.2 188.46,95.17 187.41,96.21 182.77,96.21 182.72,96.16 169.48,96.16 165.6,100.05 162.93,100.05 162.29,100.69 162.29,100.94 v2(162.13,101.11)
SYS_LED_MASK#: length 266.8
  TOP w0.102: U37.B48 17.68,38.8 17.93,38.54 17.93,38.15 17.64,37.86 v2(17.64,37.5) ; v2(12.51,40.84) 13.06,41.39 U47.1
  IN1 w0.084: v2(12.51,40.84) 12.48,40.81 12.48,40.57 10.9,38.98 10.9,36.37 10.15,35.62 v2(9.42,35.62)
  IN2 w0.122: v2(17.64,37.5) 17.64,36.94 17.4,36.7 14.63,36.7 14.36,36.97 13.89,36.97 13.63,36.7 11.9,36.7 11.05,35.85 9.65,35.85 v2(9.42,35.62)
  IN3 w0.122: v2(17.64,37.5) 18.12,37.99 18.12,38.53 18.46,38.87 20.26,38.87 20.7,39.31 24.59,39.31 25.67,40.39 27.45,40.39 30.31,43.25 34.01,43.25 35.55,44.79 35.55,45.96 37.73,48.15 47.89,48.15 48.41,47.63 54.3,47.63 56.02,49.35 56.02,51.97 57.11,53.06 57.11,55.38 55.59,56.9 55.59,63.97 58.7,67.08 58.7,68.27 57.74,69.23 57.74,72.89 58.76,73.91 58.76,80.91 62.37,84.52 64.97,87.12 69.7,87.12 75.13,92.56 77.67,92.56 79.43,94.32 94.89,94.32 97.32,96.76 100.1,96.76 102.93,99.59 109.72,99.59 110.06,99.93 112.15,99.93 115.24,103.02 115.24,104.24 118.11,107.11 146.65,107.11 148.1,105.66 148.1,104.03 153.87,98.26 160.81,98.26 161.75,97.32 166.9,97.32 169.62,94.6 180.02,94.6 180.55,95.13 181.89,95.13 185.47,98.71 195.44,98.71 196.03,99.3 197.69,99.3 v2(198,98.99)
  BOTTOM w0.102: R310.2 17.41,39.09 17.87,38.63 17.87,37.73 v2(17.64,37.5) ; Q25.5 199.57,95.57 v1(198.53,96.61) 198.3,96.84 198.3,98.69 v2(198,98.99)
SYS_PWROK: length 247.5
  TOP w0.102: v2(16.24,36.15) 16.11,36.02 U37.B57 ; v2(71.21,60.93) 70.71,61.44 RC110.1 ; v2(47.43,36.41) 47.43,36.04 48.89,34.58 49.39,34.58 v1(51.08,32.9) 51.08,29.06 v2(51.26,28.88)
  IN2 w0.122: v2(51.26,28.88) 52.33,28.88 54.32,30.87 55.24,30.87 56.05,31.67 61.98,31.67 63.28,32.98 124.41,32.98 127.05,30.33 128.53,30.33 130.45,32.25 133.4,32.25 134.23,33.08 149.67,33.08 166.67,50.08 166.67,55.56 166.23,56 166.23,58.32 165.23,59.32 165.23,59.64 165.47,59.88 165.47,60.67 164.57,61.57 164.57,62.43 164.69,62.56 164.69,63.73 164.52,63.91 164.52,64.64 163.6,65.56 163.6,66.78 162.7,67.68 162.7,68.67 161.8,69.57 v2(161.8,71.48)
  IN4 w0.084: v2(51.26,28.88) 51.26,28.99 52.31,30.05 52.31,33.97 56.07,37.73 56.08,37.73 58.96,40.6 59.85,40.6 67.23,47.97 67.23,60.24 67.92,60.93 v2(71.21,60.93) ; v2(16.24,36.15) 16.24,36.42 16.38,36.56 17.69,36.56 18.17,37.04 22.43,37.04 22.85,36.63 26.06,36.63 26.59,36.09 29,36.09 29.68,36.77 32.7,36.77 36.97,41.05 39.83,41.05 42.22,38.66 45.18,38.66 v2(47.43,36.41)
  BOTTOM w0.102: RC87.1 155.12,70.28 156.12,71.28 161.61,71.28 v2(161.8,71.48)
SYS_PWROK_R: length 6
  BOTTOM w0.076: 153.85,69.02 153.82,69.02 v5(153.73,68.93) 153.48,68.68 152.79,68.68 152.66,68.55 151.66,68.55 151.51,68.39 151.15,68.39 150.86,68.1 UC1.AG2
  BOTTOM w0.102: 153.85,69.02 154.46,69.02 RC87.2 RC84.2
SYS_PWROK_XDP: length 4.7
  TOP w0.102: JXDP1.47 68.01,61.13 68.31,61.44 v1(68.69,61.44) RC110.2 CC48.1 RC102.1
SYS_RESET#: length 213.2
  TOP w0.102: UC2.4 171.07,74.5 171.35,74.22 171.88,74.22 172.17,73.93 172.17,73.05 171.76,72.63 v2(171.76,72.29) ; JAPS1.13 34.57,44.56 34.57,46.89 39.43,51.75 43.1,51.75 43.85,51.01 46.17,51.01 46.56,50.62 48.46,50.62 49.47,51.62 49.85,51.62 50.22,51.25 54.86,51.25 56.16,49.95 56.16,45.67 55.55,45.06 55.55,43.29 57.24,41.6 v5(57.24,40.68) v2(57.24,36.57) ; v2(165.21,71.79) 165.28,71.79 167.26,73.77 RC72.2
  IN1 w0.084: v2(153.78,71.45) 153.78,71.5 154.77,72.49 159.18,72.49 159.51,72.81 162.99,72.81 164.01,71.79 v2(165.21,71.79)
  IN2 w0.089: v2(153.78,71.45) 153.85,71.39
  IN2 w0.122: v2(57.24,36.57) 57.24,34.99 57.6,34.63 61.03,34.63 62.49,36.09 145.71,36.09 145.73,36.11 156.52,46.9 160.41,50.78 160.41,53.78 159.42,54.77 156.85,54.77 155.5,56.12 155.5,60.61 155.08,61.03 155.08,63.41 157.52,65.85 157.52,67.37 156.55,68.34 156.55,68.6 155.9,69.25 155.44,69.25 154.19,70.5 154.19,71.05 153.85,71.39
  IN4 w0.084: v2(171.76,72.29) 170.59,71.12 166.55,71.12 165.87,71.79 v2(165.21,71.79)
  BOTTOM w0.076: v2(153.78,71.45) 153.21,70.87 152.11,70.87 151.74,70.51 151.52,70.51 151.4,70.64 151.15,70.64 150.98,70.47 150.98,70.29 150.75,70.06 150.23,70.06 UC1.AC3
